bioz netlist
r_1_2_e 1 2 13376.4
r_1_2_i 1_2 2 93218.1
c_1_2_i 1 1_2 2.08965e-09
r_561_562_e 561 562 13376.4
r_561_562_i 561_562 562 93218.1
c_561_562_i 561 561_562 2.08965e-09
r_1121_1122_e 1121 1122 13376.4
r_1121_1122_i 1121_1122 1122 93218.1
c_1121_1122_i 1121 1121_1122 2.08965e-09
r_1681_1682_e 1681 1682 13376.4
r_1681_1682_i 1681_1682 1682 93218.1
c_1681_1682_i 1681 1681_1682 2.08965e-09
r_2241_2242_e 2241 2242 13376.4
r_2241_2242_i 2241_2242 2242 93218.1
c_2241_2242_i 2241 2241_2242 2.08965e-09
r_2801_2802_e 2801 2802 13376.4
r_2801_2802_i 2801_2802 2802 93218.1
c_2801_2802_i 2801 2801_2802 2.08965e-09
r_3361_3362_e 3361 3362 13376.4
r_3361_3362_i 3361_3362 3362 93218.1
c_3361_3362_i 3361 3361_3362 2.08965e-09
r_2_3_e 2 3 13376.4
r_2_3_i 2_3 3 93218.1
c_2_3_i 2 2_3 2.08965e-09
r_562_563_e 562 563 13376.4
r_562_563_i 562_563 563 93218.1
c_562_563_i 562 562_563 2.08965e-09
r_1122_1123_e 1122 1123 13376.4
r_1122_1123_i 1122_1123 1123 93218.1
c_1122_1123_i 1122 1122_1123 2.08965e-09
r_1682_1683_e 1682 1683 13376.4
r_1682_1683_i 1682_1683 1683 93218.1
c_1682_1683_i 1682 1682_1683 2.08965e-09
r_2242_2243_e 2242 2243 13376.4
r_2242_2243_i 2242_2243 2243 93218.1
c_2242_2243_i 2242 2242_2243 2.08965e-09
r_2802_2803_e 2802 2803 13376.4
r_2802_2803_i 2802_2803 2803 93218.1
c_2802_2803_i 2802 2802_2803 2.08965e-09
r_3362_3363_e 3362 3363 13376.4
r_3362_3363_i 3362_3363 3363 93218.1
c_3362_3363_i 3362 3362_3363 2.08965e-09
r_3_4_e 3 4 13376.4
r_3_4_i 3_4 4 93218.1
c_3_4_i 3 3_4 2.08965e-09
r_563_564_e 563 564 13376.4
r_563_564_i 563_564 564 93218.1
c_563_564_i 563 563_564 2.08965e-09
r_1123_1124_e 1123 1124 836.944
r_1123_1124_i 1123_1124 1124 4256.89
c_1123_1124_i 1123 1123_1124 4.67522e-10
r_1683_1684_e 1683 1684 836.944
r_1683_1684_i 1683_1684 1684 4256.89
c_1683_1684_i 1683 1683_1684 4.67522e-10
r_2243_2244_e 2243 2244 836.944
r_2243_2244_i 2243_2244 2244 4256.89
c_2243_2244_i 2243 2243_2244 4.67522e-10
r_2803_2804_e 2803 2804 836.944
r_2803_2804_i 2803_2804 2804 4256.89
c_2803_2804_i 2803 2803_2804 4.67522e-10
r_3363_3364_e 3363 3364 836.944
r_3363_3364_i 3363_3364 3364 4256.89
c_3363_3364_i 3363 3363_3364 4.67522e-10
r_4_5_e 4 5 13376.4
r_4_5_i 4_5 5 93218.1
c_4_5_i 4 4_5 2.08965e-09
r_564_565_e 564 565 13376.4
r_564_565_i 564_565 565 93218.1
c_564_565_i 564 564_565 2.08965e-09
r_1124_1125_e 1124 1125 836.944
r_1124_1125_i 1124_1125 1125 4256.89
c_1124_1125_i 1124 1124_1125 4.67522e-10
r_1684_1685_e 1684 1685 836.944
r_1684_1685_i 1684_1685 1685 4256.89
c_1684_1685_i 1684 1684_1685 4.67522e-10
r_2244_2245_e 2244 2245 836.944
r_2244_2245_i 2244_2245 2245 4256.89
c_2244_2245_i 2244 2244_2245 4.67522e-10
r_2804_2805_e 2804 2805 13758.3
r_2804_2805_i 2804_2805 2805 95645.6
c_2804_2805_i 2804 2804_2805 9.36084e-12
r_3364_3365_e 3364 3365 13758.3
r_3364_3365_i 3364_3365 3365 95645.6
c_3364_3365_i 3364 3364_3365 9.36084e-12
r_5_6_e 5 6 13376.4
r_5_6_i 5_6 6 93218.1
c_5_6_i 5 5_6 2.08965e-09
r_565_566_e 565 566 13376.4
r_565_566_i 565_566 566 93218.1
c_565_566_i 565 565_566 2.08965e-09
r_1125_1126_e 1125 1126 836.944
r_1125_1126_i 1125_1126 1126 4256.89
c_1125_1126_i 1125 1125_1126 4.67522e-10
r_1685_1686_e 1685 1686 836.944
r_1685_1686_i 1685_1686 1686 4256.89
c_1685_1686_i 1685 1685_1686 4.67522e-10
r_2245_2246_e 2245 2246 836.944
r_2245_2246_i 2245_2246 2246 4256.89
c_2245_2246_i 2245 2245_2246 4.67522e-10
r_2805_2806_e 2805 2806 13758.3
r_2805_2806_i 2805_2806 2806 95645.6
c_2805_2806_i 2805 2805_2806 9.36084e-12
r_3365_3366_e 3365 3366 13758.3
r_3365_3366_i 3365_3366 3366 95645.6
c_3365_3366_i 3365 3365_3366 9.36084e-12
r_6_7_e 6 7 13376.4
r_6_7_i 6_7 7 93218.1
c_6_7_i 6 6_7 2.08965e-09
r_566_567_e 566 567 13376.4
r_566_567_i 566_567 567 93218.1
c_566_567_i 566 566_567 2.08965e-09
r_1126_1127_e 1126 1127 836.944
r_1126_1127_i 1126_1127 1127 4256.89
c_1126_1127_i 1126 1126_1127 4.67522e-10
r_1686_1687_e 1686 1687 836.944
r_1686_1687_i 1686_1687 1687 4256.89
c_1686_1687_i 1686 1686_1687 4.67522e-10
r_2246_2247_e 2246 2247 836.944
r_2246_2247_i 2246_2247 2247 4256.89
c_2246_2247_i 2246 2246_2247 4.67522e-10
r_2806_2807_e 2806 2807 13758.3
r_2806_2807_i 2806_2807 2807 95645.6
c_2806_2807_i 2806 2806_2807 9.36084e-12
r_3366_3367_e 3366 3367 13758.3
r_3366_3367_i 3366_3367 3367 95645.6
c_3366_3367_i 3366 3366_3367 9.36084e-12
r_7_8_e 7 8 13376.4
r_7_8_i 7_8 8 93218.1
c_7_8_i 7 7_8 2.08965e-09
r_567_568_e 567 568 13376.4
r_567_568_i 567_568 568 93218.1
c_567_568_i 567 567_568 2.08965e-09
r_1127_1128_e 1127 1128 836.944
r_1127_1128_i 1127_1128 1128 4256.89
c_1127_1128_i 1127 1127_1128 4.67522e-10
r_1687_1688_e 1687 1688 836.944
r_1687_1688_i 1687_1688 1688 4256.89
c_1687_1688_i 1687 1687_1688 4.67522e-10
r_2247_2248_e 2247 2248 836.944
r_2247_2248_i 2247_2248 2248 4256.89
c_2247_2248_i 2247 2247_2248 4.67522e-10
r_2807_2808_e 2807 2808 13758.3
r_2807_2808_i 2807_2808 2808 95645.6
c_2807_2808_i 2807 2807_2808 9.36084e-12
r_3367_3368_e 3367 3368 13758.3
r_3367_3368_i 3367_3368 3368 95645.6
c_3367_3368_i 3367 3367_3368 9.36084e-12
r_8_9_e 8 9 13376.4
r_8_9_i 8_9 9 93218.1
c_8_9_i 8 8_9 2.08965e-09
r_568_569_e 568 569 13376.4
r_568_569_i 568_569 569 93218.1
c_568_569_i 568 568_569 2.08965e-09
r_1128_1129_e 1128 1129 836.944
r_1128_1129_i 1128_1129 1129 4256.89
c_1128_1129_i 1128 1128_1129 4.67522e-10
r_1688_1689_e 1688 1689 836.944
r_1688_1689_i 1688_1689 1689 4256.89
c_1688_1689_i 1688 1688_1689 4.67522e-10
r_2248_2249_e 2248 2249 836.944
r_2248_2249_i 2248_2249 2249 4256.89
c_2248_2249_i 2248 2248_2249 4.67522e-10
r_2808_2809_e 2808 2809 13758.3
r_2808_2809_i 2808_2809 2809 95645.6
c_2808_2809_i 2808 2808_2809 9.36084e-12
r_3368_3369_e 3368 3369 13758.3
r_3368_3369_i 3368_3369 3369 95645.6
c_3368_3369_i 3368 3368_3369 9.36084e-12
r_9_10_e 9 10 13376.4
r_9_10_i 9_10 10 93218.1
c_9_10_i 9 9_10 2.08965e-09
r_569_570_e 569 570 13376.4
r_569_570_i 569_570 570 93218.1
c_569_570_i 569 569_570 2.08965e-09
r_1129_1130_e 1129 1130 836.944
r_1129_1130_i 1129_1130 1130 4256.89
c_1129_1130_i 1129 1129_1130 4.67522e-10
r_1689_1690_e 1689 1690 836.944
r_1689_1690_i 1689_1690 1690 4256.89
c_1689_1690_i 1689 1689_1690 4.67522e-10
r_2249_2250_e 2249 2250 836.944
r_2249_2250_i 2249_2250 2250 4256.89
c_2249_2250_i 2249 2249_2250 4.67522e-10
r_2809_2810_e 2809 2810 13758.3
r_2809_2810_i 2809_2810 2810 95645.6
c_2809_2810_i 2809 2809_2810 9.36084e-12
r_3369_3370_e 3369 3370 13758.3
r_3369_3370_i 3369_3370 3370 95645.6
c_3369_3370_i 3369 3369_3370 9.36084e-12
r_10_11_e 10 11 13376.4
r_10_11_i 10_11 11 93218.1
c_10_11_i 10 10_11 2.08965e-09
r_570_571_e 570 571 13376.4
r_570_571_i 570_571 571 93218.1
c_570_571_i 570 570_571 2.08965e-09
r_1130_1131_e 1130 1131 836.944
r_1130_1131_i 1130_1131 1131 4256.89
c_1130_1131_i 1130 1130_1131 4.67522e-10
r_1690_1691_e 1690 1691 836.944
r_1690_1691_i 1690_1691 1691 4256.89
c_1690_1691_i 1690 1690_1691 4.67522e-10
r_2250_2251_e 2250 2251 836.944
r_2250_2251_i 2250_2251 2251 4256.89
c_2250_2251_i 2250 2250_2251 4.67522e-10
r_2810_2811_e 2810 2811 13758.3
r_2810_2811_i 2810_2811 2811 95645.6
c_2810_2811_i 2810 2810_2811 9.36084e-12
r_3370_3371_e 3370 3371 13758.3
r_3370_3371_i 3370_3371 3371 95645.6
c_3370_3371_i 3370 3370_3371 9.36084e-12
r_11_12_e 11 12 13376.4
r_11_12_i 11_12 12 93218.1
c_11_12_i 11 11_12 2.08965e-09
r_571_572_e 571 572 13376.4
r_571_572_i 571_572 572 93218.1
c_571_572_i 571 571_572 2.08965e-09
r_1131_1132_e 1131 1132 396.769
r_1131_1132_i 1131_1132 1132 1005.45
c_1131_1132_i 1131 1131_1132 1.65766e-10
r_1691_1692_e 1691 1692 396.769
r_1691_1692_i 1691_1692 1692 1005.45
c_1691_1692_i 1691 1691_1692 1.65766e-10
r_2251_2252_e 2251 2252 836.944
r_2251_2252_i 2251_2252 2252 4256.89
c_2251_2252_i 2251 2251_2252 4.67522e-10
r_2811_2812_e 2811 2812 13758.3
r_2811_2812_i 2811_2812 2812 95645.6
c_2811_2812_i 2811 2811_2812 9.36084e-12
r_3371_3372_e 3371 3372 13758.3
r_3371_3372_i 3371_3372 3372 95645.6
c_3371_3372_i 3371 3371_3372 9.36084e-12
r_12_13_e 12 13 13376.4
r_12_13_i 12_13 13 93218.1
c_12_13_i 12 12_13 2.08965e-09
r_572_573_e 572 573 13376.4
r_572_573_i 572_573 573 93218.1
c_572_573_i 572 572_573 2.08965e-09
r_1132_1133_e 1132 1133 836.944
r_1132_1133_i 1132_1133 1133 4256.89
c_1132_1133_i 1132 1132_1133 4.67522e-10
r_1692_1693_e 1692 1693 836.944
r_1692_1693_i 1692_1693 1693 4256.89
c_1692_1693_i 1692 1692_1693 4.67522e-10
r_2252_2253_e 2252 2253 836.944
r_2252_2253_i 2252_2253 2253 4256.89
c_2252_2253_i 2252 2252_2253 4.67522e-10
r_2812_2813_e 2812 2813 13758.3
r_2812_2813_i 2812_2813 2813 95645.6
c_2812_2813_i 2812 2812_2813 9.36084e-12
r_3372_3373_e 3372 3373 13758.3
r_3372_3373_i 3372_3373 3373 95645.6
c_3372_3373_i 3372 3372_3373 9.36084e-12
r_13_14_e 13 14 13376.4
r_13_14_i 13_14 14 93218.1
c_13_14_i 13 13_14 2.08965e-09
r_573_574_e 573 574 13376.4
r_573_574_i 573_574 574 93218.1
c_573_574_i 573 573_574 2.08965e-09
r_1133_1134_e 1133 1134 836.944
r_1133_1134_i 1133_1134 1134 4256.89
c_1133_1134_i 1133 1133_1134 4.67522e-10
r_1693_1694_e 1693 1694 836.944
r_1693_1694_i 1693_1694 1694 4256.89
c_1693_1694_i 1693 1693_1694 4.67522e-10
r_2253_2254_e 2253 2254 836.944
r_2253_2254_i 2253_2254 2254 4256.89
c_2253_2254_i 2253 2253_2254 4.67522e-10
r_2813_2814_e 2813 2814 13758.3
r_2813_2814_i 2813_2814 2814 95645.6
c_2813_2814_i 2813 2813_2814 9.36084e-12
r_3373_3374_e 3373 3374 13758.3
r_3373_3374_i 3373_3374 3374 95645.6
c_3373_3374_i 3373 3373_3374 9.36084e-12
r_14_15_e 14 15 13376.4
r_14_15_i 14_15 15 93218.1
c_14_15_i 14 14_15 2.08965e-09
r_574_575_e 574 575 13376.4
r_574_575_i 574_575 575 93218.1
c_574_575_i 574 574_575 2.08965e-09
r_1134_1135_e 1134 1135 836.944
r_1134_1135_i 1134_1135 1135 4256.89
c_1134_1135_i 1134 1134_1135 4.67522e-10
r_1694_1695_e 1694 1695 836.944
r_1694_1695_i 1694_1695 1695 4256.89
c_1694_1695_i 1694 1694_1695 4.67522e-10
r_2254_2255_e 2254 2255 836.944
r_2254_2255_i 2254_2255 2255 4256.89
c_2254_2255_i 2254 2254_2255 4.67522e-10
r_2814_2815_e 2814 2815 13758.3
r_2814_2815_i 2814_2815 2815 95645.6
c_2814_2815_i 2814 2814_2815 9.36084e-12
r_3374_3375_e 3374 3375 13758.3
r_3374_3375_i 3374_3375 3375 95645.6
c_3374_3375_i 3374 3374_3375 9.36084e-12
r_15_16_e 15 16 13376.4
r_15_16_i 15_16 16 93218.1
c_15_16_i 15 15_16 2.08965e-09
r_575_576_e 575 576 13376.4
r_575_576_i 575_576 576 93218.1
c_575_576_i 575 575_576 2.08965e-09
r_1135_1136_e 1135 1136 836.944
r_1135_1136_i 1135_1136 1136 4256.89
c_1135_1136_i 1135 1135_1136 4.67522e-10
r_1695_1696_e 1695 1696 836.944
r_1695_1696_i 1695_1696 1696 4256.89
c_1695_1696_i 1695 1695_1696 4.67522e-10
r_2255_2256_e 2255 2256 836.944
r_2255_2256_i 2255_2256 2256 4256.89
c_2255_2256_i 2255 2255_2256 4.67522e-10
r_2815_2816_e 2815 2816 13758.3
r_2815_2816_i 2815_2816 2816 95645.6
c_2815_2816_i 2815 2815_2816 9.36084e-12
r_3375_3376_e 3375 3376 13758.3
r_3375_3376_i 3375_3376 3376 95645.6
c_3375_3376_i 3375 3375_3376 9.36084e-12
r_17_18_e 17 18 13376.4
r_17_18_i 17_18 18 93218.1
c_17_18_i 17 17_18 2.08965e-09
r_577_578_e 577 578 13376.4
r_577_578_i 577_578 578 93218.1
c_577_578_i 577 577_578 2.08965e-09
r_1137_1138_e 1137 1138 13376.4
r_1137_1138_i 1137_1138 1138 93218.1
c_1137_1138_i 1137 1137_1138 2.08965e-09
r_1697_1698_e 1697 1698 13376.4
r_1697_1698_i 1697_1698 1698 93218.1
c_1697_1698_i 1697 1697_1698 2.08965e-09
r_2257_2258_e 2257 2258 13376.4
r_2257_2258_i 2257_2258 2258 93218.1
c_2257_2258_i 2257 2257_2258 2.08965e-09
r_2817_2818_e 2817 2818 13376.4
r_2817_2818_i 2817_2818 2818 93218.1
c_2817_2818_i 2817 2817_2818 2.08965e-09
r_3377_3378_e 3377 3378 13376.4
r_3377_3378_i 3377_3378 3378 93218.1
c_3377_3378_i 3377 3377_3378 2.08965e-09
r_18_19_e 18 19 13376.4
r_18_19_i 18_19 19 93218.1
c_18_19_i 18 18_19 2.08965e-09
r_578_579_e 578 579 13376.4
r_578_579_i 578_579 579 93218.1
c_578_579_i 578 578_579 2.08965e-09
r_1138_1139_e 1138 1139 13376.4
r_1138_1139_i 1138_1139 1139 93218.1
c_1138_1139_i 1138 1138_1139 2.08965e-09
r_1698_1699_e 1698 1699 13376.4
r_1698_1699_i 1698_1699 1699 93218.1
c_1698_1699_i 1698 1698_1699 2.08965e-09
r_2258_2259_e 2258 2259 13376.4
r_2258_2259_i 2258_2259 2259 93218.1
c_2258_2259_i 2258 2258_2259 2.08965e-09
r_2818_2819_e 2818 2819 13376.4
r_2818_2819_i 2818_2819 2819 93218.1
c_2818_2819_i 2818 2818_2819 2.08965e-09
r_3378_3379_e 3378 3379 13376.4
r_3378_3379_i 3378_3379 3379 93218.1
c_3378_3379_i 3378 3378_3379 2.08965e-09
r_19_20_e 19 20 13376.4
r_19_20_i 19_20 20 93218.1
c_19_20_i 19 19_20 2.08965e-09
r_579_580_e 579 580 13376.4
r_579_580_i 579_580 580 93218.1
c_579_580_i 579 579_580 2.08965e-09
r_1139_1140_e 1139 1140 836.944
r_1139_1140_i 1139_1140 1140 4256.89
c_1139_1140_i 1139 1139_1140 4.67522e-10
r_1699_1700_e 1699 1700 836.944
r_1699_1700_i 1699_1700 1700 4256.89
c_1699_1700_i 1699 1699_1700 4.67522e-10
r_2259_2260_e 2259 2260 836.944
r_2259_2260_i 2259_2260 2260 4256.89
c_2259_2260_i 2259 2259_2260 4.67522e-10
r_2819_2820_e 2819 2820 836.944
r_2819_2820_i 2819_2820 2820 4256.89
c_2819_2820_i 2819 2819_2820 4.67522e-10
r_3379_3380_e 3379 3380 836.944
r_3379_3380_i 3379_3380 3380 4256.89
c_3379_3380_i 3379 3379_3380 4.67522e-10
r_20_21_e 20 21 13376.4
r_20_21_i 20_21 21 93218.1
c_20_21_i 20 20_21 2.08965e-09
r_580_581_e 580 581 13376.4
r_580_581_i 580_581 581 93218.1
c_580_581_i 580 580_581 2.08965e-09
r_1140_1141_e 1140 1141 836.944
r_1140_1141_i 1140_1141 1141 4256.89
c_1140_1141_i 1140 1140_1141 4.67522e-10
r_1700_1701_e 1700 1701 836.944
r_1700_1701_i 1700_1701 1701 4256.89
c_1700_1701_i 1700 1700_1701 4.67522e-10
r_2260_2261_e 2260 2261 836.944
r_2260_2261_i 2260_2261 2261 4256.89
c_2260_2261_i 2260 2260_2261 4.67522e-10
r_2820_2821_e 2820 2821 13758.3
r_2820_2821_i 2820_2821 2821 95645.6
c_2820_2821_i 2820 2820_2821 9.36084e-12
r_3380_3381_e 3380 3381 13758.3
r_3380_3381_i 3380_3381 3381 95645.6
c_3380_3381_i 3380 3380_3381 9.36084e-12
r_21_22_e 21 22 13376.4
r_21_22_i 21_22 22 93218.1
c_21_22_i 21 21_22 2.08965e-09
r_581_582_e 581 582 13376.4
r_581_582_i 581_582 582 93218.1
c_581_582_i 581 581_582 2.08965e-09
r_1141_1142_e 1141 1142 836.944
r_1141_1142_i 1141_1142 1142 4256.89
c_1141_1142_i 1141 1141_1142 4.67522e-10
r_1701_1702_e 1701 1702 836.944
r_1701_1702_i 1701_1702 1702 4256.89
c_1701_1702_i 1701 1701_1702 4.67522e-10
r_2261_2262_e 2261 2262 836.944
r_2261_2262_i 2261_2262 2262 4256.89
c_2261_2262_i 2261 2261_2262 4.67522e-10
r_2821_2822_e 2821 2822 13758.3
r_2821_2822_i 2821_2822 2822 95645.6
c_2821_2822_i 2821 2821_2822 9.36084e-12
r_3381_3382_e 3381 3382 13758.3
r_3381_3382_i 3381_3382 3382 95645.6
c_3381_3382_i 3381 3381_3382 9.36084e-12
r_22_23_e 22 23 13376.4
r_22_23_i 22_23 23 93218.1
c_22_23_i 22 22_23 2.08965e-09
r_582_583_e 582 583 13376.4
r_582_583_i 582_583 583 93218.1
c_582_583_i 582 582_583 2.08965e-09
r_1142_1143_e 1142 1143 836.944
r_1142_1143_i 1142_1143 1143 4256.89
c_1142_1143_i 1142 1142_1143 4.67522e-10
r_1702_1703_e 1702 1703 836.944
r_1702_1703_i 1702_1703 1703 4256.89
c_1702_1703_i 1702 1702_1703 4.67522e-10
r_2262_2263_e 2262 2263 836.944
r_2262_2263_i 2262_2263 2263 4256.89
c_2262_2263_i 2262 2262_2263 4.67522e-10
r_2822_2823_e 2822 2823 13758.3
r_2822_2823_i 2822_2823 2823 95645.6
c_2822_2823_i 2822 2822_2823 9.36084e-12
r_3382_3383_e 3382 3383 13758.3
r_3382_3383_i 3382_3383 3383 95645.6
c_3382_3383_i 3382 3382_3383 9.36084e-12
r_23_24_e 23 24 13376.4
r_23_24_i 23_24 24 93218.1
c_23_24_i 23 23_24 2.08965e-09
r_583_584_e 583 584 13376.4
r_583_584_i 583_584 584 93218.1
c_583_584_i 583 583_584 2.08965e-09
r_1143_1144_e 1143 1144 836.944
r_1143_1144_i 1143_1144 1144 4256.89
c_1143_1144_i 1143 1143_1144 4.67522e-10
r_1703_1704_e 1703 1704 836.944
r_1703_1704_i 1703_1704 1704 4256.89
c_1703_1704_i 1703 1703_1704 4.67522e-10
r_2263_2264_e 2263 2264 836.944
r_2263_2264_i 2263_2264 2264 4256.89
c_2263_2264_i 2263 2263_2264 4.67522e-10
r_2823_2824_e 2823 2824 13758.3
r_2823_2824_i 2823_2824 2824 95645.6
c_2823_2824_i 2823 2823_2824 9.36084e-12
r_3383_3384_e 3383 3384 13758.3
r_3383_3384_i 3383_3384 3384 95645.6
c_3383_3384_i 3383 3383_3384 9.36084e-12
r_24_25_e 24 25 13376.4
r_24_25_i 24_25 25 93218.1
c_24_25_i 24 24_25 2.08965e-09
r_584_585_e 584 585 13376.4
r_584_585_i 584_585 585 93218.1
c_584_585_i 584 584_585 2.08965e-09
r_1144_1145_e 1144 1145 836.944
r_1144_1145_i 1144_1145 1145 4256.89
c_1144_1145_i 1144 1144_1145 4.67522e-10
r_1704_1705_e 1704 1705 836.944
r_1704_1705_i 1704_1705 1705 4256.89
c_1704_1705_i 1704 1704_1705 4.67522e-10
r_2264_2265_e 2264 2265 836.944
r_2264_2265_i 2264_2265 2265 4256.89
c_2264_2265_i 2264 2264_2265 4.67522e-10
r_2824_2825_e 2824 2825 13758.3
r_2824_2825_i 2824_2825 2825 95645.6
c_2824_2825_i 2824 2824_2825 9.36084e-12
r_3384_3385_e 3384 3385 13758.3
r_3384_3385_i 3384_3385 3385 95645.6
c_3384_3385_i 3384 3384_3385 9.36084e-12
r_25_26_e 25 26 13376.4
r_25_26_i 25_26 26 93218.1
c_25_26_i 25 25_26 2.08965e-09
r_585_586_e 585 586 13376.4
r_585_586_i 585_586 586 93218.1
c_585_586_i 585 585_586 2.08965e-09
r_1145_1146_e 1145 1146 836.944
r_1145_1146_i 1145_1146 1146 4256.89
c_1145_1146_i 1145 1145_1146 4.67522e-10
r_1705_1706_e 1705 1706 836.944
r_1705_1706_i 1705_1706 1706 4256.89
c_1705_1706_i 1705 1705_1706 4.67522e-10
r_2265_2266_e 2265 2266 836.944
r_2265_2266_i 2265_2266 2266 4256.89
c_2265_2266_i 2265 2265_2266 4.67522e-10
r_2825_2826_e 2825 2826 13758.3
r_2825_2826_i 2825_2826 2826 95645.6
c_2825_2826_i 2825 2825_2826 9.36084e-12
r_3385_3386_e 3385 3386 13758.3
r_3385_3386_i 3385_3386 3386 95645.6
c_3385_3386_i 3385 3385_3386 9.36084e-12
r_26_27_e 26 27 13376.4
r_26_27_i 26_27 27 93218.1
c_26_27_i 26 26_27 2.08965e-09
r_586_587_e 586 587 13376.4
r_586_587_i 586_587 587 93218.1
c_586_587_i 586 586_587 2.08965e-09
r_1146_1147_e 1146 1147 836.944
r_1146_1147_i 1146_1147 1147 4256.89
c_1146_1147_i 1146 1146_1147 4.67522e-10
r_1706_1707_e 1706 1707 836.944
r_1706_1707_i 1706_1707 1707 4256.89
c_1706_1707_i 1706 1706_1707 4.67522e-10
r_2266_2267_e 2266 2267 836.944
r_2266_2267_i 2266_2267 2267 4256.89
c_2266_2267_i 2266 2266_2267 4.67522e-10
r_2826_2827_e 2826 2827 13758.3
r_2826_2827_i 2826_2827 2827 95645.6
c_2826_2827_i 2826 2826_2827 9.36084e-12
r_3386_3387_e 3386 3387 13758.3
r_3386_3387_i 3386_3387 3387 95645.6
c_3386_3387_i 3386 3386_3387 9.36084e-12
r_27_28_e 27 28 13376.4
r_27_28_i 27_28 28 93218.1
c_27_28_i 27 27_28 2.08965e-09
r_587_588_e 587 588 13376.4
r_587_588_i 587_588 588 93218.1
c_587_588_i 587 587_588 2.08965e-09
r_1147_1148_e 1147 1148 396.769
r_1147_1148_i 1147_1148 1148 1005.45
c_1147_1148_i 1147 1147_1148 1.65766e-10
r_1707_1708_e 1707 1708 396.769
r_1707_1708_i 1707_1708 1708 1005.45
c_1707_1708_i 1707 1707_1708 1.65766e-10
r_2267_2268_e 2267 2268 836.944
r_2267_2268_i 2267_2268 2268 4256.89
c_2267_2268_i 2267 2267_2268 4.67522e-10
r_2827_2828_e 2827 2828 13758.3
r_2827_2828_i 2827_2828 2828 95645.6
c_2827_2828_i 2827 2827_2828 9.36084e-12
r_3387_3388_e 3387 3388 13758.3
r_3387_3388_i 3387_3388 3388 95645.6
c_3387_3388_i 3387 3387_3388 9.36084e-12
r_28_29_e 28 29 13376.4
r_28_29_i 28_29 29 93218.1
c_28_29_i 28 28_29 2.08965e-09
r_588_589_e 588 589 13376.4
r_588_589_i 588_589 589 93218.1
c_588_589_i 588 588_589 2.08965e-09
r_1148_1149_e 1148 1149 836.944
r_1148_1149_i 1148_1149 1149 4256.89
c_1148_1149_i 1148 1148_1149 4.67522e-10
r_1708_1709_e 1708 1709 836.944
r_1708_1709_i 1708_1709 1709 4256.89
c_1708_1709_i 1708 1708_1709 4.67522e-10
r_2268_2269_e 2268 2269 836.944
r_2268_2269_i 2268_2269 2269 4256.89
c_2268_2269_i 2268 2268_2269 4.67522e-10
r_2828_2829_e 2828 2829 13758.3
r_2828_2829_i 2828_2829 2829 95645.6
c_2828_2829_i 2828 2828_2829 9.36084e-12
r_3388_3389_e 3388 3389 13758.3
r_3388_3389_i 3388_3389 3389 95645.6
c_3388_3389_i 3388 3388_3389 9.36084e-12
r_29_30_e 29 30 13376.4
r_29_30_i 29_30 30 93218.1
c_29_30_i 29 29_30 2.08965e-09
r_589_590_e 589 590 13376.4
r_589_590_i 589_590 590 93218.1
c_589_590_i 589 589_590 2.08965e-09
r_1149_1150_e 1149 1150 836.944
r_1149_1150_i 1149_1150 1150 4256.89
c_1149_1150_i 1149 1149_1150 4.67522e-10
r_1709_1710_e 1709 1710 836.944
r_1709_1710_i 1709_1710 1710 4256.89
c_1709_1710_i 1709 1709_1710 4.67522e-10
r_2269_2270_e 2269 2270 836.944
r_2269_2270_i 2269_2270 2270 4256.89
c_2269_2270_i 2269 2269_2270 4.67522e-10
r_2829_2830_e 2829 2830 13758.3
r_2829_2830_i 2829_2830 2830 95645.6
c_2829_2830_i 2829 2829_2830 9.36084e-12
r_3389_3390_e 3389 3390 13758.3
r_3389_3390_i 3389_3390 3390 95645.6
c_3389_3390_i 3389 3389_3390 9.36084e-12
r_30_31_e 30 31 13376.4
r_30_31_i 30_31 31 93218.1
c_30_31_i 30 30_31 2.08965e-09
r_590_591_e 590 591 13376.4
r_590_591_i 590_591 591 93218.1
c_590_591_i 590 590_591 2.08965e-09
r_1150_1151_e 1150 1151 836.944
r_1150_1151_i 1150_1151 1151 4256.89
c_1150_1151_i 1150 1150_1151 4.67522e-10
r_1710_1711_e 1710 1711 836.944
r_1710_1711_i 1710_1711 1711 4256.89
c_1710_1711_i 1710 1710_1711 4.67522e-10
r_2270_2271_e 2270 2271 836.944
r_2270_2271_i 2270_2271 2271 4256.89
c_2270_2271_i 2270 2270_2271 4.67522e-10
r_2830_2831_e 2830 2831 13758.3
r_2830_2831_i 2830_2831 2831 95645.6
c_2830_2831_i 2830 2830_2831 9.36084e-12
r_3390_3391_e 3390 3391 13758.3
r_3390_3391_i 3390_3391 3391 95645.6
c_3390_3391_i 3390 3390_3391 9.36084e-12
r_31_32_e 31 32 13376.4
r_31_32_i 31_32 32 93218.1
c_31_32_i 31 31_32 2.08965e-09
r_591_592_e 591 592 13376.4
r_591_592_i 591_592 592 93218.1
c_591_592_i 591 591_592 2.08965e-09
r_1151_1152_e 1151 1152 836.944
r_1151_1152_i 1151_1152 1152 4256.89
c_1151_1152_i 1151 1151_1152 4.67522e-10
r_1711_1712_e 1711 1712 836.944
r_1711_1712_i 1711_1712 1712 4256.89
c_1711_1712_i 1711 1711_1712 4.67522e-10
r_2271_2272_e 2271 2272 836.944
r_2271_2272_i 2271_2272 2272 4256.89
c_2271_2272_i 2271 2271_2272 4.67522e-10
r_2831_2832_e 2831 2832 13758.3
r_2831_2832_i 2831_2832 2832 95645.6
c_2831_2832_i 2831 2831_2832 9.36084e-12
r_3391_3392_e 3391 3392 13758.3
r_3391_3392_i 3391_3392 3392 95645.6
c_3391_3392_i 3391 3391_3392 9.36084e-12
r_33_34_e 33 34 13376.4
r_33_34_i 33_34 34 93218.1
c_33_34_i 33 33_34 2.08965e-09
r_593_594_e 593 594 13376.4
r_593_594_i 593_594 594 93218.1
c_593_594_i 593 593_594 2.08965e-09
r_1153_1154_e 1153 1154 13376.4
r_1153_1154_i 1153_1154 1154 93218.1
c_1153_1154_i 1153 1153_1154 2.08965e-09
r_1713_1714_e 1713 1714 13376.4
r_1713_1714_i 1713_1714 1714 93218.1
c_1713_1714_i 1713 1713_1714 2.08965e-09
r_2273_2274_e 2273 2274 13376.4
r_2273_2274_i 2273_2274 2274 93218.1
c_2273_2274_i 2273 2273_2274 2.08965e-09
r_2833_2834_e 2833 2834 13376.4
r_2833_2834_i 2833_2834 2834 93218.1
c_2833_2834_i 2833 2833_2834 2.08965e-09
r_3393_3394_e 3393 3394 13376.4
r_3393_3394_i 3393_3394 3394 93218.1
c_3393_3394_i 3393 3393_3394 2.08965e-09
r_34_35_e 34 35 13376.4
r_34_35_i 34_35 35 93218.1
c_34_35_i 34 34_35 2.08965e-09
r_594_595_e 594 595 13376.4
r_594_595_i 594_595 595 93218.1
c_594_595_i 594 594_595 2.08965e-09
r_1154_1155_e 1154 1155 13376.4
r_1154_1155_i 1154_1155 1155 93218.1
c_1154_1155_i 1154 1154_1155 2.08965e-09
r_1714_1715_e 1714 1715 13376.4
r_1714_1715_i 1714_1715 1715 93218.1
c_1714_1715_i 1714 1714_1715 2.08965e-09
r_2274_2275_e 2274 2275 13376.4
r_2274_2275_i 2274_2275 2275 93218.1
c_2274_2275_i 2274 2274_2275 2.08965e-09
r_2834_2835_e 2834 2835 13376.4
r_2834_2835_i 2834_2835 2835 93218.1
c_2834_2835_i 2834 2834_2835 2.08965e-09
r_3394_3395_e 3394 3395 13376.4
r_3394_3395_i 3394_3395 3395 93218.1
c_3394_3395_i 3394 3394_3395 2.08965e-09
r_35_36_e 35 36 13376.4
r_35_36_i 35_36 36 93218.1
c_35_36_i 35 35_36 2.08965e-09
r_595_596_e 595 596 13376.4
r_595_596_i 595_596 596 93218.1
c_595_596_i 595 595_596 2.08965e-09
r_1155_1156_e 1155 1156 836.944
r_1155_1156_i 1155_1156 1156 4256.89
c_1155_1156_i 1155 1155_1156 4.67522e-10
r_1715_1716_e 1715 1716 836.944
r_1715_1716_i 1715_1716 1716 4256.89
c_1715_1716_i 1715 1715_1716 4.67522e-10
r_2275_2276_e 2275 2276 836.944
r_2275_2276_i 2275_2276 2276 4256.89
c_2275_2276_i 2275 2275_2276 4.67522e-10
r_2835_2836_e 2835 2836 836.944
r_2835_2836_i 2835_2836 2836 4256.89
c_2835_2836_i 2835 2835_2836 4.67522e-10
r_3395_3396_e 3395 3396 836.944
r_3395_3396_i 3395_3396 3396 4256.89
c_3395_3396_i 3395 3395_3396 4.67522e-10
r_36_37_e 36 37 13376.4
r_36_37_i 36_37 37 93218.1
c_36_37_i 36 36_37 2.08965e-09
r_596_597_e 596 597 13376.4
r_596_597_i 596_597 597 93218.1
c_596_597_i 596 596_597 2.08965e-09
r_1156_1157_e 1156 1157 836.944
r_1156_1157_i 1156_1157 1157 4256.89
c_1156_1157_i 1156 1156_1157 4.67522e-10
r_1716_1717_e 1716 1717 836.944
r_1716_1717_i 1716_1717 1717 4256.89
c_1716_1717_i 1716 1716_1717 4.67522e-10
r_2276_2277_e 2276 2277 836.944
r_2276_2277_i 2276_2277 2277 4256.89
c_2276_2277_i 2276 2276_2277 4.67522e-10
r_2836_2837_e 2836 2837 13758.3
r_2836_2837_i 2836_2837 2837 95645.6
c_2836_2837_i 2836 2836_2837 9.36084e-12
r_3396_3397_e 3396 3397 13758.3
r_3396_3397_i 3396_3397 3397 95645.6
c_3396_3397_i 3396 3396_3397 9.36084e-12
r_37_38_e 37 38 13376.4
r_37_38_i 37_38 38 93218.1
c_37_38_i 37 37_38 2.08965e-09
r_597_598_e 597 598 13376.4
r_597_598_i 597_598 598 93218.1
c_597_598_i 597 597_598 2.08965e-09
r_1157_1158_e 1157 1158 836.944
r_1157_1158_i 1157_1158 1158 4256.89
c_1157_1158_i 1157 1157_1158 4.67522e-10
r_1717_1718_e 1717 1718 836.944
r_1717_1718_i 1717_1718 1718 4256.89
c_1717_1718_i 1717 1717_1718 4.67522e-10
r_2277_2278_e 2277 2278 836.944
r_2277_2278_i 2277_2278 2278 4256.89
c_2277_2278_i 2277 2277_2278 4.67522e-10
r_2837_2838_e 2837 2838 13758.3
r_2837_2838_i 2837_2838 2838 95645.6
c_2837_2838_i 2837 2837_2838 9.36084e-12
r_3397_3398_e 3397 3398 13758.3
r_3397_3398_i 3397_3398 3398 95645.6
c_3397_3398_i 3397 3397_3398 9.36084e-12
r_38_39_e 38 39 13376.4
r_38_39_i 38_39 39 93218.1
c_38_39_i 38 38_39 2.08965e-09
r_598_599_e 598 599 13376.4
r_598_599_i 598_599 599 93218.1
c_598_599_i 598 598_599 2.08965e-09
r_1158_1159_e 1158 1159 836.944
r_1158_1159_i 1158_1159 1159 4256.89
c_1158_1159_i 1158 1158_1159 4.67522e-10
r_1718_1719_e 1718 1719 836.944
r_1718_1719_i 1718_1719 1719 4256.89
c_1718_1719_i 1718 1718_1719 4.67522e-10
r_2278_2279_e 2278 2279 836.944
r_2278_2279_i 2278_2279 2279 4256.89
c_2278_2279_i 2278 2278_2279 4.67522e-10
r_2838_2839_e 2838 2839 13758.3
r_2838_2839_i 2838_2839 2839 95645.6
c_2838_2839_i 2838 2838_2839 9.36084e-12
r_3398_3399_e 3398 3399 13758.3
r_3398_3399_i 3398_3399 3399 95645.6
c_3398_3399_i 3398 3398_3399 9.36084e-12
r_39_40_e 39 40 13376.4
r_39_40_i 39_40 40 93218.1
c_39_40_i 39 39_40 2.08965e-09
r_599_600_e 599 600 13376.4
r_599_600_i 599_600 600 93218.1
c_599_600_i 599 599_600 2.08965e-09
r_1159_1160_e 1159 1160 836.944
r_1159_1160_i 1159_1160 1160 4256.89
c_1159_1160_i 1159 1159_1160 4.67522e-10
r_1719_1720_e 1719 1720 836.944
r_1719_1720_i 1719_1720 1720 4256.89
c_1719_1720_i 1719 1719_1720 4.67522e-10
r_2279_2280_e 2279 2280 836.944
r_2279_2280_i 2279_2280 2280 4256.89
c_2279_2280_i 2279 2279_2280 4.67522e-10
r_2839_2840_e 2839 2840 13758.3
r_2839_2840_i 2839_2840 2840 95645.6
c_2839_2840_i 2839 2839_2840 9.36084e-12
r_3399_3400_e 3399 3400 13758.3
r_3399_3400_i 3399_3400 3400 95645.6
c_3399_3400_i 3399 3399_3400 9.36084e-12
r_40_41_e 40 41 13376.4
r_40_41_i 40_41 41 93218.1
c_40_41_i 40 40_41 2.08965e-09
r_600_601_e 600 601 13376.4
r_600_601_i 600_601 601 93218.1
c_600_601_i 600 600_601 2.08965e-09
r_1160_1161_e 1160 1161 836.944
r_1160_1161_i 1160_1161 1161 4256.89
c_1160_1161_i 1160 1160_1161 4.67522e-10
r_1720_1721_e 1720 1721 836.944
r_1720_1721_i 1720_1721 1721 4256.89
c_1720_1721_i 1720 1720_1721 4.67522e-10
r_2280_2281_e 2280 2281 836.944
r_2280_2281_i 2280_2281 2281 4256.89
c_2280_2281_i 2280 2280_2281 4.67522e-10
r_2840_2841_e 2840 2841 13758.3
r_2840_2841_i 2840_2841 2841 95645.6
c_2840_2841_i 2840 2840_2841 9.36084e-12
r_3400_3401_e 3400 3401 13758.3
r_3400_3401_i 3400_3401 3401 95645.6
c_3400_3401_i 3400 3400_3401 9.36084e-12
r_41_42_e 41 42 13376.4
r_41_42_i 41_42 42 93218.1
c_41_42_i 41 41_42 2.08965e-09
r_601_602_e 601 602 13376.4
r_601_602_i 601_602 602 93218.1
c_601_602_i 601 601_602 2.08965e-09
r_1161_1162_e 1161 1162 836.944
r_1161_1162_i 1161_1162 1162 4256.89
c_1161_1162_i 1161 1161_1162 4.67522e-10
r_1721_1722_e 1721 1722 836.944
r_1721_1722_i 1721_1722 1722 4256.89
c_1721_1722_i 1721 1721_1722 4.67522e-10
r_2281_2282_e 2281 2282 836.944
r_2281_2282_i 2281_2282 2282 4256.89
c_2281_2282_i 2281 2281_2282 4.67522e-10
r_2841_2842_e 2841 2842 13758.3
r_2841_2842_i 2841_2842 2842 95645.6
c_2841_2842_i 2841 2841_2842 9.36084e-12
r_3401_3402_e 3401 3402 13758.3
r_3401_3402_i 3401_3402 3402 95645.6
c_3401_3402_i 3401 3401_3402 9.36084e-12
r_42_43_e 42 43 13376.4
r_42_43_i 42_43 43 93218.1
c_42_43_i 42 42_43 2.08965e-09
r_602_603_e 602 603 13376.4
r_602_603_i 602_603 603 93218.1
c_602_603_i 602 602_603 2.08965e-09
r_1162_1163_e 1162 1163 836.944
r_1162_1163_i 1162_1163 1163 4256.89
c_1162_1163_i 1162 1162_1163 4.67522e-10
r_1722_1723_e 1722 1723 836.944
r_1722_1723_i 1722_1723 1723 4256.89
c_1722_1723_i 1722 1722_1723 4.67522e-10
r_2282_2283_e 2282 2283 836.944
r_2282_2283_i 2282_2283 2283 4256.89
c_2282_2283_i 2282 2282_2283 4.67522e-10
r_2842_2843_e 2842 2843 13758.3
r_2842_2843_i 2842_2843 2843 95645.6
c_2842_2843_i 2842 2842_2843 9.36084e-12
r_3402_3403_e 3402 3403 13758.3
r_3402_3403_i 3402_3403 3403 95645.6
c_3402_3403_i 3402 3402_3403 9.36084e-12
r_43_44_e 43 44 13376.4
r_43_44_i 43_44 44 93218.1
c_43_44_i 43 43_44 2.08965e-09
r_603_604_e 603 604 13376.4
r_603_604_i 603_604 604 93218.1
c_603_604_i 603 603_604 2.08965e-09
r_1163_1164_e 1163 1164 396.76
r_1163_1164_i 1163_1164 1164 1005.43
c_1163_1164_i 1163 1163_1164 1.6577e-10
r_1723_1724_e 1723 1724 396.76
r_1723_1724_i 1723_1724 1724 1005.43
c_1723_1724_i 1723 1723_1724 1.6577e-10
r_2283_2284_e 2283 2284 836.944
r_2283_2284_i 2283_2284 2284 4256.89
c_2283_2284_i 2283 2283_2284 4.67522e-10
r_2843_2844_e 2843 2844 13758.3
r_2843_2844_i 2843_2844 2844 95645.6
c_2843_2844_i 2843 2843_2844 9.36084e-12
r_3403_3404_e 3403 3404 13758.3
r_3403_3404_i 3403_3404 3404 95645.6
c_3403_3404_i 3403 3403_3404 9.36084e-12
r_44_45_e 44 45 13376.4
r_44_45_i 44_45 45 93218.1
c_44_45_i 44 44_45 2.08965e-09
r_604_605_e 604 605 13376.4
r_604_605_i 604_605 605 93218.1
c_604_605_i 604 604_605 2.08965e-09
r_1164_1165_e 1164 1165 836.944
r_1164_1165_i 1164_1165 1165 4256.89
c_1164_1165_i 1164 1164_1165 4.67522e-10
r_1724_1725_e 1724 1725 836.944
r_1724_1725_i 1724_1725 1725 4256.89
c_1724_1725_i 1724 1724_1725 4.67522e-10
r_2284_2285_e 2284 2285 836.944
r_2284_2285_i 2284_2285 2285 4256.89
c_2284_2285_i 2284 2284_2285 4.67522e-10
r_2844_2845_e 2844 2845 13758.3
r_2844_2845_i 2844_2845 2845 95645.6
c_2844_2845_i 2844 2844_2845 9.36084e-12
r_3404_3405_e 3404 3405 13758.3
r_3404_3405_i 3404_3405 3405 95645.6
c_3404_3405_i 3404 3404_3405 9.36084e-12
r_45_46_e 45 46 13376.4
r_45_46_i 45_46 46 93218.1
c_45_46_i 45 45_46 2.08965e-09
r_605_606_e 605 606 13376.4
r_605_606_i 605_606 606 93218.1
c_605_606_i 605 605_606 2.08965e-09
r_1165_1166_e 1165 1166 836.944
r_1165_1166_i 1165_1166 1166 4256.89
c_1165_1166_i 1165 1165_1166 4.67522e-10
r_1725_1726_e 1725 1726 836.944
r_1725_1726_i 1725_1726 1726 4256.89
c_1725_1726_i 1725 1725_1726 4.67522e-10
r_2285_2286_e 2285 2286 836.944
r_2285_2286_i 2285_2286 2286 4256.89
c_2285_2286_i 2285 2285_2286 4.67522e-10
r_2845_2846_e 2845 2846 13758.3
r_2845_2846_i 2845_2846 2846 95645.6
c_2845_2846_i 2845 2845_2846 9.36084e-12
r_3405_3406_e 3405 3406 13758.3
r_3405_3406_i 3405_3406 3406 95645.6
c_3405_3406_i 3405 3405_3406 9.36084e-12
r_46_47_e 46 47 13376.4
r_46_47_i 46_47 47 93218.1
c_46_47_i 46 46_47 2.08965e-09
r_606_607_e 606 607 13376.4
r_606_607_i 606_607 607 93218.1
c_606_607_i 606 606_607 2.08965e-09
r_1166_1167_e 1166 1167 836.944
r_1166_1167_i 1166_1167 1167 4256.89
c_1166_1167_i 1166 1166_1167 4.67522e-10
r_1726_1727_e 1726 1727 836.944
r_1726_1727_i 1726_1727 1727 4256.89
c_1726_1727_i 1726 1726_1727 4.67522e-10
r_2286_2287_e 2286 2287 836.944
r_2286_2287_i 2286_2287 2287 4256.89
c_2286_2287_i 2286 2286_2287 4.67522e-10
r_2846_2847_e 2846 2847 13758.3
r_2846_2847_i 2846_2847 2847 95645.6
c_2846_2847_i 2846 2846_2847 9.36084e-12
r_3406_3407_e 3406 3407 13758.3
r_3406_3407_i 3406_3407 3407 95645.6
c_3406_3407_i 3406 3406_3407 9.36084e-12
r_47_48_e 47 48 13376.4
r_47_48_i 47_48 48 93218.1
c_47_48_i 47 47_48 2.08965e-09
r_607_608_e 607 608 13376.4
r_607_608_i 607_608 608 93218.1
c_607_608_i 607 607_608 2.08965e-09
r_1167_1168_e 1167 1168 836.944
r_1167_1168_i 1167_1168 1168 4256.89
c_1167_1168_i 1167 1167_1168 4.67522e-10
r_1727_1728_e 1727 1728 836.944
r_1727_1728_i 1727_1728 1728 4256.89
c_1727_1728_i 1727 1727_1728 4.67522e-10
r_2287_2288_e 2287 2288 836.944
r_2287_2288_i 2287_2288 2288 4256.89
c_2287_2288_i 2287 2287_2288 4.67522e-10
r_2847_2848_e 2847 2848 13758.3
r_2847_2848_i 2847_2848 2848 95645.6
c_2847_2848_i 2847 2847_2848 9.36084e-12
r_3407_3408_e 3407 3408 13758.3
r_3407_3408_i 3407_3408 3408 95645.6
c_3407_3408_i 3407 3407_3408 9.36084e-12
r_49_50_e 49 50 13376.4
r_49_50_i 49_50 50 93218.1
c_49_50_i 49 49_50 2.08965e-09
r_609_610_e 609 610 13376.4
r_609_610_i 609_610 610 93218.1
c_609_610_i 609 609_610 2.08965e-09
r_1169_1170_e 1169 1170 13376.4
r_1169_1170_i 1169_1170 1170 93218.1
c_1169_1170_i 1169 1169_1170 2.08965e-09
r_1729_1730_e 1729 1730 13376.4
r_1729_1730_i 1729_1730 1730 93218.1
c_1729_1730_i 1729 1729_1730 2.08965e-09
r_2289_2290_e 2289 2290 13376.4
r_2289_2290_i 2289_2290 2290 93218.1
c_2289_2290_i 2289 2289_2290 2.08965e-09
r_2849_2850_e 2849 2850 13376.4
r_2849_2850_i 2849_2850 2850 93218.1
c_2849_2850_i 2849 2849_2850 2.08965e-09
r_3409_3410_e 3409 3410 13376.4
r_3409_3410_i 3409_3410 3410 93218.1
c_3409_3410_i 3409 3409_3410 2.08965e-09
r_50_51_e 50 51 13376.4
r_50_51_i 50_51 51 93218.1
c_50_51_i 50 50_51 2.08965e-09
r_610_611_e 610 611 13376.4
r_610_611_i 610_611 611 93218.1
c_610_611_i 610 610_611 2.08965e-09
r_1170_1171_e 1170 1171 13376.4
r_1170_1171_i 1170_1171 1171 93218.1
c_1170_1171_i 1170 1170_1171 2.08965e-09
r_1730_1731_e 1730 1731 13376.4
r_1730_1731_i 1730_1731 1731 93218.1
c_1730_1731_i 1730 1730_1731 2.08965e-09
r_2290_2291_e 2290 2291 13376.4
r_2290_2291_i 2290_2291 2291 93218.1
c_2290_2291_i 2290 2290_2291 2.08965e-09
r_2850_2851_e 2850 2851 13376.4
r_2850_2851_i 2850_2851 2851 93218.1
c_2850_2851_i 2850 2850_2851 2.08965e-09
r_3410_3411_e 3410 3411 13376.4
r_3410_3411_i 3410_3411 3411 93218.1
c_3410_3411_i 3410 3410_3411 2.08965e-09
r_51_52_e 51 52 13376.4
r_51_52_i 51_52 52 93218.1
c_51_52_i 51 51_52 2.08965e-09
r_611_612_e 611 612 13376.4
r_611_612_i 611_612 612 93218.1
c_611_612_i 611 611_612 2.08965e-09
r_1171_1172_e 1171 1172 836.944
r_1171_1172_i 1171_1172 1172 4256.89
c_1171_1172_i 1171 1171_1172 4.67522e-10
r_1731_1732_e 1731 1732 836.944
r_1731_1732_i 1731_1732 1732 4256.89
c_1731_1732_i 1731 1731_1732 4.67522e-10
r_2291_2292_e 2291 2292 836.944
r_2291_2292_i 2291_2292 2292 4256.89
c_2291_2292_i 2291 2291_2292 4.67522e-10
r_2851_2852_e 2851 2852 836.944
r_2851_2852_i 2851_2852 2852 4256.89
c_2851_2852_i 2851 2851_2852 4.67522e-10
r_3411_3412_e 3411 3412 836.944
r_3411_3412_i 3411_3412 3412 4256.89
c_3411_3412_i 3411 3411_3412 4.67522e-10
r_52_53_e 52 53 13376.4
r_52_53_i 52_53 53 93218.1
c_52_53_i 52 52_53 2.08965e-09
r_612_613_e 612 613 13376.4
r_612_613_i 612_613 613 93218.1
c_612_613_i 612 612_613 2.08965e-09
r_1172_1173_e 1172 1173 836.944
r_1172_1173_i 1172_1173 1173 4256.89
c_1172_1173_i 1172 1172_1173 4.67522e-10
r_1732_1733_e 1732 1733 836.944
r_1732_1733_i 1732_1733 1733 4256.89
c_1732_1733_i 1732 1732_1733 4.67522e-10
r_2292_2293_e 2292 2293 836.944
r_2292_2293_i 2292_2293 2293 4256.89
c_2292_2293_i 2292 2292_2293 4.67522e-10
r_2852_2853_e 2852 2853 13758.3
r_2852_2853_i 2852_2853 2853 95645.6
c_2852_2853_i 2852 2852_2853 9.36084e-12
r_3412_3413_e 3412 3413 13758.3
r_3412_3413_i 3412_3413 3413 95645.6
c_3412_3413_i 3412 3412_3413 9.36084e-12
r_53_54_e 53 54 13376.4
r_53_54_i 53_54 54 93218.1
c_53_54_i 53 53_54 2.08965e-09
r_613_614_e 613 614 13376.4
r_613_614_i 613_614 614 93218.1
c_613_614_i 613 613_614 2.08965e-09
r_1173_1174_e 1173 1174 836.944
r_1173_1174_i 1173_1174 1174 4256.89
c_1173_1174_i 1173 1173_1174 4.67522e-10
r_1733_1734_e 1733 1734 836.944
r_1733_1734_i 1733_1734 1734 4256.89
c_1733_1734_i 1733 1733_1734 4.67522e-10
r_2293_2294_e 2293 2294 836.944
r_2293_2294_i 2293_2294 2294 4256.89
c_2293_2294_i 2293 2293_2294 4.67522e-10
r_2853_2854_e 2853 2854 13758.3
r_2853_2854_i 2853_2854 2854 95645.6
c_2853_2854_i 2853 2853_2854 9.36084e-12
r_3413_3414_e 3413 3414 13758.3
r_3413_3414_i 3413_3414 3414 95645.6
c_3413_3414_i 3413 3413_3414 9.36084e-12
r_54_55_e 54 55 13376.4
r_54_55_i 54_55 55 93218.1
c_54_55_i 54 54_55 2.08965e-09
r_614_615_e 614 615 13376.4
r_614_615_i 614_615 615 93218.1
c_614_615_i 614 614_615 2.08965e-09
r_1174_1175_e 1174 1175 836.944
r_1174_1175_i 1174_1175 1175 4256.89
c_1174_1175_i 1174 1174_1175 4.67522e-10
r_1734_1735_e 1734 1735 836.944
r_1734_1735_i 1734_1735 1735 4256.89
c_1734_1735_i 1734 1734_1735 4.67522e-10
r_2294_2295_e 2294 2295 836.944
r_2294_2295_i 2294_2295 2295 4256.89
c_2294_2295_i 2294 2294_2295 4.67522e-10
r_2854_2855_e 2854 2855 13758.3
r_2854_2855_i 2854_2855 2855 95645.6
c_2854_2855_i 2854 2854_2855 9.36084e-12
r_3414_3415_e 3414 3415 13758.3
r_3414_3415_i 3414_3415 3415 95645.6
c_3414_3415_i 3414 3414_3415 9.36084e-12
r_55_56_e 55 56 13376.4
r_55_56_i 55_56 56 93218.1
c_55_56_i 55 55_56 2.08965e-09
r_615_616_e 615 616 13376.4
r_615_616_i 615_616 616 93218.1
c_615_616_i 615 615_616 2.08965e-09
r_1175_1176_e 1175 1176 836.944
r_1175_1176_i 1175_1176 1176 4256.89
c_1175_1176_i 1175 1175_1176 4.67522e-10
r_1735_1736_e 1735 1736 836.944
r_1735_1736_i 1735_1736 1736 4256.89
c_1735_1736_i 1735 1735_1736 4.67522e-10
r_2295_2296_e 2295 2296 836.944
r_2295_2296_i 2295_2296 2296 4256.89
c_2295_2296_i 2295 2295_2296 4.67522e-10
r_2855_2856_e 2855 2856 13758.3
r_2855_2856_i 2855_2856 2856 95645.6
c_2855_2856_i 2855 2855_2856 9.36084e-12
r_3415_3416_e 3415 3416 13758.3
r_3415_3416_i 3415_3416 3416 95645.6
c_3415_3416_i 3415 3415_3416 9.36084e-12
r_56_57_e 56 57 13376.4
r_56_57_i 56_57 57 93218.1
c_56_57_i 56 56_57 2.08965e-09
r_616_617_e 616 617 13376.4
r_616_617_i 616_617 617 93218.1
c_616_617_i 616 616_617 2.08965e-09
r_1176_1177_e 1176 1177 836.944
r_1176_1177_i 1176_1177 1177 4256.89
c_1176_1177_i 1176 1176_1177 4.67522e-10
r_1736_1737_e 1736 1737 836.944
r_1736_1737_i 1736_1737 1737 4256.89
c_1736_1737_i 1736 1736_1737 4.67522e-10
r_2296_2297_e 2296 2297 836.944
r_2296_2297_i 2296_2297 2297 4256.89
c_2296_2297_i 2296 2296_2297 4.67522e-10
r_2856_2857_e 2856 2857 13758.3
r_2856_2857_i 2856_2857 2857 95645.6
c_2856_2857_i 2856 2856_2857 9.36084e-12
r_3416_3417_e 3416 3417 13758.3
r_3416_3417_i 3416_3417 3417 95645.6
c_3416_3417_i 3416 3416_3417 9.36084e-12
r_57_58_e 57 58 13376.4
r_57_58_i 57_58 58 93218.1
c_57_58_i 57 57_58 2.08965e-09
r_617_618_e 617 618 13376.4
r_617_618_i 617_618 618 93218.1
c_617_618_i 617 617_618 2.08965e-09
r_1177_1178_e 1177 1178 836.944
r_1177_1178_i 1177_1178 1178 4256.89
c_1177_1178_i 1177 1177_1178 4.67522e-10
r_1737_1738_e 1737 1738 836.944
r_1737_1738_i 1737_1738 1738 4256.89
c_1737_1738_i 1737 1737_1738 4.67522e-10
r_2297_2298_e 2297 2298 836.944
r_2297_2298_i 2297_2298 2298 4256.89
c_2297_2298_i 2297 2297_2298 4.67522e-10
r_2857_2858_e 2857 2858 13758.3
r_2857_2858_i 2857_2858 2858 95645.6
c_2857_2858_i 2857 2857_2858 9.36084e-12
r_3417_3418_e 3417 3418 13758.3
r_3417_3418_i 3417_3418 3418 95645.6
c_3417_3418_i 3417 3417_3418 9.36084e-12
r_58_59_e 58 59 13376.4
r_58_59_i 58_59 59 93218.1
c_58_59_i 58 58_59 2.08965e-09
r_618_619_e 618 619 13376.4
r_618_619_i 618_619 619 93218.1
c_618_619_i 618 618_619 2.08965e-09
r_1178_1179_e 1178 1179 836.944
r_1178_1179_i 1178_1179 1179 4256.89
c_1178_1179_i 1178 1178_1179 4.67522e-10
r_1738_1739_e 1738 1739 836.944
r_1738_1739_i 1738_1739 1739 4256.89
c_1738_1739_i 1738 1738_1739 4.67522e-10
r_2298_2299_e 2298 2299 836.944
r_2298_2299_i 2298_2299 2299 4256.89
c_2298_2299_i 2298 2298_2299 4.67522e-10
r_2858_2859_e 2858 2859 13758.3
r_2858_2859_i 2858_2859 2859 95645.6
c_2858_2859_i 2858 2858_2859 9.36084e-12
r_3418_3419_e 3418 3419 13758.3
r_3418_3419_i 3418_3419 3419 95645.6
c_3418_3419_i 3418 3418_3419 9.36084e-12
r_59_60_e 59 60 13376.4
r_59_60_i 59_60 60 93218.1
c_59_60_i 59 59_60 2.08965e-09
r_619_620_e 619 620 13376.4
r_619_620_i 619_620 620 93218.1
c_619_620_i 619 619_620 2.08965e-09
r_1179_1180_e 1179 1180 396.751
r_1179_1180_i 1179_1180 1180 1005.4
c_1179_1180_i 1179 1179_1180 1.65774e-10
r_1739_1740_e 1739 1740 396.751
r_1739_1740_i 1739_1740 1740 1005.4
c_1739_1740_i 1739 1739_1740 1.65774e-10
r_2299_2300_e 2299 2300 836.944
r_2299_2300_i 2299_2300 2300 4256.89
c_2299_2300_i 2299 2299_2300 4.67522e-10
r_2859_2860_e 2859 2860 13758.3
r_2859_2860_i 2859_2860 2860 95645.6
c_2859_2860_i 2859 2859_2860 9.36084e-12
r_3419_3420_e 3419 3420 13758.3
r_3419_3420_i 3419_3420 3420 95645.6
c_3419_3420_i 3419 3419_3420 9.36084e-12
r_60_61_e 60 61 13376.4
r_60_61_i 60_61 61 93218.1
c_60_61_i 60 60_61 2.08965e-09
r_620_621_e 620 621 13376.4
r_620_621_i 620_621 621 93218.1
c_620_621_i 620 620_621 2.08965e-09
r_1180_1181_e 1180 1181 836.944
r_1180_1181_i 1180_1181 1181 4256.89
c_1180_1181_i 1180 1180_1181 4.67522e-10
r_1740_1741_e 1740 1741 836.944
r_1740_1741_i 1740_1741 1741 4256.89
c_1740_1741_i 1740 1740_1741 4.67522e-10
r_2300_2301_e 2300 2301 836.944
r_2300_2301_i 2300_2301 2301 4256.89
c_2300_2301_i 2300 2300_2301 4.67522e-10
r_2860_2861_e 2860 2861 13758.3
r_2860_2861_i 2860_2861 2861 95645.6
c_2860_2861_i 2860 2860_2861 9.36084e-12
r_3420_3421_e 3420 3421 13758.3
r_3420_3421_i 3420_3421 3421 95645.6
c_3420_3421_i 3420 3420_3421 9.36084e-12
r_61_62_e 61 62 13376.4
r_61_62_i 61_62 62 93218.1
c_61_62_i 61 61_62 2.08965e-09
r_621_622_e 621 622 13376.4
r_621_622_i 621_622 622 93218.1
c_621_622_i 621 621_622 2.08965e-09
r_1181_1182_e 1181 1182 836.944
r_1181_1182_i 1181_1182 1182 4256.89
c_1181_1182_i 1181 1181_1182 4.67522e-10
r_1741_1742_e 1741 1742 836.944
r_1741_1742_i 1741_1742 1742 4256.89
c_1741_1742_i 1741 1741_1742 4.67522e-10
r_2301_2302_e 2301 2302 836.944
r_2301_2302_i 2301_2302 2302 4256.89
c_2301_2302_i 2301 2301_2302 4.67522e-10
r_2861_2862_e 2861 2862 13758.3
r_2861_2862_i 2861_2862 2862 95645.6
c_2861_2862_i 2861 2861_2862 9.36084e-12
r_3421_3422_e 3421 3422 13758.3
r_3421_3422_i 3421_3422 3422 95645.6
c_3421_3422_i 3421 3421_3422 9.36084e-12
r_62_63_e 62 63 13376.4
r_62_63_i 62_63 63 93218.1
c_62_63_i 62 62_63 2.08965e-09
r_622_623_e 622 623 13376.4
r_622_623_i 622_623 623 93218.1
c_622_623_i 622 622_623 2.08965e-09
r_1182_1183_e 1182 1183 836.944
r_1182_1183_i 1182_1183 1183 4256.89
c_1182_1183_i 1182 1182_1183 4.67522e-10
r_1742_1743_e 1742 1743 836.944
r_1742_1743_i 1742_1743 1743 4256.89
c_1742_1743_i 1742 1742_1743 4.67522e-10
r_2302_2303_e 2302 2303 836.944
r_2302_2303_i 2302_2303 2303 4256.89
c_2302_2303_i 2302 2302_2303 4.67522e-10
r_2862_2863_e 2862 2863 13758.3
r_2862_2863_i 2862_2863 2863 95645.6
c_2862_2863_i 2862 2862_2863 9.36084e-12
r_3422_3423_e 3422 3423 13758.3
r_3422_3423_i 3422_3423 3423 95645.6
c_3422_3423_i 3422 3422_3423 9.36084e-12
r_63_64_e 63 64 13376.4
r_63_64_i 63_64 64 93218.1
c_63_64_i 63 63_64 2.08965e-09
r_623_624_e 623 624 13376.4
r_623_624_i 623_624 624 93218.1
c_623_624_i 623 623_624 2.08965e-09
r_1183_1184_e 1183 1184 836.944
r_1183_1184_i 1183_1184 1184 4256.89
c_1183_1184_i 1183 1183_1184 4.67522e-10
r_1743_1744_e 1743 1744 836.944
r_1743_1744_i 1743_1744 1744 4256.89
c_1743_1744_i 1743 1743_1744 4.67522e-10
r_2303_2304_e 2303 2304 836.944
r_2303_2304_i 2303_2304 2304 4256.89
c_2303_2304_i 2303 2303_2304 4.67522e-10
r_2863_2864_e 2863 2864 13758.3
r_2863_2864_i 2863_2864 2864 95645.6
c_2863_2864_i 2863 2863_2864 9.36084e-12
r_3423_3424_e 3423 3424 13758.3
r_3423_3424_i 3423_3424 3424 95645.6
c_3423_3424_i 3423 3423_3424 9.36084e-12
r_65_66_e 65 66 13376.4
r_65_66_i 65_66 66 93218.1
c_65_66_i 65 65_66 2.08965e-09
r_625_626_e 625 626 13376.4
r_625_626_i 625_626 626 93218.1
c_625_626_i 625 625_626 2.08965e-09
r_1185_1186_e 1185 1186 13376.4
r_1185_1186_i 1185_1186 1186 93218.1
c_1185_1186_i 1185 1185_1186 2.08965e-09
r_1745_1746_e 1745 1746 13376.4
r_1745_1746_i 1745_1746 1746 93218.1
c_1745_1746_i 1745 1745_1746 2.08965e-09
r_2305_2306_e 2305 2306 13376.4
r_2305_2306_i 2305_2306 2306 93218.1
c_2305_2306_i 2305 2305_2306 2.08965e-09
r_2865_2866_e 2865 2866 13376.4
r_2865_2866_i 2865_2866 2866 93218.1
c_2865_2866_i 2865 2865_2866 2.08965e-09
r_3425_3426_e 3425 3426 13376.4
r_3425_3426_i 3425_3426 3426 93218.1
c_3425_3426_i 3425 3425_3426 2.08965e-09
r_66_67_e 66 67 13376.4
r_66_67_i 66_67 67 93218.1
c_66_67_i 66 66_67 2.08965e-09
r_626_627_e 626 627 13376.4
r_626_627_i 626_627 627 93218.1
c_626_627_i 626 626_627 2.08965e-09
r_1186_1187_e 1186 1187 13376.4
r_1186_1187_i 1186_1187 1187 93218.1
c_1186_1187_i 1186 1186_1187 2.08965e-09
r_1746_1747_e 1746 1747 13376.4
r_1746_1747_i 1746_1747 1747 93218.1
c_1746_1747_i 1746 1746_1747 2.08965e-09
r_2306_2307_e 2306 2307 13376.4
r_2306_2307_i 2306_2307 2307 93218.1
c_2306_2307_i 2306 2306_2307 2.08965e-09
r_2866_2867_e 2866 2867 13376.4
r_2866_2867_i 2866_2867 2867 93218.1
c_2866_2867_i 2866 2866_2867 2.08965e-09
r_3426_3427_e 3426 3427 13376.4
r_3426_3427_i 3426_3427 3427 93218.1
c_3426_3427_i 3426 3426_3427 2.08965e-09
r_67_68_e 67 68 13376.4
r_67_68_i 67_68 68 93218.1
c_67_68_i 67 67_68 2.08965e-09
r_627_628_e 627 628 13376.4
r_627_628_i 627_628 628 93218.1
c_627_628_i 627 627_628 2.08965e-09
r_1187_1188_e 1187 1188 836.944
r_1187_1188_i 1187_1188 1188 4256.89
c_1187_1188_i 1187 1187_1188 4.67522e-10
r_1747_1748_e 1747 1748 836.944
r_1747_1748_i 1747_1748 1748 4256.89
c_1747_1748_i 1747 1747_1748 4.67522e-10
r_2307_2308_e 2307 2308 836.944
r_2307_2308_i 2307_2308 2308 4256.89
c_2307_2308_i 2307 2307_2308 4.67522e-10
r_2867_2868_e 2867 2868 836.944
r_2867_2868_i 2867_2868 2868 4256.89
c_2867_2868_i 2867 2867_2868 4.67522e-10
r_3427_3428_e 3427 3428 836.944
r_3427_3428_i 3427_3428 3428 4256.89
c_3427_3428_i 3427 3427_3428 4.67522e-10
r_68_69_e 68 69 13376.4
r_68_69_i 68_69 69 93218.1
c_68_69_i 68 68_69 2.08965e-09
r_628_629_e 628 629 13376.4
r_628_629_i 628_629 629 93218.1
c_628_629_i 628 628_629 2.08965e-09
r_1188_1189_e 1188 1189 836.944
r_1188_1189_i 1188_1189 1189 4256.89
c_1188_1189_i 1188 1188_1189 4.67522e-10
r_1748_1749_e 1748 1749 836.944
r_1748_1749_i 1748_1749 1749 4256.89
c_1748_1749_i 1748 1748_1749 4.67522e-10
r_2308_2309_e 2308 2309 836.944
r_2308_2309_i 2308_2309 2309 4256.89
c_2308_2309_i 2308 2308_2309 4.67522e-10
r_2868_2869_e 2868 2869 13758.3
r_2868_2869_i 2868_2869 2869 95645.6
c_2868_2869_i 2868 2868_2869 9.36084e-12
r_3428_3429_e 3428 3429 13758.3
r_3428_3429_i 3428_3429 3429 95645.6
c_3428_3429_i 3428 3428_3429 9.36084e-12
r_69_70_e 69 70 13376.4
r_69_70_i 69_70 70 93218.1
c_69_70_i 69 69_70 2.08965e-09
r_629_630_e 629 630 13376.4
r_629_630_i 629_630 630 93218.1
c_629_630_i 629 629_630 2.08965e-09
r_1189_1190_e 1189 1190 836.944
r_1189_1190_i 1189_1190 1190 4256.89
c_1189_1190_i 1189 1189_1190 4.67522e-10
r_1749_1750_e 1749 1750 836.944
r_1749_1750_i 1749_1750 1750 4256.89
c_1749_1750_i 1749 1749_1750 4.67522e-10
r_2309_2310_e 2309 2310 836.944
r_2309_2310_i 2309_2310 2310 4256.89
c_2309_2310_i 2309 2309_2310 4.67522e-10
r_2869_2870_e 2869 2870 13758.3
r_2869_2870_i 2869_2870 2870 95645.6
c_2869_2870_i 2869 2869_2870 9.36084e-12
r_3429_3430_e 3429 3430 13758.3
r_3429_3430_i 3429_3430 3430 95645.6
c_3429_3430_i 3429 3429_3430 9.36084e-12
r_70_71_e 70 71 13376.4
r_70_71_i 70_71 71 93218.1
c_70_71_i 70 70_71 2.08965e-09
r_630_631_e 630 631 13376.4
r_630_631_i 630_631 631 93218.1
c_630_631_i 630 630_631 2.08965e-09
r_1190_1191_e 1190 1191 836.944
r_1190_1191_i 1190_1191 1191 4256.89
c_1190_1191_i 1190 1190_1191 4.67522e-10
r_1750_1751_e 1750 1751 836.944
r_1750_1751_i 1750_1751 1751 4256.89
c_1750_1751_i 1750 1750_1751 4.67522e-10
r_2310_2311_e 2310 2311 836.944
r_2310_2311_i 2310_2311 2311 4256.89
c_2310_2311_i 2310 2310_2311 4.67522e-10
r_2870_2871_e 2870 2871 13758.3
r_2870_2871_i 2870_2871 2871 95645.6
c_2870_2871_i 2870 2870_2871 9.36084e-12
r_3430_3431_e 3430 3431 13758.3
r_3430_3431_i 3430_3431 3431 95645.6
c_3430_3431_i 3430 3430_3431 9.36084e-12
r_71_72_e 71 72 13376.4
r_71_72_i 71_72 72 93218.1
c_71_72_i 71 71_72 2.08965e-09
r_631_632_e 631 632 13376.4
r_631_632_i 631_632 632 93218.1
c_631_632_i 631 631_632 2.08965e-09
r_1191_1192_e 1191 1192 836.944
r_1191_1192_i 1191_1192 1192 4256.89
c_1191_1192_i 1191 1191_1192 4.67522e-10
r_1751_1752_e 1751 1752 836.944
r_1751_1752_i 1751_1752 1752 4256.89
c_1751_1752_i 1751 1751_1752 4.67522e-10
r_2311_2312_e 2311 2312 836.944
r_2311_2312_i 2311_2312 2312 4256.89
c_2311_2312_i 2311 2311_2312 4.67522e-10
r_2871_2872_e 2871 2872 13758.3
r_2871_2872_i 2871_2872 2872 95645.6
c_2871_2872_i 2871 2871_2872 9.36084e-12
r_3431_3432_e 3431 3432 13758.3
r_3431_3432_i 3431_3432 3432 95645.6
c_3431_3432_i 3431 3431_3432 9.36084e-12
r_72_73_e 72 73 13376.4
r_72_73_i 72_73 73 93218.1
c_72_73_i 72 72_73 2.08965e-09
r_632_633_e 632 633 13376.4
r_632_633_i 632_633 633 93218.1
c_632_633_i 632 632_633 2.08965e-09
r_1192_1193_e 1192 1193 836.944
r_1192_1193_i 1192_1193 1193 4256.89
c_1192_1193_i 1192 1192_1193 4.67522e-10
r_1752_1753_e 1752 1753 836.944
r_1752_1753_i 1752_1753 1753 4256.89
c_1752_1753_i 1752 1752_1753 4.67522e-10
r_2312_2313_e 2312 2313 836.944
r_2312_2313_i 2312_2313 2313 4256.89
c_2312_2313_i 2312 2312_2313 4.67522e-10
r_2872_2873_e 2872 2873 13758.3
r_2872_2873_i 2872_2873 2873 95645.6
c_2872_2873_i 2872 2872_2873 9.36084e-12
r_3432_3433_e 3432 3433 13758.3
r_3432_3433_i 3432_3433 3433 95645.6
c_3432_3433_i 3432 3432_3433 9.36084e-12
r_73_74_e 73 74 13376.4
r_73_74_i 73_74 74 93218.1
c_73_74_i 73 73_74 2.08965e-09
r_633_634_e 633 634 13376.4
r_633_634_i 633_634 634 93218.1
c_633_634_i 633 633_634 2.08965e-09
r_1193_1194_e 1193 1194 836.944
r_1193_1194_i 1193_1194 1194 4256.89
c_1193_1194_i 1193 1193_1194 4.67522e-10
r_1753_1754_e 1753 1754 836.944
r_1753_1754_i 1753_1754 1754 4256.89
c_1753_1754_i 1753 1753_1754 4.67522e-10
r_2313_2314_e 2313 2314 836.944
r_2313_2314_i 2313_2314 2314 4256.89
c_2313_2314_i 2313 2313_2314 4.67522e-10
r_2873_2874_e 2873 2874 13758.3
r_2873_2874_i 2873_2874 2874 95645.6
c_2873_2874_i 2873 2873_2874 9.36084e-12
r_3433_3434_e 3433 3434 13758.3
r_3433_3434_i 3433_3434 3434 95645.6
c_3433_3434_i 3433 3433_3434 9.36084e-12
r_74_75_e 74 75 13376.4
r_74_75_i 74_75 75 93218.1
c_74_75_i 74 74_75 2.08965e-09
r_634_635_e 634 635 13376.4
r_634_635_i 634_635 635 93218.1
c_634_635_i 634 634_635 2.08965e-09
r_1194_1195_e 1194 1195 836.944
r_1194_1195_i 1194_1195 1195 4256.89
c_1194_1195_i 1194 1194_1195 4.67522e-10
r_1754_1755_e 1754 1755 836.944
r_1754_1755_i 1754_1755 1755 4256.89
c_1754_1755_i 1754 1754_1755 4.67522e-10
r_2314_2315_e 2314 2315 836.944
r_2314_2315_i 2314_2315 2315 4256.89
c_2314_2315_i 2314 2314_2315 4.67522e-10
r_2874_2875_e 2874 2875 13758.3
r_2874_2875_i 2874_2875 2875 95645.6
c_2874_2875_i 2874 2874_2875 9.36084e-12
r_3434_3435_e 3434 3435 13758.3
r_3434_3435_i 3434_3435 3435 95645.6
c_3434_3435_i 3434 3434_3435 9.36084e-12
r_75_76_e 75 76 13376.4
r_75_76_i 75_76 76 93218.1
c_75_76_i 75 75_76 2.08965e-09
r_635_636_e 635 636 13376.4
r_635_636_i 635_636 636 93218.1
c_635_636_i 635 635_636 2.08965e-09
r_1195_1196_e 1195 1196 396.742
r_1195_1196_i 1195_1196 1196 1005.38
c_1195_1196_i 1195 1195_1196 1.65777e-10
r_1755_1756_e 1755 1756 396.742
r_1755_1756_i 1755_1756 1756 1005.38
c_1755_1756_i 1755 1755_1756 1.65777e-10
r_2315_2316_e 2315 2316 836.944
r_2315_2316_i 2315_2316 2316 4256.89
c_2315_2316_i 2315 2315_2316 4.67522e-10
r_2875_2876_e 2875 2876 13758.3
r_2875_2876_i 2875_2876 2876 95645.6
c_2875_2876_i 2875 2875_2876 9.36084e-12
r_3435_3436_e 3435 3436 13758.3
r_3435_3436_i 3435_3436 3436 95645.6
c_3435_3436_i 3435 3435_3436 9.36084e-12
r_76_77_e 76 77 13376.4
r_76_77_i 76_77 77 93218.1
c_76_77_i 76 76_77 2.08965e-09
r_636_637_e 636 637 13376.4
r_636_637_i 636_637 637 93218.1
c_636_637_i 636 636_637 2.08965e-09
r_1196_1197_e 1196 1197 836.944
r_1196_1197_i 1196_1197 1197 4256.89
c_1196_1197_i 1196 1196_1197 4.67522e-10
r_1756_1757_e 1756 1757 836.944
r_1756_1757_i 1756_1757 1757 4256.89
c_1756_1757_i 1756 1756_1757 4.67522e-10
r_2316_2317_e 2316 2317 836.944
r_2316_2317_i 2316_2317 2317 4256.89
c_2316_2317_i 2316 2316_2317 4.67522e-10
r_2876_2877_e 2876 2877 13758.3
r_2876_2877_i 2876_2877 2877 95645.6
c_2876_2877_i 2876 2876_2877 9.36084e-12
r_3436_3437_e 3436 3437 13758.3
r_3436_3437_i 3436_3437 3437 95645.6
c_3436_3437_i 3436 3436_3437 9.36084e-12
r_77_78_e 77 78 13376.4
r_77_78_i 77_78 78 93218.1
c_77_78_i 77 77_78 2.08965e-09
r_637_638_e 637 638 13376.4
r_637_638_i 637_638 638 93218.1
c_637_638_i 637 637_638 2.08965e-09
r_1197_1198_e 1197 1198 836.944
r_1197_1198_i 1197_1198 1198 4256.89
c_1197_1198_i 1197 1197_1198 4.67522e-10
r_1757_1758_e 1757 1758 836.944
r_1757_1758_i 1757_1758 1758 4256.89
c_1757_1758_i 1757 1757_1758 4.67522e-10
r_2317_2318_e 2317 2318 836.944
r_2317_2318_i 2317_2318 2318 4256.89
c_2317_2318_i 2317 2317_2318 4.67522e-10
r_2877_2878_e 2877 2878 13758.3
r_2877_2878_i 2877_2878 2878 95645.6
c_2877_2878_i 2877 2877_2878 9.36084e-12
r_3437_3438_e 3437 3438 13758.3
r_3437_3438_i 3437_3438 3438 95645.6
c_3437_3438_i 3437 3437_3438 9.36084e-12
r_78_79_e 78 79 13376.4
r_78_79_i 78_79 79 93218.1
c_78_79_i 78 78_79 2.08965e-09
r_638_639_e 638 639 13376.4
r_638_639_i 638_639 639 93218.1
c_638_639_i 638 638_639 2.08965e-09
r_1198_1199_e 1198 1199 836.944
r_1198_1199_i 1198_1199 1199 4256.89
c_1198_1199_i 1198 1198_1199 4.67522e-10
r_1758_1759_e 1758 1759 836.944
r_1758_1759_i 1758_1759 1759 4256.89
c_1758_1759_i 1758 1758_1759 4.67522e-10
r_2318_2319_e 2318 2319 836.944
r_2318_2319_i 2318_2319 2319 4256.89
c_2318_2319_i 2318 2318_2319 4.67522e-10
r_2878_2879_e 2878 2879 13758.3
r_2878_2879_i 2878_2879 2879 95645.6
c_2878_2879_i 2878 2878_2879 9.36084e-12
r_3438_3439_e 3438 3439 13758.3
r_3438_3439_i 3438_3439 3439 95645.6
c_3438_3439_i 3438 3438_3439 9.36084e-12
r_79_80_e 79 80 13376.4
r_79_80_i 79_80 80 93218.1
c_79_80_i 79 79_80 2.08965e-09
r_639_640_e 639 640 13376.4
r_639_640_i 639_640 640 93218.1
c_639_640_i 639 639_640 2.08965e-09
r_1199_1200_e 1199 1200 836.944
r_1199_1200_i 1199_1200 1200 4256.89
c_1199_1200_i 1199 1199_1200 4.67522e-10
r_1759_1760_e 1759 1760 836.944
r_1759_1760_i 1759_1760 1760 4256.89
c_1759_1760_i 1759 1759_1760 4.67522e-10
r_2319_2320_e 2319 2320 836.944
r_2319_2320_i 2319_2320 2320 4256.89
c_2319_2320_i 2319 2319_2320 4.67522e-10
r_2879_2880_e 2879 2880 13758.3
r_2879_2880_i 2879_2880 2880 95645.6
c_2879_2880_i 2879 2879_2880 9.36084e-12
r_3439_3440_e 3439 3440 13758.3
r_3439_3440_i 3439_3440 3440 95645.6
c_3439_3440_i 3439 3439_3440 9.36084e-12
r_81_82_e 81 82 13376.4
r_81_82_i 81_82 82 93218.1
c_81_82_i 81 81_82 2.08965e-09
r_641_642_e 641 642 13376.4
r_641_642_i 641_642 642 93218.1
c_641_642_i 641 641_642 2.08965e-09
r_1201_1202_e 1201 1202 13376.4
r_1201_1202_i 1201_1202 1202 93218.1
c_1201_1202_i 1201 1201_1202 2.08965e-09
r_1761_1762_e 1761 1762 13376.4
r_1761_1762_i 1761_1762 1762 93218.1
c_1761_1762_i 1761 1761_1762 2.08965e-09
r_2321_2322_e 2321 2322 13376.4
r_2321_2322_i 2321_2322 2322 93218.1
c_2321_2322_i 2321 2321_2322 2.08965e-09
r_2881_2882_e 2881 2882 13376.4
r_2881_2882_i 2881_2882 2882 93218.1
c_2881_2882_i 2881 2881_2882 2.08965e-09
r_3441_3442_e 3441 3442 13376.4
r_3441_3442_i 3441_3442 3442 93218.1
c_3441_3442_i 3441 3441_3442 2.08965e-09
r_82_83_e 82 83 13376.4
r_82_83_i 82_83 83 93218.1
c_82_83_i 82 82_83 2.08965e-09
r_642_643_e 642 643 13376.4
r_642_643_i 642_643 643 93218.1
c_642_643_i 642 642_643 2.08965e-09
r_1202_1203_e 1202 1203 13376.4
r_1202_1203_i 1202_1203 1203 93218.1
c_1202_1203_i 1202 1202_1203 2.08965e-09
r_1762_1763_e 1762 1763 13376.4
r_1762_1763_i 1762_1763 1763 93218.1
c_1762_1763_i 1762 1762_1763 2.08965e-09
r_2322_2323_e 2322 2323 13376.4
r_2322_2323_i 2322_2323 2323 93218.1
c_2322_2323_i 2322 2322_2323 2.08965e-09
r_2882_2883_e 2882 2883 13376.4
r_2882_2883_i 2882_2883 2883 93218.1
c_2882_2883_i 2882 2882_2883 2.08965e-09
r_3442_3443_e 3442 3443 13376.4
r_3442_3443_i 3442_3443 3443 93218.1
c_3442_3443_i 3442 3442_3443 2.08965e-09
r_83_84_e 83 84 13376.4
r_83_84_i 83_84 84 93218.1
c_83_84_i 83 83_84 2.08965e-09
r_643_644_e 643 644 13376.4
r_643_644_i 643_644 644 93218.1
c_643_644_i 643 643_644 2.08965e-09
r_1203_1204_e 1203 1204 836.944
r_1203_1204_i 1203_1204 1204 4256.89
c_1203_1204_i 1203 1203_1204 4.67522e-10
r_1763_1764_e 1763 1764 836.944
r_1763_1764_i 1763_1764 1764 4256.89
c_1763_1764_i 1763 1763_1764 4.67522e-10
r_2323_2324_e 2323 2324 836.944
r_2323_2324_i 2323_2324 2324 4256.89
c_2323_2324_i 2323 2323_2324 4.67522e-10
r_2883_2884_e 2883 2884 836.944
r_2883_2884_i 2883_2884 2884 4256.89
c_2883_2884_i 2883 2883_2884 4.67522e-10
r_3443_3444_e 3443 3444 836.944
r_3443_3444_i 3443_3444 3444 4256.89
c_3443_3444_i 3443 3443_3444 4.67522e-10
r_84_85_e 84 85 13376.4
r_84_85_i 84_85 85 93218.1
c_84_85_i 84 84_85 2.08965e-09
r_644_645_e 644 645 13376.4
r_644_645_i 644_645 645 93218.1
c_644_645_i 644 644_645 2.08965e-09
r_1204_1205_e 1204 1205 836.944
r_1204_1205_i 1204_1205 1205 4256.89
c_1204_1205_i 1204 1204_1205 4.67522e-10
r_1764_1765_e 1764 1765 836.944
r_1764_1765_i 1764_1765 1765 4256.89
c_1764_1765_i 1764 1764_1765 4.67522e-10
r_2324_2325_e 2324 2325 836.944
r_2324_2325_i 2324_2325 2325 4256.89
c_2324_2325_i 2324 2324_2325 4.67522e-10
r_2884_2885_e 2884 2885 13758.3
r_2884_2885_i 2884_2885 2885 95645.6
c_2884_2885_i 2884 2884_2885 9.36084e-12
r_3444_3445_e 3444 3445 13758.3
r_3444_3445_i 3444_3445 3445 95645.6
c_3444_3445_i 3444 3444_3445 9.36084e-12
r_85_86_e 85 86 13376.4
r_85_86_i 85_86 86 93218.1
c_85_86_i 85 85_86 2.08965e-09
r_645_646_e 645 646 13376.4
r_645_646_i 645_646 646 93218.1
c_645_646_i 645 645_646 2.08965e-09
r_1205_1206_e 1205 1206 836.944
r_1205_1206_i 1205_1206 1206 4256.89
c_1205_1206_i 1205 1205_1206 4.67522e-10
r_1765_1766_e 1765 1766 836.944
r_1765_1766_i 1765_1766 1766 4256.89
c_1765_1766_i 1765 1765_1766 4.67522e-10
r_2325_2326_e 2325 2326 836.944
r_2325_2326_i 2325_2326 2326 4256.89
c_2325_2326_i 2325 2325_2326 4.67522e-10
r_2885_2886_e 2885 2886 13758.3
r_2885_2886_i 2885_2886 2886 95645.6
c_2885_2886_i 2885 2885_2886 9.36084e-12
r_3445_3446_e 3445 3446 13758.3
r_3445_3446_i 3445_3446 3446 95645.6
c_3445_3446_i 3445 3445_3446 9.36084e-12
r_86_87_e 86 87 13376.4
r_86_87_i 86_87 87 93218.1
c_86_87_i 86 86_87 2.08965e-09
r_646_647_e 646 647 13376.4
r_646_647_i 646_647 647 93218.1
c_646_647_i 646 646_647 2.08965e-09
r_1206_1207_e 1206 1207 836.944
r_1206_1207_i 1206_1207 1207 4256.89
c_1206_1207_i 1206 1206_1207 4.67522e-10
r_1766_1767_e 1766 1767 836.944
r_1766_1767_i 1766_1767 1767 4256.89
c_1766_1767_i 1766 1766_1767 4.67522e-10
r_2326_2327_e 2326 2327 836.944
r_2326_2327_i 2326_2327 2327 4256.89
c_2326_2327_i 2326 2326_2327 4.67522e-10
r_2886_2887_e 2886 2887 13758.3
r_2886_2887_i 2886_2887 2887 95645.6
c_2886_2887_i 2886 2886_2887 9.36084e-12
r_3446_3447_e 3446 3447 13758.3
r_3446_3447_i 3446_3447 3447 95645.6
c_3446_3447_i 3446 3446_3447 9.36084e-12
r_87_88_e 87 88 13376.4
r_87_88_i 87_88 88 93218.1
c_87_88_i 87 87_88 2.08965e-09
r_647_648_e 647 648 13376.4
r_647_648_i 647_648 648 93218.1
c_647_648_i 647 647_648 2.08965e-09
r_1207_1208_e 1207 1208 836.944
r_1207_1208_i 1207_1208 1208 4256.89
c_1207_1208_i 1207 1207_1208 4.67522e-10
r_1767_1768_e 1767 1768 836.944
r_1767_1768_i 1767_1768 1768 4256.89
c_1767_1768_i 1767 1767_1768 4.67522e-10
r_2327_2328_e 2327 2328 836.944
r_2327_2328_i 2327_2328 2328 4256.89
c_2327_2328_i 2327 2327_2328 4.67522e-10
r_2887_2888_e 2887 2888 13758.3
r_2887_2888_i 2887_2888 2888 95645.6
c_2887_2888_i 2887 2887_2888 9.36084e-12
r_3447_3448_e 3447 3448 13758.3
r_3447_3448_i 3447_3448 3448 95645.6
c_3447_3448_i 3447 3447_3448 9.36084e-12
r_88_89_e 88 89 13376.4
r_88_89_i 88_89 89 93218.1
c_88_89_i 88 88_89 2.08965e-09
r_648_649_e 648 649 13376.4
r_648_649_i 648_649 649 93218.1
c_648_649_i 648 648_649 2.08965e-09
r_1208_1209_e 1208 1209 836.944
r_1208_1209_i 1208_1209 1209 4256.89
c_1208_1209_i 1208 1208_1209 4.67522e-10
r_1768_1769_e 1768 1769 836.944
r_1768_1769_i 1768_1769 1769 4256.89
c_1768_1769_i 1768 1768_1769 4.67522e-10
r_2328_2329_e 2328 2329 836.944
r_2328_2329_i 2328_2329 2329 4256.89
c_2328_2329_i 2328 2328_2329 4.67522e-10
r_2888_2889_e 2888 2889 13758.3
r_2888_2889_i 2888_2889 2889 95645.6
c_2888_2889_i 2888 2888_2889 9.36084e-12
r_3448_3449_e 3448 3449 13758.3
r_3448_3449_i 3448_3449 3449 95645.6
c_3448_3449_i 3448 3448_3449 9.36084e-12
r_89_90_e 89 90 13376.4
r_89_90_i 89_90 90 93218.1
c_89_90_i 89 89_90 2.08965e-09
r_649_650_e 649 650 13376.4
r_649_650_i 649_650 650 93218.1
c_649_650_i 649 649_650 2.08965e-09
r_1209_1210_e 1209 1210 836.944
r_1209_1210_i 1209_1210 1210 4256.89
c_1209_1210_i 1209 1209_1210 4.67522e-10
r_1769_1770_e 1769 1770 836.944
r_1769_1770_i 1769_1770 1770 4256.89
c_1769_1770_i 1769 1769_1770 4.67522e-10
r_2329_2330_e 2329 2330 836.944
r_2329_2330_i 2329_2330 2330 4256.89
c_2329_2330_i 2329 2329_2330 4.67522e-10
r_2889_2890_e 2889 2890 13758.3
r_2889_2890_i 2889_2890 2890 95645.6
c_2889_2890_i 2889 2889_2890 9.36084e-12
r_3449_3450_e 3449 3450 13758.3
r_3449_3450_i 3449_3450 3450 95645.6
c_3449_3450_i 3449 3449_3450 9.36084e-12
r_90_91_e 90 91 13376.4
r_90_91_i 90_91 91 93218.1
c_90_91_i 90 90_91 2.08965e-09
r_650_651_e 650 651 13376.4
r_650_651_i 650_651 651 93218.1
c_650_651_i 650 650_651 2.08965e-09
r_1210_1211_e 1210 1211 836.944
r_1210_1211_i 1210_1211 1211 4256.89
c_1210_1211_i 1210 1210_1211 4.67522e-10
r_1770_1771_e 1770 1771 836.944
r_1770_1771_i 1770_1771 1771 4256.89
c_1770_1771_i 1770 1770_1771 4.67522e-10
r_2330_2331_e 2330 2331 836.944
r_2330_2331_i 2330_2331 2331 4256.89
c_2330_2331_i 2330 2330_2331 4.67522e-10
r_2890_2891_e 2890 2891 13758.3
r_2890_2891_i 2890_2891 2891 95645.6
c_2890_2891_i 2890 2890_2891 9.36084e-12
r_3450_3451_e 3450 3451 13758.3
r_3450_3451_i 3450_3451 3451 95645.6
c_3450_3451_i 3450 3450_3451 9.36084e-12
r_91_92_e 91 92 13376.4
r_91_92_i 91_92 92 93218.1
c_91_92_i 91 91_92 2.08965e-09
r_651_652_e 651 652 13376.4
r_651_652_i 651_652 652 93218.1
c_651_652_i 651 651_652 2.08965e-09
r_1211_1212_e 1211 1212 396.733
r_1211_1212_i 1211_1212 1212 1005.36
c_1211_1212_i 1211 1211_1212 1.65781e-10
r_1771_1772_e 1771 1772 396.733
r_1771_1772_i 1771_1772 1772 1005.36
c_1771_1772_i 1771 1771_1772 1.65781e-10
r_2331_2332_e 2331 2332 836.944
r_2331_2332_i 2331_2332 2332 4256.89
c_2331_2332_i 2331 2331_2332 4.67522e-10
r_2891_2892_e 2891 2892 13758.3
r_2891_2892_i 2891_2892 2892 95645.6
c_2891_2892_i 2891 2891_2892 9.36084e-12
r_3451_3452_e 3451 3452 13758.3
r_3451_3452_i 3451_3452 3452 95645.6
c_3451_3452_i 3451 3451_3452 9.36084e-12
r_92_93_e 92 93 13376.4
r_92_93_i 92_93 93 93218.1
c_92_93_i 92 92_93 2.08965e-09
r_652_653_e 652 653 13376.4
r_652_653_i 652_653 653 93218.1
c_652_653_i 652 652_653 2.08965e-09
r_1212_1213_e 1212 1213 836.944
r_1212_1213_i 1212_1213 1213 4256.89
c_1212_1213_i 1212 1212_1213 4.67522e-10
r_1772_1773_e 1772 1773 836.944
r_1772_1773_i 1772_1773 1773 4256.89
c_1772_1773_i 1772 1772_1773 4.67522e-10
r_2332_2333_e 2332 2333 836.944
r_2332_2333_i 2332_2333 2333 4256.89
c_2332_2333_i 2332 2332_2333 4.67522e-10
r_2892_2893_e 2892 2893 13758.3
r_2892_2893_i 2892_2893 2893 95645.6
c_2892_2893_i 2892 2892_2893 9.36084e-12
r_3452_3453_e 3452 3453 13758.3
r_3452_3453_i 3452_3453 3453 95645.6
c_3452_3453_i 3452 3452_3453 9.36084e-12
r_93_94_e 93 94 13376.4
r_93_94_i 93_94 94 93218.1
c_93_94_i 93 93_94 2.08965e-09
r_653_654_e 653 654 13376.4
r_653_654_i 653_654 654 93218.1
c_653_654_i 653 653_654 2.08965e-09
r_1213_1214_e 1213 1214 836.944
r_1213_1214_i 1213_1214 1214 4256.89
c_1213_1214_i 1213 1213_1214 4.67522e-10
r_1773_1774_e 1773 1774 836.944
r_1773_1774_i 1773_1774 1774 4256.89
c_1773_1774_i 1773 1773_1774 4.67522e-10
r_2333_2334_e 2333 2334 836.944
r_2333_2334_i 2333_2334 2334 4256.89
c_2333_2334_i 2333 2333_2334 4.67522e-10
r_2893_2894_e 2893 2894 13758.3
r_2893_2894_i 2893_2894 2894 95645.6
c_2893_2894_i 2893 2893_2894 9.36084e-12
r_3453_3454_e 3453 3454 13758.3
r_3453_3454_i 3453_3454 3454 95645.6
c_3453_3454_i 3453 3453_3454 9.36084e-12
r_94_95_e 94 95 13376.4
r_94_95_i 94_95 95 93218.1
c_94_95_i 94 94_95 2.08965e-09
r_654_655_e 654 655 13376.4
r_654_655_i 654_655 655 93218.1
c_654_655_i 654 654_655 2.08965e-09
r_1214_1215_e 1214 1215 836.944
r_1214_1215_i 1214_1215 1215 4256.89
c_1214_1215_i 1214 1214_1215 4.67522e-10
r_1774_1775_e 1774 1775 836.944
r_1774_1775_i 1774_1775 1775 4256.89
c_1774_1775_i 1774 1774_1775 4.67522e-10
r_2334_2335_e 2334 2335 836.944
r_2334_2335_i 2334_2335 2335 4256.89
c_2334_2335_i 2334 2334_2335 4.67522e-10
r_2894_2895_e 2894 2895 13758.3
r_2894_2895_i 2894_2895 2895 95645.6
c_2894_2895_i 2894 2894_2895 9.36084e-12
r_3454_3455_e 3454 3455 13758.3
r_3454_3455_i 3454_3455 3455 95645.6
c_3454_3455_i 3454 3454_3455 9.36084e-12
r_95_96_e 95 96 13376.4
r_95_96_i 95_96 96 93218.1
c_95_96_i 95 95_96 2.08965e-09
r_655_656_e 655 656 13376.4
r_655_656_i 655_656 656 93218.1
c_655_656_i 655 655_656 2.08965e-09
r_1215_1216_e 1215 1216 836.944
r_1215_1216_i 1215_1216 1216 4256.89
c_1215_1216_i 1215 1215_1216 4.67522e-10
r_1775_1776_e 1775 1776 836.944
r_1775_1776_i 1775_1776 1776 4256.89
c_1775_1776_i 1775 1775_1776 4.67522e-10
r_2335_2336_e 2335 2336 836.944
r_2335_2336_i 2335_2336 2336 4256.89
c_2335_2336_i 2335 2335_2336 4.67522e-10
r_2895_2896_e 2895 2896 13758.3
r_2895_2896_i 2895_2896 2896 95645.6
c_2895_2896_i 2895 2895_2896 9.36084e-12
r_3455_3456_e 3455 3456 13758.3
r_3455_3456_i 3455_3456 3456 95645.6
c_3455_3456_i 3455 3455_3456 9.36084e-12
r_97_98_e 97 98 13376.4
r_97_98_i 97_98 98 93218.1
c_97_98_i 97 97_98 2.08965e-09
r_657_658_e 657 658 13376.4
r_657_658_i 657_658 658 93218.1
c_657_658_i 657 657_658 2.08965e-09
r_1217_1218_e 1217 1218 13376.4
r_1217_1218_i 1217_1218 1218 93218.1
c_1217_1218_i 1217 1217_1218 2.08965e-09
r_1777_1778_e 1777 1778 13376.4
r_1777_1778_i 1777_1778 1778 93218.1
c_1777_1778_i 1777 1777_1778 2.08965e-09
r_2337_2338_e 2337 2338 13376.4
r_2337_2338_i 2337_2338 2338 93218.1
c_2337_2338_i 2337 2337_2338 2.08965e-09
r_2897_2898_e 2897 2898 13376.4
r_2897_2898_i 2897_2898 2898 93218.1
c_2897_2898_i 2897 2897_2898 2.08965e-09
r_3457_3458_e 3457 3458 13376.4
r_3457_3458_i 3457_3458 3458 93218.1
c_3457_3458_i 3457 3457_3458 2.08965e-09
r_98_99_e 98 99 13376.4
r_98_99_i 98_99 99 93218.1
c_98_99_i 98 98_99 2.08965e-09
r_658_659_e 658 659 13376.4
r_658_659_i 658_659 659 93218.1
c_658_659_i 658 658_659 2.08965e-09
r_1218_1219_e 1218 1219 13376.4
r_1218_1219_i 1218_1219 1219 93218.1
c_1218_1219_i 1218 1218_1219 2.08965e-09
r_1778_1779_e 1778 1779 13376.4
r_1778_1779_i 1778_1779 1779 93218.1
c_1778_1779_i 1778 1778_1779 2.08965e-09
r_2338_2339_e 2338 2339 13376.4
r_2338_2339_i 2338_2339 2339 93218.1
c_2338_2339_i 2338 2338_2339 2.08965e-09
r_2898_2899_e 2898 2899 13376.4
r_2898_2899_i 2898_2899 2899 93218.1
c_2898_2899_i 2898 2898_2899 2.08965e-09
r_3458_3459_e 3458 3459 13376.4
r_3458_3459_i 3458_3459 3459 93218.1
c_3458_3459_i 3458 3458_3459 2.08965e-09
r_99_100_e 99 100 13376.4
r_99_100_i 99_100 100 93218.1
c_99_100_i 99 99_100 2.08965e-09
r_659_660_e 659 660 13376.4
r_659_660_i 659_660 660 93218.1
c_659_660_i 659 659_660 2.08965e-09
r_1219_1220_e 1219 1220 836.944
r_1219_1220_i 1219_1220 1220 4256.89
c_1219_1220_i 1219 1219_1220 4.67522e-10
r_1779_1780_e 1779 1780 836.944
r_1779_1780_i 1779_1780 1780 4256.89
c_1779_1780_i 1779 1779_1780 4.67522e-10
r_2339_2340_e 2339 2340 836.944
r_2339_2340_i 2339_2340 2340 4256.89
c_2339_2340_i 2339 2339_2340 4.67522e-10
r_2899_2900_e 2899 2900 836.944
r_2899_2900_i 2899_2900 2900 4256.89
c_2899_2900_i 2899 2899_2900 4.67522e-10
r_3459_3460_e 3459 3460 836.944
r_3459_3460_i 3459_3460 3460 4256.89
c_3459_3460_i 3459 3459_3460 4.67522e-10
r_100_101_e 100 101 13376.4
r_100_101_i 100_101 101 93218.1
c_100_101_i 100 100_101 2.08965e-09
r_660_661_e 660 661 13376.4
r_660_661_i 660_661 661 93218.1
c_660_661_i 660 660_661 2.08965e-09
r_1220_1221_e 1220 1221 836.944
r_1220_1221_i 1220_1221 1221 4256.89
c_1220_1221_i 1220 1220_1221 4.67522e-10
r_1780_1781_e 1780 1781 836.944
r_1780_1781_i 1780_1781 1781 4256.89
c_1780_1781_i 1780 1780_1781 4.67522e-10
r_2340_2341_e 2340 2341 836.944
r_2340_2341_i 2340_2341 2341 4256.89
c_2340_2341_i 2340 2340_2341 4.67522e-10
r_2900_2901_e 2900 2901 13758.3
r_2900_2901_i 2900_2901 2901 95645.6
c_2900_2901_i 2900 2900_2901 9.36084e-12
r_3460_3461_e 3460 3461 13758.3
r_3460_3461_i 3460_3461 3461 95645.6
c_3460_3461_i 3460 3460_3461 9.36084e-12
r_101_102_e 101 102 13376.4
r_101_102_i 101_102 102 93218.1
c_101_102_i 101 101_102 2.08965e-09
r_661_662_e 661 662 13376.4
r_661_662_i 661_662 662 93218.1
c_661_662_i 661 661_662 2.08965e-09
r_1221_1222_e 1221 1222 836.944
r_1221_1222_i 1221_1222 1222 4256.89
c_1221_1222_i 1221 1221_1222 4.67522e-10
r_1781_1782_e 1781 1782 836.944
r_1781_1782_i 1781_1782 1782 4256.89
c_1781_1782_i 1781 1781_1782 4.67522e-10
r_2341_2342_e 2341 2342 836.944
r_2341_2342_i 2341_2342 2342 4256.89
c_2341_2342_i 2341 2341_2342 4.67522e-10
r_2901_2902_e 2901 2902 13758.3
r_2901_2902_i 2901_2902 2902 95645.6
c_2901_2902_i 2901 2901_2902 9.36084e-12
r_3461_3462_e 3461 3462 13758.3
r_3461_3462_i 3461_3462 3462 95645.6
c_3461_3462_i 3461 3461_3462 9.36084e-12
r_102_103_e 102 103 13376.4
r_102_103_i 102_103 103 93218.1
c_102_103_i 102 102_103 2.08965e-09
r_662_663_e 662 663 13376.4
r_662_663_i 662_663 663 93218.1
c_662_663_i 662 662_663 2.08965e-09
r_1222_1223_e 1222 1223 836.944
r_1222_1223_i 1222_1223 1223 4256.89
c_1222_1223_i 1222 1222_1223 4.67522e-10
r_1782_1783_e 1782 1783 836.944
r_1782_1783_i 1782_1783 1783 4256.89
c_1782_1783_i 1782 1782_1783 4.67522e-10
r_2342_2343_e 2342 2343 836.944
r_2342_2343_i 2342_2343 2343 4256.89
c_2342_2343_i 2342 2342_2343 4.67522e-10
r_2902_2903_e 2902 2903 13758.3
r_2902_2903_i 2902_2903 2903 95645.6
c_2902_2903_i 2902 2902_2903 9.36084e-12
r_3462_3463_e 3462 3463 13758.3
r_3462_3463_i 3462_3463 3463 95645.6
c_3462_3463_i 3462 3462_3463 9.36084e-12
r_103_104_e 103 104 13376.4
r_103_104_i 103_104 104 93218.1
c_103_104_i 103 103_104 2.08965e-09
r_663_664_e 663 664 13376.4
r_663_664_i 663_664 664 93218.1
c_663_664_i 663 663_664 2.08965e-09
r_1223_1224_e 1223 1224 836.944
r_1223_1224_i 1223_1224 1224 4256.89
c_1223_1224_i 1223 1223_1224 4.67522e-10
r_1783_1784_e 1783 1784 836.944
r_1783_1784_i 1783_1784 1784 4256.89
c_1783_1784_i 1783 1783_1784 4.67522e-10
r_2343_2344_e 2343 2344 836.944
r_2343_2344_i 2343_2344 2344 4256.89
c_2343_2344_i 2343 2343_2344 4.67522e-10
r_2903_2904_e 2903 2904 13758.3
r_2903_2904_i 2903_2904 2904 95645.6
c_2903_2904_i 2903 2903_2904 9.36084e-12
r_3463_3464_e 3463 3464 13758.3
r_3463_3464_i 3463_3464 3464 95645.6
c_3463_3464_i 3463 3463_3464 9.36084e-12
r_104_105_e 104 105 13376.4
r_104_105_i 104_105 105 93218.1
c_104_105_i 104 104_105 2.08965e-09
r_664_665_e 664 665 13376.4
r_664_665_i 664_665 665 93218.1
c_664_665_i 664 664_665 2.08965e-09
r_1224_1225_e 1224 1225 836.944
r_1224_1225_i 1224_1225 1225 4256.89
c_1224_1225_i 1224 1224_1225 4.67522e-10
r_1784_1785_e 1784 1785 836.944
r_1784_1785_i 1784_1785 1785 4256.89
c_1784_1785_i 1784 1784_1785 4.67522e-10
r_2344_2345_e 2344 2345 836.944
r_2344_2345_i 2344_2345 2345 4256.89
c_2344_2345_i 2344 2344_2345 4.67522e-10
r_2904_2905_e 2904 2905 13758.3
r_2904_2905_i 2904_2905 2905 95645.6
c_2904_2905_i 2904 2904_2905 9.36084e-12
r_3464_3465_e 3464 3465 13758.3
r_3464_3465_i 3464_3465 3465 95645.6
c_3464_3465_i 3464 3464_3465 9.36084e-12
r_105_106_e 105 106 13376.4
r_105_106_i 105_106 106 93218.1
c_105_106_i 105 105_106 2.08965e-09
r_665_666_e 665 666 13376.4
r_665_666_i 665_666 666 93218.1
c_665_666_i 665 665_666 2.08965e-09
r_1225_1226_e 1225 1226 836.944
r_1225_1226_i 1225_1226 1226 4256.89
c_1225_1226_i 1225 1225_1226 4.67522e-10
r_1785_1786_e 1785 1786 836.944
r_1785_1786_i 1785_1786 1786 4256.89
c_1785_1786_i 1785 1785_1786 4.67522e-10
r_2345_2346_e 2345 2346 836.944
r_2345_2346_i 2345_2346 2346 4256.89
c_2345_2346_i 2345 2345_2346 4.67522e-10
r_2905_2906_e 2905 2906 13758.3
r_2905_2906_i 2905_2906 2906 95645.6
c_2905_2906_i 2905 2905_2906 9.36084e-12
r_3465_3466_e 3465 3466 13758.3
r_3465_3466_i 3465_3466 3466 95645.6
c_3465_3466_i 3465 3465_3466 9.36084e-12
r_106_107_e 106 107 13376.4
r_106_107_i 106_107 107 93218.1
c_106_107_i 106 106_107 2.08965e-09
r_666_667_e 666 667 13376.4
r_666_667_i 666_667 667 93218.1
c_666_667_i 666 666_667 2.08965e-09
r_1226_1227_e 1226 1227 836.944
r_1226_1227_i 1226_1227 1227 4256.89
c_1226_1227_i 1226 1226_1227 4.67522e-10
r_1786_1787_e 1786 1787 836.944
r_1786_1787_i 1786_1787 1787 4256.89
c_1786_1787_i 1786 1786_1787 4.67522e-10
r_2346_2347_e 2346 2347 836.944
r_2346_2347_i 2346_2347 2347 4256.89
c_2346_2347_i 2346 2346_2347 4.67522e-10
r_2906_2907_e 2906 2907 13758.3
r_2906_2907_i 2906_2907 2907 95645.6
c_2906_2907_i 2906 2906_2907 9.36084e-12
r_3466_3467_e 3466 3467 13758.3
r_3466_3467_i 3466_3467 3467 95645.6
c_3466_3467_i 3466 3466_3467 9.36084e-12
r_107_108_e 107 108 13376.4
r_107_108_i 107_108 108 93218.1
c_107_108_i 107 107_108 2.08965e-09
r_667_668_e 667 668 13376.4
r_667_668_i 667_668 668 93218.1
c_667_668_i 667 667_668 2.08965e-09
r_1227_1228_e 1227 1228 396.724
r_1227_1228_i 1227_1228 1228 1005.34
c_1227_1228_i 1227 1227_1228 1.65785e-10
r_1787_1788_e 1787 1788 396.724
r_1787_1788_i 1787_1788 1788 1005.34
c_1787_1788_i 1787 1787_1788 1.65785e-10
r_2347_2348_e 2347 2348 836.944
r_2347_2348_i 2347_2348 2348 4256.89
c_2347_2348_i 2347 2347_2348 4.67522e-10
r_2907_2908_e 2907 2908 13758.3
r_2907_2908_i 2907_2908 2908 95645.6
c_2907_2908_i 2907 2907_2908 9.36084e-12
r_3467_3468_e 3467 3468 13758.3
r_3467_3468_i 3467_3468 3468 95645.6
c_3467_3468_i 3467 3467_3468 9.36084e-12
r_108_109_e 108 109 13376.4
r_108_109_i 108_109 109 93218.1
c_108_109_i 108 108_109 2.08965e-09
r_668_669_e 668 669 13376.4
r_668_669_i 668_669 669 93218.1
c_668_669_i 668 668_669 2.08965e-09
r_1228_1229_e 1228 1229 836.944
r_1228_1229_i 1228_1229 1229 4256.89
c_1228_1229_i 1228 1228_1229 4.67522e-10
r_1788_1789_e 1788 1789 836.944
r_1788_1789_i 1788_1789 1789 4256.89
c_1788_1789_i 1788 1788_1789 4.67522e-10
r_2348_2349_e 2348 2349 836.944
r_2348_2349_i 2348_2349 2349 4256.89
c_2348_2349_i 2348 2348_2349 4.67522e-10
r_2908_2909_e 2908 2909 13758.3
r_2908_2909_i 2908_2909 2909 95645.6
c_2908_2909_i 2908 2908_2909 9.36084e-12
r_3468_3469_e 3468 3469 13758.3
r_3468_3469_i 3468_3469 3469 95645.6
c_3468_3469_i 3468 3468_3469 9.36084e-12
r_109_110_e 109 110 13376.4
r_109_110_i 109_110 110 93218.1
c_109_110_i 109 109_110 2.08965e-09
r_669_670_e 669 670 13376.4
r_669_670_i 669_670 670 93218.1
c_669_670_i 669 669_670 2.08965e-09
r_1229_1230_e 1229 1230 836.944
r_1229_1230_i 1229_1230 1230 4256.89
c_1229_1230_i 1229 1229_1230 4.67522e-10
r_1789_1790_e 1789 1790 836.944
r_1789_1790_i 1789_1790 1790 4256.89
c_1789_1790_i 1789 1789_1790 4.67522e-10
r_2349_2350_e 2349 2350 836.944
r_2349_2350_i 2349_2350 2350 4256.89
c_2349_2350_i 2349 2349_2350 4.67522e-10
r_2909_2910_e 2909 2910 13758.3
r_2909_2910_i 2909_2910 2910 95645.6
c_2909_2910_i 2909 2909_2910 9.36084e-12
r_3469_3470_e 3469 3470 13758.3
r_3469_3470_i 3469_3470 3470 95645.6
c_3469_3470_i 3469 3469_3470 9.36084e-12
r_110_111_e 110 111 13376.4
r_110_111_i 110_111 111 93218.1
c_110_111_i 110 110_111 2.08965e-09
r_670_671_e 670 671 13376.4
r_670_671_i 670_671 671 93218.1
c_670_671_i 670 670_671 2.08965e-09
r_1230_1231_e 1230 1231 836.944
r_1230_1231_i 1230_1231 1231 4256.89
c_1230_1231_i 1230 1230_1231 4.67522e-10
r_1790_1791_e 1790 1791 836.944
r_1790_1791_i 1790_1791 1791 4256.89
c_1790_1791_i 1790 1790_1791 4.67522e-10
r_2350_2351_e 2350 2351 836.944
r_2350_2351_i 2350_2351 2351 4256.89
c_2350_2351_i 2350 2350_2351 4.67522e-10
r_2910_2911_e 2910 2911 13758.3
r_2910_2911_i 2910_2911 2911 95645.6
c_2910_2911_i 2910 2910_2911 9.36084e-12
r_3470_3471_e 3470 3471 13758.3
r_3470_3471_i 3470_3471 3471 95645.6
c_3470_3471_i 3470 3470_3471 9.36084e-12
r_111_112_e 111 112 13376.4
r_111_112_i 111_112 112 93218.1
c_111_112_i 111 111_112 2.08965e-09
r_671_672_e 671 672 13376.4
r_671_672_i 671_672 672 93218.1
c_671_672_i 671 671_672 2.08965e-09
r_1231_1232_e 1231 1232 836.944
r_1231_1232_i 1231_1232 1232 4256.89
c_1231_1232_i 1231 1231_1232 4.67522e-10
r_1791_1792_e 1791 1792 836.944
r_1791_1792_i 1791_1792 1792 4256.89
c_1791_1792_i 1791 1791_1792 4.67522e-10
r_2351_2352_e 2351 2352 836.944
r_2351_2352_i 2351_2352 2352 4256.89
c_2351_2352_i 2351 2351_2352 4.67522e-10
r_2911_2912_e 2911 2912 13758.3
r_2911_2912_i 2911_2912 2912 95645.6
c_2911_2912_i 2911 2911_2912 9.36084e-12
r_3471_3472_e 3471 3472 13758.3
r_3471_3472_i 3471_3472 3472 95645.6
c_3471_3472_i 3471 3471_3472 9.36084e-12
r_113_114_e 113 114 13376.4
r_113_114_i 113_114 114 93218.1
c_113_114_i 113 113_114 2.08965e-09
r_673_674_e 673 674 13376.4
r_673_674_i 673_674 674 93218.1
c_673_674_i 673 673_674 2.08965e-09
r_1233_1234_e 1233 1234 13376.4
r_1233_1234_i 1233_1234 1234 93218.1
c_1233_1234_i 1233 1233_1234 2.08965e-09
r_1793_1794_e 1793 1794 13376.4
r_1793_1794_i 1793_1794 1794 93218.1
c_1793_1794_i 1793 1793_1794 2.08965e-09
r_2353_2354_e 2353 2354 13376.4
r_2353_2354_i 2353_2354 2354 93218.1
c_2353_2354_i 2353 2353_2354 2.08965e-09
r_2913_2914_e 2913 2914 13376.4
r_2913_2914_i 2913_2914 2914 93218.1
c_2913_2914_i 2913 2913_2914 2.08965e-09
r_3473_3474_e 3473 3474 13376.4
r_3473_3474_i 3473_3474 3474 93218.1
c_3473_3474_i 3473 3473_3474 2.08965e-09
r_114_115_e 114 115 13376.4
r_114_115_i 114_115 115 93218.1
c_114_115_i 114 114_115 2.08965e-09
r_674_675_e 674 675 13376.4
r_674_675_i 674_675 675 93218.1
c_674_675_i 674 674_675 2.08965e-09
r_1234_1235_e 1234 1235 13376.4
r_1234_1235_i 1234_1235 1235 93218.1
c_1234_1235_i 1234 1234_1235 2.08965e-09
r_1794_1795_e 1794 1795 13376.4
r_1794_1795_i 1794_1795 1795 93218.1
c_1794_1795_i 1794 1794_1795 2.08965e-09
r_2354_2355_e 2354 2355 13376.4
r_2354_2355_i 2354_2355 2355 93218.1
c_2354_2355_i 2354 2354_2355 2.08965e-09
r_2914_2915_e 2914 2915 13376.4
r_2914_2915_i 2914_2915 2915 93218.1
c_2914_2915_i 2914 2914_2915 2.08965e-09
r_3474_3475_e 3474 3475 13376.4
r_3474_3475_i 3474_3475 3475 93218.1
c_3474_3475_i 3474 3474_3475 2.08965e-09
r_115_116_e 115 116 13376.4
r_115_116_i 115_116 116 93218.1
c_115_116_i 115 115_116 2.08965e-09
r_675_676_e 675 676 13376.4
r_675_676_i 675_676 676 93218.1
c_675_676_i 675 675_676 2.08965e-09
r_1235_1236_e 1235 1236 836.944
r_1235_1236_i 1235_1236 1236 4256.89
c_1235_1236_i 1235 1235_1236 4.67522e-10
r_1795_1796_e 1795 1796 836.944
r_1795_1796_i 1795_1796 1796 4256.89
c_1795_1796_i 1795 1795_1796 4.67522e-10
r_2355_2356_e 2355 2356 836.944
r_2355_2356_i 2355_2356 2356 4256.89
c_2355_2356_i 2355 2355_2356 4.67522e-10
r_2915_2916_e 2915 2916 836.944
r_2915_2916_i 2915_2916 2916 4256.89
c_2915_2916_i 2915 2915_2916 4.67522e-10
r_3475_3476_e 3475 3476 836.944
r_3475_3476_i 3475_3476 3476 4256.89
c_3475_3476_i 3475 3475_3476 4.67522e-10
r_116_117_e 116 117 13376.4
r_116_117_i 116_117 117 93218.1
c_116_117_i 116 116_117 2.08965e-09
r_676_677_e 676 677 13376.4
r_676_677_i 676_677 677 93218.1
c_676_677_i 676 676_677 2.08965e-09
r_1236_1237_e 1236 1237 836.944
r_1236_1237_i 1236_1237 1237 4256.89
c_1236_1237_i 1236 1236_1237 4.67522e-10
r_1796_1797_e 1796 1797 836.944
r_1796_1797_i 1796_1797 1797 4256.89
c_1796_1797_i 1796 1796_1797 4.67522e-10
r_2356_2357_e 2356 2357 836.944
r_2356_2357_i 2356_2357 2357 4256.89
c_2356_2357_i 2356 2356_2357 4.67522e-10
r_2916_2917_e 2916 2917 13758.3
r_2916_2917_i 2916_2917 2917 95645.6
c_2916_2917_i 2916 2916_2917 9.36084e-12
r_3476_3477_e 3476 3477 13758.3
r_3476_3477_i 3476_3477 3477 95645.6
c_3476_3477_i 3476 3476_3477 9.36084e-12
r_117_118_e 117 118 13376.4
r_117_118_i 117_118 118 93218.1
c_117_118_i 117 117_118 2.08965e-09
r_677_678_e 677 678 13376.4
r_677_678_i 677_678 678 93218.1
c_677_678_i 677 677_678 2.08965e-09
r_1237_1238_e 1237 1238 836.944
r_1237_1238_i 1237_1238 1238 4256.89
c_1237_1238_i 1237 1237_1238 4.67522e-10
r_1797_1798_e 1797 1798 836.944
r_1797_1798_i 1797_1798 1798 4256.89
c_1797_1798_i 1797 1797_1798 4.67522e-10
r_2357_2358_e 2357 2358 836.944
r_2357_2358_i 2357_2358 2358 4256.89
c_2357_2358_i 2357 2357_2358 4.67522e-10
r_2917_2918_e 2917 2918 13758.3
r_2917_2918_i 2917_2918 2918 95645.6
c_2917_2918_i 2917 2917_2918 9.36084e-12
r_3477_3478_e 3477 3478 13758.3
r_3477_3478_i 3477_3478 3478 95645.6
c_3477_3478_i 3477 3477_3478 9.36084e-12
r_118_119_e 118 119 13376.4
r_118_119_i 118_119 119 93218.1
c_118_119_i 118 118_119 2.08965e-09
r_678_679_e 678 679 13376.4
r_678_679_i 678_679 679 93218.1
c_678_679_i 678 678_679 2.08965e-09
r_1238_1239_e 1238 1239 836.944
r_1238_1239_i 1238_1239 1239 4256.89
c_1238_1239_i 1238 1238_1239 4.67522e-10
r_1798_1799_e 1798 1799 836.944
r_1798_1799_i 1798_1799 1799 4256.89
c_1798_1799_i 1798 1798_1799 4.67522e-10
r_2358_2359_e 2358 2359 836.944
r_2358_2359_i 2358_2359 2359 4256.89
c_2358_2359_i 2358 2358_2359 4.67522e-10
r_2918_2919_e 2918 2919 13758.3
r_2918_2919_i 2918_2919 2919 95645.6
c_2918_2919_i 2918 2918_2919 9.36084e-12
r_3478_3479_e 3478 3479 13758.3
r_3478_3479_i 3478_3479 3479 95645.6
c_3478_3479_i 3478 3478_3479 9.36084e-12
r_119_120_e 119 120 13376.4
r_119_120_i 119_120 120 93218.1
c_119_120_i 119 119_120 2.08965e-09
r_679_680_e 679 680 13376.4
r_679_680_i 679_680 680 93218.1
c_679_680_i 679 679_680 2.08965e-09
r_1239_1240_e 1239 1240 836.944
r_1239_1240_i 1239_1240 1240 4256.89
c_1239_1240_i 1239 1239_1240 4.67522e-10
r_1799_1800_e 1799 1800 836.944
r_1799_1800_i 1799_1800 1800 4256.89
c_1799_1800_i 1799 1799_1800 4.67522e-10
r_2359_2360_e 2359 2360 836.944
r_2359_2360_i 2359_2360 2360 4256.89
c_2359_2360_i 2359 2359_2360 4.67522e-10
r_2919_2920_e 2919 2920 13758.3
r_2919_2920_i 2919_2920 2920 95645.6
c_2919_2920_i 2919 2919_2920 9.36084e-12
r_3479_3480_e 3479 3480 13758.3
r_3479_3480_i 3479_3480 3480 95645.6
c_3479_3480_i 3479 3479_3480 9.36084e-12
r_120_121_e 120 121 13376.4
r_120_121_i 120_121 121 93218.1
c_120_121_i 120 120_121 2.08965e-09
r_680_681_e 680 681 13376.4
r_680_681_i 680_681 681 93218.1
c_680_681_i 680 680_681 2.08965e-09
r_1240_1241_e 1240 1241 836.944
r_1240_1241_i 1240_1241 1241 4256.89
c_1240_1241_i 1240 1240_1241 4.67522e-10
r_1800_1801_e 1800 1801 836.944
r_1800_1801_i 1800_1801 1801 4256.89
c_1800_1801_i 1800 1800_1801 4.67522e-10
r_2360_2361_e 2360 2361 836.944
r_2360_2361_i 2360_2361 2361 4256.89
c_2360_2361_i 2360 2360_2361 4.67522e-10
r_2920_2921_e 2920 2921 13758.3
r_2920_2921_i 2920_2921 2921 95645.6
c_2920_2921_i 2920 2920_2921 9.36084e-12
r_3480_3481_e 3480 3481 13758.3
r_3480_3481_i 3480_3481 3481 95645.6
c_3480_3481_i 3480 3480_3481 9.36084e-12
r_121_122_e 121 122 13376.4
r_121_122_i 121_122 122 93218.1
c_121_122_i 121 121_122 2.08965e-09
r_681_682_e 681 682 13376.4
r_681_682_i 681_682 682 93218.1
c_681_682_i 681 681_682 2.08965e-09
r_1241_1242_e 1241 1242 836.944
r_1241_1242_i 1241_1242 1242 4256.89
c_1241_1242_i 1241 1241_1242 4.67522e-10
r_1801_1802_e 1801 1802 836.944
r_1801_1802_i 1801_1802 1802 4256.89
c_1801_1802_i 1801 1801_1802 4.67522e-10
r_2361_2362_e 2361 2362 836.944
r_2361_2362_i 2361_2362 2362 4256.89
c_2361_2362_i 2361 2361_2362 4.67522e-10
r_2921_2922_e 2921 2922 13758.3
r_2921_2922_i 2921_2922 2922 95645.6
c_2921_2922_i 2921 2921_2922 9.36084e-12
r_3481_3482_e 3481 3482 13758.3
r_3481_3482_i 3481_3482 3482 95645.6
c_3481_3482_i 3481 3481_3482 9.36084e-12
r_122_123_e 122 123 13376.4
r_122_123_i 122_123 123 93218.1
c_122_123_i 122 122_123 2.08965e-09
r_682_683_e 682 683 13376.4
r_682_683_i 682_683 683 93218.1
c_682_683_i 682 682_683 2.08965e-09
r_1242_1243_e 1242 1243 836.944
r_1242_1243_i 1242_1243 1243 4256.89
c_1242_1243_i 1242 1242_1243 4.67522e-10
r_1802_1803_e 1802 1803 836.944
r_1802_1803_i 1802_1803 1803 4256.89
c_1802_1803_i 1802 1802_1803 4.67522e-10
r_2362_2363_e 2362 2363 836.944
r_2362_2363_i 2362_2363 2363 4256.89
c_2362_2363_i 2362 2362_2363 4.67522e-10
r_2922_2923_e 2922 2923 13758.3
r_2922_2923_i 2922_2923 2923 95645.6
c_2922_2923_i 2922 2922_2923 9.36084e-12
r_3482_3483_e 3482 3483 13758.3
r_3482_3483_i 3482_3483 3483 95645.6
c_3482_3483_i 3482 3482_3483 9.36084e-12
r_123_124_e 123 124 13376.4
r_123_124_i 123_124 124 93218.1
c_123_124_i 123 123_124 2.08965e-09
r_683_684_e 683 684 13376.4
r_683_684_i 683_684 684 93218.1
c_683_684_i 683 683_684 2.08965e-09
r_1243_1244_e 1243 1244 396.715
r_1243_1244_i 1243_1244 1244 1005.31
c_1243_1244_i 1243 1243_1244 1.65788e-10
r_1803_1804_e 1803 1804 396.715
r_1803_1804_i 1803_1804 1804 1005.31
c_1803_1804_i 1803 1803_1804 1.65788e-10
r_2363_2364_e 2363 2364 836.944
r_2363_2364_i 2363_2364 2364 4256.89
c_2363_2364_i 2363 2363_2364 4.67522e-10
r_2923_2924_e 2923 2924 13758.3
r_2923_2924_i 2923_2924 2924 95645.6
c_2923_2924_i 2923 2923_2924 9.36084e-12
r_3483_3484_e 3483 3484 13758.3
r_3483_3484_i 3483_3484 3484 95645.6
c_3483_3484_i 3483 3483_3484 9.36084e-12
r_124_125_e 124 125 13376.4
r_124_125_i 124_125 125 93218.1
c_124_125_i 124 124_125 2.08965e-09
r_684_685_e 684 685 13376.4
r_684_685_i 684_685 685 93218.1
c_684_685_i 684 684_685 2.08965e-09
r_1244_1245_e 1244 1245 836.944
r_1244_1245_i 1244_1245 1245 4256.89
c_1244_1245_i 1244 1244_1245 4.67522e-10
r_1804_1805_e 1804 1805 836.944
r_1804_1805_i 1804_1805 1805 4256.89
c_1804_1805_i 1804 1804_1805 4.67522e-10
r_2364_2365_e 2364 2365 836.944
r_2364_2365_i 2364_2365 2365 4256.89
c_2364_2365_i 2364 2364_2365 4.67522e-10
r_2924_2925_e 2924 2925 13758.3
r_2924_2925_i 2924_2925 2925 95645.6
c_2924_2925_i 2924 2924_2925 9.36084e-12
r_3484_3485_e 3484 3485 13758.3
r_3484_3485_i 3484_3485 3485 95645.6
c_3484_3485_i 3484 3484_3485 9.36084e-12
r_125_126_e 125 126 13376.4
r_125_126_i 125_126 126 93218.1
c_125_126_i 125 125_126 2.08965e-09
r_685_686_e 685 686 13376.4
r_685_686_i 685_686 686 93218.1
c_685_686_i 685 685_686 2.08965e-09
r_1245_1246_e 1245 1246 836.944
r_1245_1246_i 1245_1246 1246 4256.89
c_1245_1246_i 1245 1245_1246 4.67522e-10
r_1805_1806_e 1805 1806 836.944
r_1805_1806_i 1805_1806 1806 4256.89
c_1805_1806_i 1805 1805_1806 4.67522e-10
r_2365_2366_e 2365 2366 836.944
r_2365_2366_i 2365_2366 2366 4256.89
c_2365_2366_i 2365 2365_2366 4.67522e-10
r_2925_2926_e 2925 2926 13758.3
r_2925_2926_i 2925_2926 2926 95645.6
c_2925_2926_i 2925 2925_2926 9.36084e-12
r_3485_3486_e 3485 3486 13758.3
r_3485_3486_i 3485_3486 3486 95645.6
c_3485_3486_i 3485 3485_3486 9.36084e-12
r_126_127_e 126 127 13376.4
r_126_127_i 126_127 127 93218.1
c_126_127_i 126 126_127 2.08965e-09
r_686_687_e 686 687 13376.4
r_686_687_i 686_687 687 93218.1
c_686_687_i 686 686_687 2.08965e-09
r_1246_1247_e 1246 1247 836.944
r_1246_1247_i 1246_1247 1247 4256.89
c_1246_1247_i 1246 1246_1247 4.67522e-10
r_1806_1807_e 1806 1807 836.944
r_1806_1807_i 1806_1807 1807 4256.89
c_1806_1807_i 1806 1806_1807 4.67522e-10
r_2366_2367_e 2366 2367 836.944
r_2366_2367_i 2366_2367 2367 4256.89
c_2366_2367_i 2366 2366_2367 4.67522e-10
r_2926_2927_e 2926 2927 13758.3
r_2926_2927_i 2926_2927 2927 95645.6
c_2926_2927_i 2926 2926_2927 9.36084e-12
r_3486_3487_e 3486 3487 13758.3
r_3486_3487_i 3486_3487 3487 95645.6
c_3486_3487_i 3486 3486_3487 9.36084e-12
r_127_128_e 127 128 13376.4
r_127_128_i 127_128 128 93218.1
c_127_128_i 127 127_128 2.08965e-09
r_687_688_e 687 688 13376.4
r_687_688_i 687_688 688 93218.1
c_687_688_i 687 687_688 2.08965e-09
r_1247_1248_e 1247 1248 836.944
r_1247_1248_i 1247_1248 1248 4256.89
c_1247_1248_i 1247 1247_1248 4.67522e-10
r_1807_1808_e 1807 1808 836.944
r_1807_1808_i 1807_1808 1808 4256.89
c_1807_1808_i 1807 1807_1808 4.67522e-10
r_2367_2368_e 2367 2368 836.944
r_2367_2368_i 2367_2368 2368 4256.89
c_2367_2368_i 2367 2367_2368 4.67522e-10
r_2927_2928_e 2927 2928 13758.3
r_2927_2928_i 2927_2928 2928 95645.6
c_2927_2928_i 2927 2927_2928 9.36084e-12
r_3487_3488_e 3487 3488 13758.3
r_3487_3488_i 3487_3488 3488 95645.6
c_3487_3488_i 3487 3487_3488 9.36084e-12
r_129_130_e 129 130 13376.4
r_129_130_i 129_130 130 93218.1
c_129_130_i 129 129_130 2.08965e-09
r_689_690_e 689 690 13376.4
r_689_690_i 689_690 690 93218.1
c_689_690_i 689 689_690 2.08965e-09
r_1249_1250_e 1249 1250 13376.4
r_1249_1250_i 1249_1250 1250 93218.1
c_1249_1250_i 1249 1249_1250 2.08965e-09
r_1809_1810_e 1809 1810 13376.4
r_1809_1810_i 1809_1810 1810 93218.1
c_1809_1810_i 1809 1809_1810 2.08965e-09
r_2369_2370_e 2369 2370 13376.4
r_2369_2370_i 2369_2370 2370 93218.1
c_2369_2370_i 2369 2369_2370 2.08965e-09
r_2929_2930_e 2929 2930 13376.4
r_2929_2930_i 2929_2930 2930 93218.1
c_2929_2930_i 2929 2929_2930 2.08965e-09
r_3489_3490_e 3489 3490 13376.4
r_3489_3490_i 3489_3490 3490 93218.1
c_3489_3490_i 3489 3489_3490 2.08965e-09
r_130_131_e 130 131 13376.4
r_130_131_i 130_131 131 93218.1
c_130_131_i 130 130_131 2.08965e-09
r_690_691_e 690 691 13376.4
r_690_691_i 690_691 691 93218.1
c_690_691_i 690 690_691 2.08965e-09
r_1250_1251_e 1250 1251 13376.4
r_1250_1251_i 1250_1251 1251 93218.1
c_1250_1251_i 1250 1250_1251 2.08965e-09
r_1810_1811_e 1810 1811 13376.4
r_1810_1811_i 1810_1811 1811 93218.1
c_1810_1811_i 1810 1810_1811 2.08965e-09
r_2370_2371_e 2370 2371 13376.4
r_2370_2371_i 2370_2371 2371 93218.1
c_2370_2371_i 2370 2370_2371 2.08965e-09
r_2930_2931_e 2930 2931 13376.4
r_2930_2931_i 2930_2931 2931 93218.1
c_2930_2931_i 2930 2930_2931 2.08965e-09
r_3490_3491_e 3490 3491 13376.4
r_3490_3491_i 3490_3491 3491 93218.1
c_3490_3491_i 3490 3490_3491 2.08965e-09
r_131_132_e 131 132 13376.4
r_131_132_i 131_132 132 93218.1
c_131_132_i 131 131_132 2.08965e-09
r_691_692_e 691 692 13376.4
r_691_692_i 691_692 692 93218.1
c_691_692_i 691 691_692 2.08965e-09
r_1251_1252_e 1251 1252 836.944
r_1251_1252_i 1251_1252 1252 4256.89
c_1251_1252_i 1251 1251_1252 4.67522e-10
r_1811_1812_e 1811 1812 836.944
r_1811_1812_i 1811_1812 1812 4256.89
c_1811_1812_i 1811 1811_1812 4.67522e-10
r_2371_2372_e 2371 2372 836.944
r_2371_2372_i 2371_2372 2372 4256.89
c_2371_2372_i 2371 2371_2372 4.67522e-10
r_2931_2932_e 2931 2932 836.944
r_2931_2932_i 2931_2932 2932 4256.89
c_2931_2932_i 2931 2931_2932 4.67522e-10
r_3491_3492_e 3491 3492 836.944
r_3491_3492_i 3491_3492 3492 4256.89
c_3491_3492_i 3491 3491_3492 4.67522e-10
r_132_133_e 132 133 13376.4
r_132_133_i 132_133 133 93218.1
c_132_133_i 132 132_133 2.08965e-09
r_692_693_e 692 693 13376.4
r_692_693_i 692_693 693 93218.1
c_692_693_i 692 692_693 2.08965e-09
r_1252_1253_e 1252 1253 836.944
r_1252_1253_i 1252_1253 1253 4256.89
c_1252_1253_i 1252 1252_1253 4.67522e-10
r_1812_1813_e 1812 1813 836.944
r_1812_1813_i 1812_1813 1813 4256.89
c_1812_1813_i 1812 1812_1813 4.67522e-10
r_2372_2373_e 2372 2373 836.944
r_2372_2373_i 2372_2373 2373 4256.89
c_2372_2373_i 2372 2372_2373 4.67522e-10
r_2932_2933_e 2932 2933 13758.3
r_2932_2933_i 2932_2933 2933 95645.6
c_2932_2933_i 2932 2932_2933 9.36084e-12
r_3492_3493_e 3492 3493 13758.3
r_3492_3493_i 3492_3493 3493 95645.6
c_3492_3493_i 3492 3492_3493 9.36084e-12
r_133_134_e 133 134 13376.4
r_133_134_i 133_134 134 93218.1
c_133_134_i 133 133_134 2.08965e-09
r_693_694_e 693 694 13376.4
r_693_694_i 693_694 694 93218.1
c_693_694_i 693 693_694 2.08965e-09
r_1253_1254_e 1253 1254 836.944
r_1253_1254_i 1253_1254 1254 4256.89
c_1253_1254_i 1253 1253_1254 4.67522e-10
r_1813_1814_e 1813 1814 836.944
r_1813_1814_i 1813_1814 1814 4256.89
c_1813_1814_i 1813 1813_1814 4.67522e-10
r_2373_2374_e 2373 2374 836.944
r_2373_2374_i 2373_2374 2374 4256.89
c_2373_2374_i 2373 2373_2374 4.67522e-10
r_2933_2934_e 2933 2934 13758.3
r_2933_2934_i 2933_2934 2934 95645.6
c_2933_2934_i 2933 2933_2934 9.36084e-12
r_3493_3494_e 3493 3494 13758.3
r_3493_3494_i 3493_3494 3494 95645.6
c_3493_3494_i 3493 3493_3494 9.36084e-12
r_134_135_e 134 135 13376.4
r_134_135_i 134_135 135 93218.1
c_134_135_i 134 134_135 2.08965e-09
r_694_695_e 694 695 13376.4
r_694_695_i 694_695 695 93218.1
c_694_695_i 694 694_695 2.08965e-09
r_1254_1255_e 1254 1255 836.944
r_1254_1255_i 1254_1255 1255 4256.89
c_1254_1255_i 1254 1254_1255 4.67522e-10
r_1814_1815_e 1814 1815 836.944
r_1814_1815_i 1814_1815 1815 4256.89
c_1814_1815_i 1814 1814_1815 4.67522e-10
r_2374_2375_e 2374 2375 836.944
r_2374_2375_i 2374_2375 2375 4256.89
c_2374_2375_i 2374 2374_2375 4.67522e-10
r_2934_2935_e 2934 2935 13758.3
r_2934_2935_i 2934_2935 2935 95645.6
c_2934_2935_i 2934 2934_2935 9.36084e-12
r_3494_3495_e 3494 3495 13758.3
r_3494_3495_i 3494_3495 3495 95645.6
c_3494_3495_i 3494 3494_3495 9.36084e-12
r_135_136_e 135 136 13376.4
r_135_136_i 135_136 136 93218.1
c_135_136_i 135 135_136 2.08965e-09
r_695_696_e 695 696 13376.4
r_695_696_i 695_696 696 93218.1
c_695_696_i 695 695_696 2.08965e-09
r_1255_1256_e 1255 1256 836.944
r_1255_1256_i 1255_1256 1256 4256.89
c_1255_1256_i 1255 1255_1256 4.67522e-10
r_1815_1816_e 1815 1816 836.944
r_1815_1816_i 1815_1816 1816 4256.89
c_1815_1816_i 1815 1815_1816 4.67522e-10
r_2375_2376_e 2375 2376 836.944
r_2375_2376_i 2375_2376 2376 4256.89
c_2375_2376_i 2375 2375_2376 4.67522e-10
r_2935_2936_e 2935 2936 13758.3
r_2935_2936_i 2935_2936 2936 95645.6
c_2935_2936_i 2935 2935_2936 9.36084e-12
r_3495_3496_e 3495 3496 13758.3
r_3495_3496_i 3495_3496 3496 95645.6
c_3495_3496_i 3495 3495_3496 9.36084e-12
r_136_137_e 136 137 13376.4
r_136_137_i 136_137 137 93218.1
c_136_137_i 136 136_137 2.08965e-09
r_696_697_e 696 697 13376.4
r_696_697_i 696_697 697 93218.1
c_696_697_i 696 696_697 2.08965e-09
r_1256_1257_e 1256 1257 836.944
r_1256_1257_i 1256_1257 1257 4256.89
c_1256_1257_i 1256 1256_1257 4.67522e-10
r_1816_1817_e 1816 1817 836.944
r_1816_1817_i 1816_1817 1817 4256.89
c_1816_1817_i 1816 1816_1817 4.67522e-10
r_2376_2377_e 2376 2377 836.944
r_2376_2377_i 2376_2377 2377 4256.89
c_2376_2377_i 2376 2376_2377 4.67522e-10
r_2936_2937_e 2936 2937 13758.3
r_2936_2937_i 2936_2937 2937 95645.6
c_2936_2937_i 2936 2936_2937 9.36084e-12
r_3496_3497_e 3496 3497 13758.3
r_3496_3497_i 3496_3497 3497 95645.6
c_3496_3497_i 3496 3496_3497 9.36084e-12
r_137_138_e 137 138 13376.4
r_137_138_i 137_138 138 93218.1
c_137_138_i 137 137_138 2.08965e-09
r_697_698_e 697 698 13376.4
r_697_698_i 697_698 698 93218.1
c_697_698_i 697 697_698 2.08965e-09
r_1257_1258_e 1257 1258 836.944
r_1257_1258_i 1257_1258 1258 4256.89
c_1257_1258_i 1257 1257_1258 4.67522e-10
r_1817_1818_e 1817 1818 836.944
r_1817_1818_i 1817_1818 1818 4256.89
c_1817_1818_i 1817 1817_1818 4.67522e-10
r_2377_2378_e 2377 2378 836.944
r_2377_2378_i 2377_2378 2378 4256.89
c_2377_2378_i 2377 2377_2378 4.67522e-10
r_2937_2938_e 2937 2938 13758.3
r_2937_2938_i 2937_2938 2938 95645.6
c_2937_2938_i 2937 2937_2938 9.36084e-12
r_3497_3498_e 3497 3498 13758.3
r_3497_3498_i 3497_3498 3498 95645.6
c_3497_3498_i 3497 3497_3498 9.36084e-12
r_138_139_e 138 139 13376.4
r_138_139_i 138_139 139 93218.1
c_138_139_i 138 138_139 2.08965e-09
r_698_699_e 698 699 13376.4
r_698_699_i 698_699 699 93218.1
c_698_699_i 698 698_699 2.08965e-09
r_1258_1259_e 1258 1259 836.944
r_1258_1259_i 1258_1259 1259 4256.89
c_1258_1259_i 1258 1258_1259 4.67522e-10
r_1818_1819_e 1818 1819 836.944
r_1818_1819_i 1818_1819 1819 4256.89
c_1818_1819_i 1818 1818_1819 4.67522e-10
r_2378_2379_e 2378 2379 836.944
r_2378_2379_i 2378_2379 2379 4256.89
c_2378_2379_i 2378 2378_2379 4.67522e-10
r_2938_2939_e 2938 2939 13758.3
r_2938_2939_i 2938_2939 2939 95645.6
c_2938_2939_i 2938 2938_2939 9.36084e-12
r_3498_3499_e 3498 3499 13758.3
r_3498_3499_i 3498_3499 3499 95645.6
c_3498_3499_i 3498 3498_3499 9.36084e-12
r_139_140_e 139 140 13376.4
r_139_140_i 139_140 140 93218.1
c_139_140_i 139 139_140 2.08965e-09
r_699_700_e 699 700 13376.4
r_699_700_i 699_700 700 93218.1
c_699_700_i 699 699_700 2.08965e-09
r_1259_1260_e 1259 1260 396.706
r_1259_1260_i 1259_1260 1260 1005.29
c_1259_1260_i 1259 1259_1260 1.65792e-10
r_1819_1820_e 1819 1820 396.706
r_1819_1820_i 1819_1820 1820 1005.29
c_1819_1820_i 1819 1819_1820 1.65792e-10
r_2379_2380_e 2379 2380 836.944
r_2379_2380_i 2379_2380 2380 4256.89
c_2379_2380_i 2379 2379_2380 4.67522e-10
r_2939_2940_e 2939 2940 13758.3
r_2939_2940_i 2939_2940 2940 95645.6
c_2939_2940_i 2939 2939_2940 9.36084e-12
r_3499_3500_e 3499 3500 13758.3
r_3499_3500_i 3499_3500 3500 95645.6
c_3499_3500_i 3499 3499_3500 9.36084e-12
r_140_141_e 140 141 13376.4
r_140_141_i 140_141 141 93218.1
c_140_141_i 140 140_141 2.08965e-09
r_700_701_e 700 701 13376.4
r_700_701_i 700_701 701 93218.1
c_700_701_i 700 700_701 2.08965e-09
r_1260_1261_e 1260 1261 836.944
r_1260_1261_i 1260_1261 1261 4256.89
c_1260_1261_i 1260 1260_1261 4.67522e-10
r_1820_1821_e 1820 1821 836.944
r_1820_1821_i 1820_1821 1821 4256.89
c_1820_1821_i 1820 1820_1821 4.67522e-10
r_2380_2381_e 2380 2381 836.944
r_2380_2381_i 2380_2381 2381 4256.89
c_2380_2381_i 2380 2380_2381 4.67522e-10
r_2940_2941_e 2940 2941 13758.3
r_2940_2941_i 2940_2941 2941 95645.6
c_2940_2941_i 2940 2940_2941 9.36084e-12
r_3500_3501_e 3500 3501 13758.3
r_3500_3501_i 3500_3501 3501 95645.6
c_3500_3501_i 3500 3500_3501 9.36084e-12
r_141_142_e 141 142 13376.4
r_141_142_i 141_142 142 93218.1
c_141_142_i 141 141_142 2.08965e-09
r_701_702_e 701 702 13376.4
r_701_702_i 701_702 702 93218.1
c_701_702_i 701 701_702 2.08965e-09
r_1261_1262_e 1261 1262 836.944
r_1261_1262_i 1261_1262 1262 4256.89
c_1261_1262_i 1261 1261_1262 4.67522e-10
r_1821_1822_e 1821 1822 836.944
r_1821_1822_i 1821_1822 1822 4256.89
c_1821_1822_i 1821 1821_1822 4.67522e-10
r_2381_2382_e 2381 2382 836.944
r_2381_2382_i 2381_2382 2382 4256.89
c_2381_2382_i 2381 2381_2382 4.67522e-10
r_2941_2942_e 2941 2942 13758.3
r_2941_2942_i 2941_2942 2942 95645.6
c_2941_2942_i 2941 2941_2942 9.36084e-12
r_3501_3502_e 3501 3502 13758.3
r_3501_3502_i 3501_3502 3502 95645.6
c_3501_3502_i 3501 3501_3502 9.36084e-12
r_142_143_e 142 143 13376.4
r_142_143_i 142_143 143 93218.1
c_142_143_i 142 142_143 2.08965e-09
r_702_703_e 702 703 13376.4
r_702_703_i 702_703 703 93218.1
c_702_703_i 702 702_703 2.08965e-09
r_1262_1263_e 1262 1263 836.944
r_1262_1263_i 1262_1263 1263 4256.89
c_1262_1263_i 1262 1262_1263 4.67522e-10
r_1822_1823_e 1822 1823 836.944
r_1822_1823_i 1822_1823 1823 4256.89
c_1822_1823_i 1822 1822_1823 4.67522e-10
r_2382_2383_e 2382 2383 836.944
r_2382_2383_i 2382_2383 2383 4256.89
c_2382_2383_i 2382 2382_2383 4.67522e-10
r_2942_2943_e 2942 2943 13758.3
r_2942_2943_i 2942_2943 2943 95645.6
c_2942_2943_i 2942 2942_2943 9.36084e-12
r_3502_3503_e 3502 3503 13758.3
r_3502_3503_i 3502_3503 3503 95645.6
c_3502_3503_i 3502 3502_3503 9.36084e-12
r_143_144_e 143 144 13376.4
r_143_144_i 143_144 144 93218.1
c_143_144_i 143 143_144 2.08965e-09
r_703_704_e 703 704 13376.4
r_703_704_i 703_704 704 93218.1
c_703_704_i 703 703_704 2.08965e-09
r_1263_1264_e 1263 1264 836.944
r_1263_1264_i 1263_1264 1264 4256.89
c_1263_1264_i 1263 1263_1264 4.67522e-10
r_1823_1824_e 1823 1824 836.944
r_1823_1824_i 1823_1824 1824 4256.89
c_1823_1824_i 1823 1823_1824 4.67522e-10
r_2383_2384_e 2383 2384 836.944
r_2383_2384_i 2383_2384 2384 4256.89
c_2383_2384_i 2383 2383_2384 4.67522e-10
r_2943_2944_e 2943 2944 13758.3
r_2943_2944_i 2943_2944 2944 95645.6
c_2943_2944_i 2943 2943_2944 9.36084e-12
r_3503_3504_e 3503 3504 13758.3
r_3503_3504_i 3503_3504 3504 95645.6
c_3503_3504_i 3503 3503_3504 9.36084e-12
r_145_146_e 145 146 13376.4
r_145_146_i 145_146 146 93218.1
c_145_146_i 145 145_146 2.08965e-09
r_705_706_e 705 706 13376.4
r_705_706_i 705_706 706 93218.1
c_705_706_i 705 705_706 2.08965e-09
r_1265_1266_e 1265 1266 13376.4
r_1265_1266_i 1265_1266 1266 93218.1
c_1265_1266_i 1265 1265_1266 2.08965e-09
r_1825_1826_e 1825 1826 13376.4
r_1825_1826_i 1825_1826 1826 93218.1
c_1825_1826_i 1825 1825_1826 2.08965e-09
r_2385_2386_e 2385 2386 13376.4
r_2385_2386_i 2385_2386 2386 93218.1
c_2385_2386_i 2385 2385_2386 2.08965e-09
r_2945_2946_e 2945 2946 13376.4
r_2945_2946_i 2945_2946 2946 93218.1
c_2945_2946_i 2945 2945_2946 2.08965e-09
r_3505_3506_e 3505 3506 13376.4
r_3505_3506_i 3505_3506 3506 93218.1
c_3505_3506_i 3505 3505_3506 2.08965e-09
r_146_147_e 146 147 13376.4
r_146_147_i 146_147 147 93218.1
c_146_147_i 146 146_147 2.08965e-09
r_706_707_e 706 707 13376.4
r_706_707_i 706_707 707 93218.1
c_706_707_i 706 706_707 2.08965e-09
r_1266_1267_e 1266 1267 13376.4
r_1266_1267_i 1266_1267 1267 93218.1
c_1266_1267_i 1266 1266_1267 2.08965e-09
r_1826_1827_e 1826 1827 13376.4
r_1826_1827_i 1826_1827 1827 93218.1
c_1826_1827_i 1826 1826_1827 2.08965e-09
r_2386_2387_e 2386 2387 13376.4
r_2386_2387_i 2386_2387 2387 93218.1
c_2386_2387_i 2386 2386_2387 2.08965e-09
r_2946_2947_e 2946 2947 13376.4
r_2946_2947_i 2946_2947 2947 93218.1
c_2946_2947_i 2946 2946_2947 2.08965e-09
r_3506_3507_e 3506 3507 13376.4
r_3506_3507_i 3506_3507 3507 93218.1
c_3506_3507_i 3506 3506_3507 2.08965e-09
r_147_148_e 147 148 13376.4
r_147_148_i 147_148 148 93218.1
c_147_148_i 147 147_148 2.08965e-09
r_707_708_e 707 708 13376.4
r_707_708_i 707_708 708 93218.1
c_707_708_i 707 707_708 2.08965e-09
r_1267_1268_e 1267 1268 836.944
r_1267_1268_i 1267_1268 1268 4256.89
c_1267_1268_i 1267 1267_1268 4.67522e-10
r_1827_1828_e 1827 1828 836.944
r_1827_1828_i 1827_1828 1828 4256.89
c_1827_1828_i 1827 1827_1828 4.67522e-10
r_2387_2388_e 2387 2388 836.944
r_2387_2388_i 2387_2388 2388 4256.89
c_2387_2388_i 2387 2387_2388 4.67522e-10
r_2947_2948_e 2947 2948 836.944
r_2947_2948_i 2947_2948 2948 4256.89
c_2947_2948_i 2947 2947_2948 4.67522e-10
r_3507_3508_e 3507 3508 836.944
r_3507_3508_i 3507_3508 3508 4256.89
c_3507_3508_i 3507 3507_3508 4.67522e-10
r_148_149_e 148 149 13376.4
r_148_149_i 148_149 149 93218.1
c_148_149_i 148 148_149 2.08965e-09
r_708_709_e 708 709 13376.4
r_708_709_i 708_709 709 93218.1
c_708_709_i 708 708_709 2.08965e-09
r_1268_1269_e 1268 1269 836.944
r_1268_1269_i 1268_1269 1269 4256.89
c_1268_1269_i 1268 1268_1269 4.67522e-10
r_1828_1829_e 1828 1829 836.944
r_1828_1829_i 1828_1829 1829 4256.89
c_1828_1829_i 1828 1828_1829 4.67522e-10
r_2388_2389_e 2388 2389 836.944
r_2388_2389_i 2388_2389 2389 4256.89
c_2388_2389_i 2388 2388_2389 4.67522e-10
r_2948_2949_e 2948 2949 13758.3
r_2948_2949_i 2948_2949 2949 95645.6
c_2948_2949_i 2948 2948_2949 9.36084e-12
r_3508_3509_e 3508 3509 13758.3
r_3508_3509_i 3508_3509 3509 95645.6
c_3508_3509_i 3508 3508_3509 9.36084e-12
r_149_150_e 149 150 13376.4
r_149_150_i 149_150 150 93218.1
c_149_150_i 149 149_150 2.08965e-09
r_709_710_e 709 710 13376.4
r_709_710_i 709_710 710 93218.1
c_709_710_i 709 709_710 2.08965e-09
r_1269_1270_e 1269 1270 836.944
r_1269_1270_i 1269_1270 1270 4256.89
c_1269_1270_i 1269 1269_1270 4.67522e-10
r_1829_1830_e 1829 1830 836.944
r_1829_1830_i 1829_1830 1830 4256.89
c_1829_1830_i 1829 1829_1830 4.67522e-10
r_2389_2390_e 2389 2390 836.944
r_2389_2390_i 2389_2390 2390 4256.89
c_2389_2390_i 2389 2389_2390 4.67522e-10
r_2949_2950_e 2949 2950 13758.3
r_2949_2950_i 2949_2950 2950 95645.6
c_2949_2950_i 2949 2949_2950 9.36084e-12
r_3509_3510_e 3509 3510 13758.3
r_3509_3510_i 3509_3510 3510 95645.6
c_3509_3510_i 3509 3509_3510 9.36084e-12
r_150_151_e 150 151 13376.4
r_150_151_i 150_151 151 93218.1
c_150_151_i 150 150_151 2.08965e-09
r_710_711_e 710 711 13376.4
r_710_711_i 710_711 711 93218.1
c_710_711_i 710 710_711 2.08965e-09
r_1270_1271_e 1270 1271 836.944
r_1270_1271_i 1270_1271 1271 4256.89
c_1270_1271_i 1270 1270_1271 4.67522e-10
r_1830_1831_e 1830 1831 836.944
r_1830_1831_i 1830_1831 1831 4256.89
c_1830_1831_i 1830 1830_1831 4.67522e-10
r_2390_2391_e 2390 2391 836.944
r_2390_2391_i 2390_2391 2391 4256.89
c_2390_2391_i 2390 2390_2391 4.67522e-10
r_2950_2951_e 2950 2951 13758.3
r_2950_2951_i 2950_2951 2951 95645.6
c_2950_2951_i 2950 2950_2951 9.36084e-12
r_3510_3511_e 3510 3511 13758.3
r_3510_3511_i 3510_3511 3511 95645.6
c_3510_3511_i 3510 3510_3511 9.36084e-12
r_151_152_e 151 152 13376.4
r_151_152_i 151_152 152 93218.1
c_151_152_i 151 151_152 2.08965e-09
r_711_712_e 711 712 13376.4
r_711_712_i 711_712 712 93218.1
c_711_712_i 711 711_712 2.08965e-09
r_1271_1272_e 1271 1272 836.944
r_1271_1272_i 1271_1272 1272 4256.89
c_1271_1272_i 1271 1271_1272 4.67522e-10
r_1831_1832_e 1831 1832 836.944
r_1831_1832_i 1831_1832 1832 4256.89
c_1831_1832_i 1831 1831_1832 4.67522e-10
r_2391_2392_e 2391 2392 836.944
r_2391_2392_i 2391_2392 2392 4256.89
c_2391_2392_i 2391 2391_2392 4.67522e-10
r_2951_2952_e 2951 2952 13758.3
r_2951_2952_i 2951_2952 2952 95645.6
c_2951_2952_i 2951 2951_2952 9.36084e-12
r_3511_3512_e 3511 3512 13758.3
r_3511_3512_i 3511_3512 3512 95645.6
c_3511_3512_i 3511 3511_3512 9.36084e-12
r_152_153_e 152 153 13376.4
r_152_153_i 152_153 153 93218.1
c_152_153_i 152 152_153 2.08965e-09
r_712_713_e 712 713 13376.4
r_712_713_i 712_713 713 93218.1
c_712_713_i 712 712_713 2.08965e-09
r_1272_1273_e 1272 1273 836.944
r_1272_1273_i 1272_1273 1273 4256.89
c_1272_1273_i 1272 1272_1273 4.67522e-10
r_1832_1833_e 1832 1833 836.944
r_1832_1833_i 1832_1833 1833 4256.89
c_1832_1833_i 1832 1832_1833 4.67522e-10
r_2392_2393_e 2392 2393 836.944
r_2392_2393_i 2392_2393 2393 4256.89
c_2392_2393_i 2392 2392_2393 4.67522e-10
r_2952_2953_e 2952 2953 13758.3
r_2952_2953_i 2952_2953 2953 95645.6
c_2952_2953_i 2952 2952_2953 9.36084e-12
r_3512_3513_e 3512 3513 13758.3
r_3512_3513_i 3512_3513 3513 95645.6
c_3512_3513_i 3512 3512_3513 9.36084e-12
r_153_154_e 153 154 13376.4
r_153_154_i 153_154 154 93218.1
c_153_154_i 153 153_154 2.08965e-09
r_713_714_e 713 714 13376.4
r_713_714_i 713_714 714 93218.1
c_713_714_i 713 713_714 2.08965e-09
r_1273_1274_e 1273 1274 836.944
r_1273_1274_i 1273_1274 1274 4256.89
c_1273_1274_i 1273 1273_1274 4.67522e-10
r_1833_1834_e 1833 1834 836.944
r_1833_1834_i 1833_1834 1834 4256.89
c_1833_1834_i 1833 1833_1834 4.67522e-10
r_2393_2394_e 2393 2394 836.944
r_2393_2394_i 2393_2394 2394 4256.89
c_2393_2394_i 2393 2393_2394 4.67522e-10
r_2953_2954_e 2953 2954 13758.3
r_2953_2954_i 2953_2954 2954 95645.6
c_2953_2954_i 2953 2953_2954 9.36084e-12
r_3513_3514_e 3513 3514 13758.3
r_3513_3514_i 3513_3514 3514 95645.6
c_3513_3514_i 3513 3513_3514 9.36084e-12
r_154_155_e 154 155 13376.4
r_154_155_i 154_155 155 93218.1
c_154_155_i 154 154_155 2.08965e-09
r_714_715_e 714 715 13376.4
r_714_715_i 714_715 715 93218.1
c_714_715_i 714 714_715 2.08965e-09
r_1274_1275_e 1274 1275 836.944
r_1274_1275_i 1274_1275 1275 4256.89
c_1274_1275_i 1274 1274_1275 4.67522e-10
r_1834_1835_e 1834 1835 836.944
r_1834_1835_i 1834_1835 1835 4256.89
c_1834_1835_i 1834 1834_1835 4.67522e-10
r_2394_2395_e 2394 2395 836.944
r_2394_2395_i 2394_2395 2395 4256.89
c_2394_2395_i 2394 2394_2395 4.67522e-10
r_2954_2955_e 2954 2955 13758.3
r_2954_2955_i 2954_2955 2955 95645.6
c_2954_2955_i 2954 2954_2955 9.36084e-12
r_3514_3515_e 3514 3515 13758.3
r_3514_3515_i 3514_3515 3515 95645.6
c_3514_3515_i 3514 3514_3515 9.36084e-12
r_155_156_e 155 156 13376.4
r_155_156_i 155_156 156 93218.1
c_155_156_i 155 155_156 2.08965e-09
r_715_716_e 715 716 13376.4
r_715_716_i 715_716 716 93218.1
c_715_716_i 715 715_716 2.08965e-09
r_1275_1276_e 1275 1276 396.697
r_1275_1276_i 1275_1276 1276 1005.27
c_1275_1276_i 1275 1275_1276 1.65796e-10
r_1835_1836_e 1835 1836 396.697
r_1835_1836_i 1835_1836 1836 1005.27
c_1835_1836_i 1835 1835_1836 1.65796e-10
r_2395_2396_e 2395 2396 836.944
r_2395_2396_i 2395_2396 2396 4256.89
c_2395_2396_i 2395 2395_2396 4.67522e-10
r_2955_2956_e 2955 2956 13758.3
r_2955_2956_i 2955_2956 2956 95645.6
c_2955_2956_i 2955 2955_2956 9.36084e-12
r_3515_3516_e 3515 3516 13758.3
r_3515_3516_i 3515_3516 3516 95645.6
c_3515_3516_i 3515 3515_3516 9.36084e-12
r_156_157_e 156 157 13376.4
r_156_157_i 156_157 157 93218.1
c_156_157_i 156 156_157 2.08965e-09
r_716_717_e 716 717 13376.4
r_716_717_i 716_717 717 93218.1
c_716_717_i 716 716_717 2.08965e-09
r_1276_1277_e 1276 1277 836.944
r_1276_1277_i 1276_1277 1277 4256.89
c_1276_1277_i 1276 1276_1277 4.67522e-10
r_1836_1837_e 1836 1837 836.944
r_1836_1837_i 1836_1837 1837 4256.89
c_1836_1837_i 1836 1836_1837 4.67522e-10
r_2396_2397_e 2396 2397 836.944
r_2396_2397_i 2396_2397 2397 4256.89
c_2396_2397_i 2396 2396_2397 4.67522e-10
r_2956_2957_e 2956 2957 13758.3
r_2956_2957_i 2956_2957 2957 95645.6
c_2956_2957_i 2956 2956_2957 9.36084e-12
r_3516_3517_e 3516 3517 13758.3
r_3516_3517_i 3516_3517 3517 95645.6
c_3516_3517_i 3516 3516_3517 9.36084e-12
r_157_158_e 157 158 13376.4
r_157_158_i 157_158 158 93218.1
c_157_158_i 157 157_158 2.08965e-09
r_717_718_e 717 718 13376.4
r_717_718_i 717_718 718 93218.1
c_717_718_i 717 717_718 2.08965e-09
r_1277_1278_e 1277 1278 836.944
r_1277_1278_i 1277_1278 1278 4256.89
c_1277_1278_i 1277 1277_1278 4.67522e-10
r_1837_1838_e 1837 1838 836.944
r_1837_1838_i 1837_1838 1838 4256.89
c_1837_1838_i 1837 1837_1838 4.67522e-10
r_2397_2398_e 2397 2398 836.944
r_2397_2398_i 2397_2398 2398 4256.89
c_2397_2398_i 2397 2397_2398 4.67522e-10
r_2957_2958_e 2957 2958 13758.3
r_2957_2958_i 2957_2958 2958 95645.6
c_2957_2958_i 2957 2957_2958 9.36084e-12
r_3517_3518_e 3517 3518 13758.3
r_3517_3518_i 3517_3518 3518 95645.6
c_3517_3518_i 3517 3517_3518 9.36084e-12
r_158_159_e 158 159 13376.4
r_158_159_i 158_159 159 93218.1
c_158_159_i 158 158_159 2.08965e-09
r_718_719_e 718 719 13376.4
r_718_719_i 718_719 719 93218.1
c_718_719_i 718 718_719 2.08965e-09
r_1278_1279_e 1278 1279 836.944
r_1278_1279_i 1278_1279 1279 4256.89
c_1278_1279_i 1278 1278_1279 4.67522e-10
r_1838_1839_e 1838 1839 836.944
r_1838_1839_i 1838_1839 1839 4256.89
c_1838_1839_i 1838 1838_1839 4.67522e-10
r_2398_2399_e 2398 2399 836.944
r_2398_2399_i 2398_2399 2399 4256.89
c_2398_2399_i 2398 2398_2399 4.67522e-10
r_2958_2959_e 2958 2959 13758.3
r_2958_2959_i 2958_2959 2959 95645.6
c_2958_2959_i 2958 2958_2959 9.36084e-12
r_3518_3519_e 3518 3519 13758.3
r_3518_3519_i 3518_3519 3519 95645.6
c_3518_3519_i 3518 3518_3519 9.36084e-12
r_159_160_e 159 160 13376.4
r_159_160_i 159_160 160 93218.1
c_159_160_i 159 159_160 2.08965e-09
r_719_720_e 719 720 13376.4
r_719_720_i 719_720 720 93218.1
c_719_720_i 719 719_720 2.08965e-09
r_1279_1280_e 1279 1280 836.944
r_1279_1280_i 1279_1280 1280 4256.89
c_1279_1280_i 1279 1279_1280 4.67522e-10
r_1839_1840_e 1839 1840 836.944
r_1839_1840_i 1839_1840 1840 4256.89
c_1839_1840_i 1839 1839_1840 4.67522e-10
r_2399_2400_e 2399 2400 836.944
r_2399_2400_i 2399_2400 2400 4256.89
c_2399_2400_i 2399 2399_2400 4.67522e-10
r_2959_2960_e 2959 2960 13758.3
r_2959_2960_i 2959_2960 2960 95645.6
c_2959_2960_i 2959 2959_2960 9.36084e-12
r_3519_3520_e 3519 3520 13758.3
r_3519_3520_i 3519_3520 3520 95645.6
c_3519_3520_i 3519 3519_3520 9.36084e-12
r_161_162_e 161 162 13376.4
r_161_162_i 161_162 162 93218.1
c_161_162_i 161 161_162 2.08965e-09
r_721_722_e 721 722 13376.4
r_721_722_i 721_722 722 93218.1
c_721_722_i 721 721_722 2.08965e-09
r_1281_1282_e 1281 1282 13376.4
r_1281_1282_i 1281_1282 1282 93218.1
c_1281_1282_i 1281 1281_1282 2.08965e-09
r_1841_1842_e 1841 1842 13376.4
r_1841_1842_i 1841_1842 1842 93218.1
c_1841_1842_i 1841 1841_1842 2.08965e-09
r_2401_2402_e 2401 2402 13376.4
r_2401_2402_i 2401_2402 2402 93218.1
c_2401_2402_i 2401 2401_2402 2.08965e-09
r_2961_2962_e 2961 2962 13376.4
r_2961_2962_i 2961_2962 2962 93218.1
c_2961_2962_i 2961 2961_2962 2.08965e-09
r_3521_3522_e 3521 3522 13376.4
r_3521_3522_i 3521_3522 3522 93218.1
c_3521_3522_i 3521 3521_3522 2.08965e-09
r_162_163_e 162 163 13376.4
r_162_163_i 162_163 163 93218.1
c_162_163_i 162 162_163 2.08965e-09
r_722_723_e 722 723 13376.4
r_722_723_i 722_723 723 93218.1
c_722_723_i 722 722_723 2.08965e-09
r_1282_1283_e 1282 1283 13376.4
r_1282_1283_i 1282_1283 1283 93218.1
c_1282_1283_i 1282 1282_1283 2.08965e-09
r_1842_1843_e 1842 1843 13376.4
r_1842_1843_i 1842_1843 1843 93218.1
c_1842_1843_i 1842 1842_1843 2.08965e-09
r_2402_2403_e 2402 2403 13376.4
r_2402_2403_i 2402_2403 2403 93218.1
c_2402_2403_i 2402 2402_2403 2.08965e-09
r_2962_2963_e 2962 2963 13376.4
r_2962_2963_i 2962_2963 2963 93218.1
c_2962_2963_i 2962 2962_2963 2.08965e-09
r_3522_3523_e 3522 3523 13376.4
r_3522_3523_i 3522_3523 3523 93218.1
c_3522_3523_i 3522 3522_3523 2.08965e-09
r_163_164_e 163 164 13376.4
r_163_164_i 163_164 164 93218.1
c_163_164_i 163 163_164 2.08965e-09
r_723_724_e 723 724 13376.4
r_723_724_i 723_724 724 93218.1
c_723_724_i 723 723_724 2.08965e-09
r_1283_1284_e 1283 1284 836.944
r_1283_1284_i 1283_1284 1284 4256.89
c_1283_1284_i 1283 1283_1284 4.67522e-10
r_1843_1844_e 1843 1844 836.944
r_1843_1844_i 1843_1844 1844 4256.89
c_1843_1844_i 1843 1843_1844 4.67522e-10
r_2403_2404_e 2403 2404 836.944
r_2403_2404_i 2403_2404 2404 4256.89
c_2403_2404_i 2403 2403_2404 4.67522e-10
r_2963_2964_e 2963 2964 836.944
r_2963_2964_i 2963_2964 2964 4256.89
c_2963_2964_i 2963 2963_2964 4.67522e-10
r_3523_3524_e 3523 3524 836.944
r_3523_3524_i 3523_3524 3524 4256.89
c_3523_3524_i 3523 3523_3524 4.67522e-10
r_164_165_e 164 165 13376.4
r_164_165_i 164_165 165 93218.1
c_164_165_i 164 164_165 2.08965e-09
r_724_725_e 724 725 13376.4
r_724_725_i 724_725 725 93218.1
c_724_725_i 724 724_725 2.08965e-09
r_1284_1285_e 1284 1285 836.944
r_1284_1285_i 1284_1285 1285 4256.89
c_1284_1285_i 1284 1284_1285 4.67522e-10
r_1844_1845_e 1844 1845 836.944
r_1844_1845_i 1844_1845 1845 4256.89
c_1844_1845_i 1844 1844_1845 4.67522e-10
r_2404_2405_e 2404 2405 836.944
r_2404_2405_i 2404_2405 2405 4256.89
c_2404_2405_i 2404 2404_2405 4.67522e-10
r_2964_2965_e 2964 2965 13758.3
r_2964_2965_i 2964_2965 2965 95645.6
c_2964_2965_i 2964 2964_2965 9.36084e-12
r_3524_3525_e 3524 3525 13758.3
r_3524_3525_i 3524_3525 3525 95645.6
c_3524_3525_i 3524 3524_3525 9.36084e-12
r_165_166_e 165 166 13376.4
r_165_166_i 165_166 166 93218.1
c_165_166_i 165 165_166 2.08965e-09
r_725_726_e 725 726 13376.4
r_725_726_i 725_726 726 93218.1
c_725_726_i 725 725_726 2.08965e-09
r_1285_1286_e 1285 1286 836.944
r_1285_1286_i 1285_1286 1286 4256.89
c_1285_1286_i 1285 1285_1286 4.67522e-10
r_1845_1846_e 1845 1846 836.944
r_1845_1846_i 1845_1846 1846 4256.89
c_1845_1846_i 1845 1845_1846 4.67522e-10
r_2405_2406_e 2405 2406 836.944
r_2405_2406_i 2405_2406 2406 4256.89
c_2405_2406_i 2405 2405_2406 4.67522e-10
r_2965_2966_e 2965 2966 13758.3
r_2965_2966_i 2965_2966 2966 95645.6
c_2965_2966_i 2965 2965_2966 9.36084e-12
r_3525_3526_e 3525 3526 13758.3
r_3525_3526_i 3525_3526 3526 95645.6
c_3525_3526_i 3525 3525_3526 9.36084e-12
r_166_167_e 166 167 13376.4
r_166_167_i 166_167 167 93218.1
c_166_167_i 166 166_167 2.08965e-09
r_726_727_e 726 727 13376.4
r_726_727_i 726_727 727 93218.1
c_726_727_i 726 726_727 2.08965e-09
r_1286_1287_e 1286 1287 836.944
r_1286_1287_i 1286_1287 1287 4256.89
c_1286_1287_i 1286 1286_1287 4.67522e-10
r_1846_1847_e 1846 1847 836.944
r_1846_1847_i 1846_1847 1847 4256.89
c_1846_1847_i 1846 1846_1847 4.67522e-10
r_2406_2407_e 2406 2407 836.944
r_2406_2407_i 2406_2407 2407 4256.89
c_2406_2407_i 2406 2406_2407 4.67522e-10
r_2966_2967_e 2966 2967 13758.3
r_2966_2967_i 2966_2967 2967 95645.6
c_2966_2967_i 2966 2966_2967 9.36084e-12
r_3526_3527_e 3526 3527 13758.3
r_3526_3527_i 3526_3527 3527 95645.6
c_3526_3527_i 3526 3526_3527 9.36084e-12
r_167_168_e 167 168 13376.4
r_167_168_i 167_168 168 93218.1
c_167_168_i 167 167_168 2.08965e-09
r_727_728_e 727 728 13376.4
r_727_728_i 727_728 728 93218.1
c_727_728_i 727 727_728 2.08965e-09
r_1287_1288_e 1287 1288 836.944
r_1287_1288_i 1287_1288 1288 4256.89
c_1287_1288_i 1287 1287_1288 4.67522e-10
r_1847_1848_e 1847 1848 836.944
r_1847_1848_i 1847_1848 1848 4256.89
c_1847_1848_i 1847 1847_1848 4.67522e-10
r_2407_2408_e 2407 2408 836.944
r_2407_2408_i 2407_2408 2408 4256.89
c_2407_2408_i 2407 2407_2408 4.67522e-10
r_2967_2968_e 2967 2968 13758.3
r_2967_2968_i 2967_2968 2968 95645.6
c_2967_2968_i 2967 2967_2968 9.36084e-12
r_3527_3528_e 3527 3528 13758.3
r_3527_3528_i 3527_3528 3528 95645.6
c_3527_3528_i 3527 3527_3528 9.36084e-12
r_168_169_e 168 169 13376.4
r_168_169_i 168_169 169 93218.1
c_168_169_i 168 168_169 2.08965e-09
r_728_729_e 728 729 13376.4
r_728_729_i 728_729 729 93218.1
c_728_729_i 728 728_729 2.08965e-09
r_1288_1289_e 1288 1289 836.944
r_1288_1289_i 1288_1289 1289 4256.89
c_1288_1289_i 1288 1288_1289 4.67522e-10
r_1848_1849_e 1848 1849 836.944
r_1848_1849_i 1848_1849 1849 4256.89
c_1848_1849_i 1848 1848_1849 4.67522e-10
r_2408_2409_e 2408 2409 836.944
r_2408_2409_i 2408_2409 2409 4256.89
c_2408_2409_i 2408 2408_2409 4.67522e-10
r_2968_2969_e 2968 2969 13758.3
r_2968_2969_i 2968_2969 2969 95645.6
c_2968_2969_i 2968 2968_2969 9.36084e-12
r_3528_3529_e 3528 3529 13758.3
r_3528_3529_i 3528_3529 3529 95645.6
c_3528_3529_i 3528 3528_3529 9.36084e-12
r_169_170_e 169 170 13376.4
r_169_170_i 169_170 170 93218.1
c_169_170_i 169 169_170 2.08965e-09
r_729_730_e 729 730 13376.4
r_729_730_i 729_730 730 93218.1
c_729_730_i 729 729_730 2.08965e-09
r_1289_1290_e 1289 1290 836.944
r_1289_1290_i 1289_1290 1290 4256.89
c_1289_1290_i 1289 1289_1290 4.67522e-10
r_1849_1850_e 1849 1850 836.944
r_1849_1850_i 1849_1850 1850 4256.89
c_1849_1850_i 1849 1849_1850 4.67522e-10
r_2409_2410_e 2409 2410 836.944
r_2409_2410_i 2409_2410 2410 4256.89
c_2409_2410_i 2409 2409_2410 4.67522e-10
r_2969_2970_e 2969 2970 13758.3
r_2969_2970_i 2969_2970 2970 95645.6
c_2969_2970_i 2969 2969_2970 9.36084e-12
r_3529_3530_e 3529 3530 13758.3
r_3529_3530_i 3529_3530 3530 95645.6
c_3529_3530_i 3529 3529_3530 9.36084e-12
r_170_171_e 170 171 13376.4
r_170_171_i 170_171 171 93218.1
c_170_171_i 170 170_171 2.08965e-09
r_730_731_e 730 731 13376.4
r_730_731_i 730_731 731 93218.1
c_730_731_i 730 730_731 2.08965e-09
r_1290_1291_e 1290 1291 836.944
r_1290_1291_i 1290_1291 1291 4256.89
c_1290_1291_i 1290 1290_1291 4.67522e-10
r_1850_1851_e 1850 1851 836.944
r_1850_1851_i 1850_1851 1851 4256.89
c_1850_1851_i 1850 1850_1851 4.67522e-10
r_2410_2411_e 2410 2411 836.944
r_2410_2411_i 2410_2411 2411 4256.89
c_2410_2411_i 2410 2410_2411 4.67522e-10
r_2970_2971_e 2970 2971 13758.3
r_2970_2971_i 2970_2971 2971 95645.6
c_2970_2971_i 2970 2970_2971 9.36084e-12
r_3530_3531_e 3530 3531 13758.3
r_3530_3531_i 3530_3531 3531 95645.6
c_3530_3531_i 3530 3530_3531 9.36084e-12
r_171_172_e 171 172 13376.4
r_171_172_i 171_172 172 93218.1
c_171_172_i 171 171_172 2.08965e-09
r_731_732_e 731 732 13376.4
r_731_732_i 731_732 732 93218.1
c_731_732_i 731 731_732 2.08965e-09
r_1291_1292_e 1291 1292 396.689
r_1291_1292_i 1291_1292 1292 1005.25
c_1291_1292_i 1291 1291_1292 1.65799e-10
r_1851_1852_e 1851 1852 396.689
r_1851_1852_i 1851_1852 1852 1005.25
c_1851_1852_i 1851 1851_1852 1.65799e-10
r_2411_2412_e 2411 2412 836.944
r_2411_2412_i 2411_2412 2412 4256.89
c_2411_2412_i 2411 2411_2412 4.67522e-10
r_2971_2972_e 2971 2972 13758.3
r_2971_2972_i 2971_2972 2972 95645.6
c_2971_2972_i 2971 2971_2972 9.36084e-12
r_3531_3532_e 3531 3532 13758.3
r_3531_3532_i 3531_3532 3532 95645.6
c_3531_3532_i 3531 3531_3532 9.36084e-12
r_172_173_e 172 173 13376.4
r_172_173_i 172_173 173 93218.1
c_172_173_i 172 172_173 2.08965e-09
r_732_733_e 732 733 13376.4
r_732_733_i 732_733 733 93218.1
c_732_733_i 732 732_733 2.08965e-09
r_1292_1293_e 1292 1293 836.944
r_1292_1293_i 1292_1293 1293 4256.89
c_1292_1293_i 1292 1292_1293 4.67522e-10
r_1852_1853_e 1852 1853 836.944
r_1852_1853_i 1852_1853 1853 4256.89
c_1852_1853_i 1852 1852_1853 4.67522e-10
r_2412_2413_e 2412 2413 836.944
r_2412_2413_i 2412_2413 2413 4256.89
c_2412_2413_i 2412 2412_2413 4.67522e-10
r_2972_2973_e 2972 2973 13758.3
r_2972_2973_i 2972_2973 2973 95645.6
c_2972_2973_i 2972 2972_2973 9.36084e-12
r_3532_3533_e 3532 3533 13758.3
r_3532_3533_i 3532_3533 3533 95645.6
c_3532_3533_i 3532 3532_3533 9.36084e-12
r_173_174_e 173 174 13376.4
r_173_174_i 173_174 174 93218.1
c_173_174_i 173 173_174 2.08965e-09
r_733_734_e 733 734 13376.4
r_733_734_i 733_734 734 93218.1
c_733_734_i 733 733_734 2.08965e-09
r_1293_1294_e 1293 1294 836.944
r_1293_1294_i 1293_1294 1294 4256.89
c_1293_1294_i 1293 1293_1294 4.67522e-10
r_1853_1854_e 1853 1854 836.944
r_1853_1854_i 1853_1854 1854 4256.89
c_1853_1854_i 1853 1853_1854 4.67522e-10
r_2413_2414_e 2413 2414 836.944
r_2413_2414_i 2413_2414 2414 4256.89
c_2413_2414_i 2413 2413_2414 4.67522e-10
r_2973_2974_e 2973 2974 13758.3
r_2973_2974_i 2973_2974 2974 95645.6
c_2973_2974_i 2973 2973_2974 9.36084e-12
r_3533_3534_e 3533 3534 13758.3
r_3533_3534_i 3533_3534 3534 95645.6
c_3533_3534_i 3533 3533_3534 9.36084e-12
r_174_175_e 174 175 13376.4
r_174_175_i 174_175 175 93218.1
c_174_175_i 174 174_175 2.08965e-09
r_734_735_e 734 735 13376.4
r_734_735_i 734_735 735 93218.1
c_734_735_i 734 734_735 2.08965e-09
r_1294_1295_e 1294 1295 836.944
r_1294_1295_i 1294_1295 1295 4256.89
c_1294_1295_i 1294 1294_1295 4.67522e-10
r_1854_1855_e 1854 1855 836.944
r_1854_1855_i 1854_1855 1855 4256.89
c_1854_1855_i 1854 1854_1855 4.67522e-10
r_2414_2415_e 2414 2415 836.944
r_2414_2415_i 2414_2415 2415 4256.89
c_2414_2415_i 2414 2414_2415 4.67522e-10
r_2974_2975_e 2974 2975 13758.3
r_2974_2975_i 2974_2975 2975 95645.6
c_2974_2975_i 2974 2974_2975 9.36084e-12
r_3534_3535_e 3534 3535 13758.3
r_3534_3535_i 3534_3535 3535 95645.6
c_3534_3535_i 3534 3534_3535 9.36084e-12
r_175_176_e 175 176 13376.4
r_175_176_i 175_176 176 93218.1
c_175_176_i 175 175_176 2.08965e-09
r_735_736_e 735 736 13376.4
r_735_736_i 735_736 736 93218.1
c_735_736_i 735 735_736 2.08965e-09
r_1295_1296_e 1295 1296 836.944
r_1295_1296_i 1295_1296 1296 4256.89
c_1295_1296_i 1295 1295_1296 4.67522e-10
r_1855_1856_e 1855 1856 836.944
r_1855_1856_i 1855_1856 1856 4256.89
c_1855_1856_i 1855 1855_1856 4.67522e-10
r_2415_2416_e 2415 2416 836.944
r_2415_2416_i 2415_2416 2416 4256.89
c_2415_2416_i 2415 2415_2416 4.67522e-10
r_2975_2976_e 2975 2976 13758.3
r_2975_2976_i 2975_2976 2976 95645.6
c_2975_2976_i 2975 2975_2976 9.36084e-12
r_3535_3536_e 3535 3536 13758.3
r_3535_3536_i 3535_3536 3536 95645.6
c_3535_3536_i 3535 3535_3536 9.36084e-12
r_177_178_e 177 178 13376.4
r_177_178_i 177_178 178 93218.1
c_177_178_i 177 177_178 2.08965e-09
r_737_738_e 737 738 13376.4
r_737_738_i 737_738 738 93218.1
c_737_738_i 737 737_738 2.08965e-09
r_1297_1298_e 1297 1298 13376.4
r_1297_1298_i 1297_1298 1298 93218.1
c_1297_1298_i 1297 1297_1298 2.08965e-09
r_1857_1858_e 1857 1858 13376.4
r_1857_1858_i 1857_1858 1858 93218.1
c_1857_1858_i 1857 1857_1858 2.08965e-09
r_2417_2418_e 2417 2418 13376.4
r_2417_2418_i 2417_2418 2418 93218.1
c_2417_2418_i 2417 2417_2418 2.08965e-09
r_2977_2978_e 2977 2978 13376.4
r_2977_2978_i 2977_2978 2978 93218.1
c_2977_2978_i 2977 2977_2978 2.08965e-09
r_3537_3538_e 3537 3538 13376.4
r_3537_3538_i 3537_3538 3538 93218.1
c_3537_3538_i 3537 3537_3538 2.08965e-09
r_178_179_e 178 179 13376.4
r_178_179_i 178_179 179 93218.1
c_178_179_i 178 178_179 2.08965e-09
r_738_739_e 738 739 13376.4
r_738_739_i 738_739 739 93218.1
c_738_739_i 738 738_739 2.08965e-09
r_1298_1299_e 1298 1299 13376.4
r_1298_1299_i 1298_1299 1299 93218.1
c_1298_1299_i 1298 1298_1299 2.08965e-09
r_1858_1859_e 1858 1859 13376.4
r_1858_1859_i 1858_1859 1859 93218.1
c_1858_1859_i 1858 1858_1859 2.08965e-09
r_2418_2419_e 2418 2419 13376.4
r_2418_2419_i 2418_2419 2419 93218.1
c_2418_2419_i 2418 2418_2419 2.08965e-09
r_2978_2979_e 2978 2979 13376.4
r_2978_2979_i 2978_2979 2979 93218.1
c_2978_2979_i 2978 2978_2979 2.08965e-09
r_3538_3539_e 3538 3539 13376.4
r_3538_3539_i 3538_3539 3539 93218.1
c_3538_3539_i 3538 3538_3539 2.08965e-09
r_179_180_e 179 180 13376.4
r_179_180_i 179_180 180 93218.1
c_179_180_i 179 179_180 2.08965e-09
r_739_740_e 739 740 13376.4
r_739_740_i 739_740 740 93218.1
c_739_740_i 739 739_740 2.08965e-09
r_1299_1300_e 1299 1300 836.944
r_1299_1300_i 1299_1300 1300 4256.89
c_1299_1300_i 1299 1299_1300 4.67522e-10
r_1859_1860_e 1859 1860 836.944
r_1859_1860_i 1859_1860 1860 4256.89
c_1859_1860_i 1859 1859_1860 4.67522e-10
r_2419_2420_e 2419 2420 836.944
r_2419_2420_i 2419_2420 2420 4256.89
c_2419_2420_i 2419 2419_2420 4.67522e-10
r_2979_2980_e 2979 2980 836.944
r_2979_2980_i 2979_2980 2980 4256.89
c_2979_2980_i 2979 2979_2980 4.67522e-10
r_3539_3540_e 3539 3540 836.944
r_3539_3540_i 3539_3540 3540 4256.89
c_3539_3540_i 3539 3539_3540 4.67522e-10
r_180_181_e 180 181 13376.4
r_180_181_i 180_181 181 93218.1
c_180_181_i 180 180_181 2.08965e-09
r_740_741_e 740 741 13376.4
r_740_741_i 740_741 741 93218.1
c_740_741_i 740 740_741 2.08965e-09
r_1300_1301_e 1300 1301 836.944
r_1300_1301_i 1300_1301 1301 4256.89
c_1300_1301_i 1300 1300_1301 4.67522e-10
r_1860_1861_e 1860 1861 836.944
r_1860_1861_i 1860_1861 1861 4256.89
c_1860_1861_i 1860 1860_1861 4.67522e-10
r_2420_2421_e 2420 2421 836.944
r_2420_2421_i 2420_2421 2421 4256.89
c_2420_2421_i 2420 2420_2421 4.67522e-10
r_2980_2981_e 2980 2981 13758.3
r_2980_2981_i 2980_2981 2981 95645.6
c_2980_2981_i 2980 2980_2981 9.36084e-12
r_3540_3541_e 3540 3541 13758.3
r_3540_3541_i 3540_3541 3541 95645.6
c_3540_3541_i 3540 3540_3541 9.36084e-12
r_181_182_e 181 182 13376.4
r_181_182_i 181_182 182 93218.1
c_181_182_i 181 181_182 2.08965e-09
r_741_742_e 741 742 13376.4
r_741_742_i 741_742 742 93218.1
c_741_742_i 741 741_742 2.08965e-09
r_1301_1302_e 1301 1302 836.944
r_1301_1302_i 1301_1302 1302 4256.89
c_1301_1302_i 1301 1301_1302 4.67522e-10
r_1861_1862_e 1861 1862 836.944
r_1861_1862_i 1861_1862 1862 4256.89
c_1861_1862_i 1861 1861_1862 4.67522e-10
r_2421_2422_e 2421 2422 836.944
r_2421_2422_i 2421_2422 2422 4256.89
c_2421_2422_i 2421 2421_2422 4.67522e-10
r_2981_2982_e 2981 2982 13758.3
r_2981_2982_i 2981_2982 2982 95645.6
c_2981_2982_i 2981 2981_2982 9.36084e-12
r_3541_3542_e 3541 3542 13758.3
r_3541_3542_i 3541_3542 3542 95645.6
c_3541_3542_i 3541 3541_3542 9.36084e-12
r_182_183_e 182 183 13376.4
r_182_183_i 182_183 183 93218.1
c_182_183_i 182 182_183 2.08965e-09
r_742_743_e 742 743 13376.4
r_742_743_i 742_743 743 93218.1
c_742_743_i 742 742_743 2.08965e-09
r_1302_1303_e 1302 1303 836.944
r_1302_1303_i 1302_1303 1303 4256.89
c_1302_1303_i 1302 1302_1303 4.67522e-10
r_1862_1863_e 1862 1863 836.944
r_1862_1863_i 1862_1863 1863 4256.89
c_1862_1863_i 1862 1862_1863 4.67522e-10
r_2422_2423_e 2422 2423 836.944
r_2422_2423_i 2422_2423 2423 4256.89
c_2422_2423_i 2422 2422_2423 4.67522e-10
r_2982_2983_e 2982 2983 13758.3
r_2982_2983_i 2982_2983 2983 95645.6
c_2982_2983_i 2982 2982_2983 9.36084e-12
r_3542_3543_e 3542 3543 13758.3
r_3542_3543_i 3542_3543 3543 95645.6
c_3542_3543_i 3542 3542_3543 9.36084e-12
r_183_184_e 183 184 13376.4
r_183_184_i 183_184 184 93218.1
c_183_184_i 183 183_184 2.08965e-09
r_743_744_e 743 744 13376.4
r_743_744_i 743_744 744 93218.1
c_743_744_i 743 743_744 2.08965e-09
r_1303_1304_e 1303 1304 836.944
r_1303_1304_i 1303_1304 1304 4256.89
c_1303_1304_i 1303 1303_1304 4.67522e-10
r_1863_1864_e 1863 1864 836.944
r_1863_1864_i 1863_1864 1864 4256.89
c_1863_1864_i 1863 1863_1864 4.67522e-10
r_2423_2424_e 2423 2424 836.944
r_2423_2424_i 2423_2424 2424 4256.89
c_2423_2424_i 2423 2423_2424 4.67522e-10
r_2983_2984_e 2983 2984 13758.3
r_2983_2984_i 2983_2984 2984 95645.6
c_2983_2984_i 2983 2983_2984 9.36084e-12
r_3543_3544_e 3543 3544 13758.3
r_3543_3544_i 3543_3544 3544 95645.6
c_3543_3544_i 3543 3543_3544 9.36084e-12
r_184_185_e 184 185 13376.4
r_184_185_i 184_185 185 93218.1
c_184_185_i 184 184_185 2.08965e-09
r_744_745_e 744 745 13376.4
r_744_745_i 744_745 745 93218.1
c_744_745_i 744 744_745 2.08965e-09
r_1304_1305_e 1304 1305 836.944
r_1304_1305_i 1304_1305 1305 4256.89
c_1304_1305_i 1304 1304_1305 4.67522e-10
r_1864_1865_e 1864 1865 836.944
r_1864_1865_i 1864_1865 1865 4256.89
c_1864_1865_i 1864 1864_1865 4.67522e-10
r_2424_2425_e 2424 2425 836.944
r_2424_2425_i 2424_2425 2425 4256.89
c_2424_2425_i 2424 2424_2425 4.67522e-10
r_2984_2985_e 2984 2985 13758.3
r_2984_2985_i 2984_2985 2985 95645.6
c_2984_2985_i 2984 2984_2985 9.36084e-12
r_3544_3545_e 3544 3545 13758.3
r_3544_3545_i 3544_3545 3545 95645.6
c_3544_3545_i 3544 3544_3545 9.36084e-12
r_185_186_e 185 186 13376.4
r_185_186_i 185_186 186 93218.1
c_185_186_i 185 185_186 2.08965e-09
r_745_746_e 745 746 13376.4
r_745_746_i 745_746 746 93218.1
c_745_746_i 745 745_746 2.08965e-09
r_1305_1306_e 1305 1306 836.944
r_1305_1306_i 1305_1306 1306 4256.89
c_1305_1306_i 1305 1305_1306 4.67522e-10
r_1865_1866_e 1865 1866 836.944
r_1865_1866_i 1865_1866 1866 4256.89
c_1865_1866_i 1865 1865_1866 4.67522e-10
r_2425_2426_e 2425 2426 836.944
r_2425_2426_i 2425_2426 2426 4256.89
c_2425_2426_i 2425 2425_2426 4.67522e-10
r_2985_2986_e 2985 2986 13758.3
r_2985_2986_i 2985_2986 2986 95645.6
c_2985_2986_i 2985 2985_2986 9.36084e-12
r_3545_3546_e 3545 3546 13758.3
r_3545_3546_i 3545_3546 3546 95645.6
c_3545_3546_i 3545 3545_3546 9.36084e-12
r_186_187_e 186 187 13376.4
r_186_187_i 186_187 187 93218.1
c_186_187_i 186 186_187 2.08965e-09
r_746_747_e 746 747 13376.4
r_746_747_i 746_747 747 93218.1
c_746_747_i 746 746_747 2.08965e-09
r_1306_1307_e 1306 1307 836.944
r_1306_1307_i 1306_1307 1307 4256.89
c_1306_1307_i 1306 1306_1307 4.67522e-10
r_1866_1867_e 1866 1867 836.944
r_1866_1867_i 1866_1867 1867 4256.89
c_1866_1867_i 1866 1866_1867 4.67522e-10
r_2426_2427_e 2426 2427 836.944
r_2426_2427_i 2426_2427 2427 4256.89
c_2426_2427_i 2426 2426_2427 4.67522e-10
r_2986_2987_e 2986 2987 13758.3
r_2986_2987_i 2986_2987 2987 95645.6
c_2986_2987_i 2986 2986_2987 9.36084e-12
r_3546_3547_e 3546 3547 13758.3
r_3546_3547_i 3546_3547 3547 95645.6
c_3546_3547_i 3546 3546_3547 9.36084e-12
r_187_188_e 187 188 13376.4
r_187_188_i 187_188 188 93218.1
c_187_188_i 187 187_188 2.08965e-09
r_747_748_e 747 748 13376.4
r_747_748_i 747_748 748 93218.1
c_747_748_i 747 747_748 2.08965e-09
r_1307_1308_e 1307 1308 396.68
r_1307_1308_i 1307_1308 1308 1005.22
c_1307_1308_i 1307 1307_1308 1.65803e-10
r_1867_1868_e 1867 1868 396.68
r_1867_1868_i 1867_1868 1868 1005.22
c_1867_1868_i 1867 1867_1868 1.65803e-10
r_2427_2428_e 2427 2428 836.944
r_2427_2428_i 2427_2428 2428 4256.89
c_2427_2428_i 2427 2427_2428 4.67522e-10
r_2987_2988_e 2987 2988 13758.3
r_2987_2988_i 2987_2988 2988 95645.6
c_2987_2988_i 2987 2987_2988 9.36084e-12
r_3547_3548_e 3547 3548 13758.3
r_3547_3548_i 3547_3548 3548 95645.6
c_3547_3548_i 3547 3547_3548 9.36084e-12
r_188_189_e 188 189 13376.4
r_188_189_i 188_189 189 93218.1
c_188_189_i 188 188_189 2.08965e-09
r_748_749_e 748 749 13376.4
r_748_749_i 748_749 749 93218.1
c_748_749_i 748 748_749 2.08965e-09
r_1308_1309_e 1308 1309 836.944
r_1308_1309_i 1308_1309 1309 4256.89
c_1308_1309_i 1308 1308_1309 4.67522e-10
r_1868_1869_e 1868 1869 836.944
r_1868_1869_i 1868_1869 1869 4256.89
c_1868_1869_i 1868 1868_1869 4.67522e-10
r_2428_2429_e 2428 2429 836.944
r_2428_2429_i 2428_2429 2429 4256.89
c_2428_2429_i 2428 2428_2429 4.67522e-10
r_2988_2989_e 2988 2989 13758.3
r_2988_2989_i 2988_2989 2989 95645.6
c_2988_2989_i 2988 2988_2989 9.36084e-12
r_3548_3549_e 3548 3549 13758.3
r_3548_3549_i 3548_3549 3549 95645.6
c_3548_3549_i 3548 3548_3549 9.36084e-12
r_189_190_e 189 190 13376.4
r_189_190_i 189_190 190 93218.1
c_189_190_i 189 189_190 2.08965e-09
r_749_750_e 749 750 13376.4
r_749_750_i 749_750 750 93218.1
c_749_750_i 749 749_750 2.08965e-09
r_1309_1310_e 1309 1310 836.944
r_1309_1310_i 1309_1310 1310 4256.89
c_1309_1310_i 1309 1309_1310 4.67522e-10
r_1869_1870_e 1869 1870 836.944
r_1869_1870_i 1869_1870 1870 4256.89
c_1869_1870_i 1869 1869_1870 4.67522e-10
r_2429_2430_e 2429 2430 836.944
r_2429_2430_i 2429_2430 2430 4256.89
c_2429_2430_i 2429 2429_2430 4.67522e-10
r_2989_2990_e 2989 2990 13758.3
r_2989_2990_i 2989_2990 2990 95645.6
c_2989_2990_i 2989 2989_2990 9.36084e-12
r_3549_3550_e 3549 3550 13758.3
r_3549_3550_i 3549_3550 3550 95645.6
c_3549_3550_i 3549 3549_3550 9.36084e-12
r_190_191_e 190 191 13376.4
r_190_191_i 190_191 191 93218.1
c_190_191_i 190 190_191 2.08965e-09
r_750_751_e 750 751 13376.4
r_750_751_i 750_751 751 93218.1
c_750_751_i 750 750_751 2.08965e-09
r_1310_1311_e 1310 1311 836.944
r_1310_1311_i 1310_1311 1311 4256.89
c_1310_1311_i 1310 1310_1311 4.67522e-10
r_1870_1871_e 1870 1871 836.944
r_1870_1871_i 1870_1871 1871 4256.89
c_1870_1871_i 1870 1870_1871 4.67522e-10
r_2430_2431_e 2430 2431 836.944
r_2430_2431_i 2430_2431 2431 4256.89
c_2430_2431_i 2430 2430_2431 4.67522e-10
r_2990_2991_e 2990 2991 13758.3
r_2990_2991_i 2990_2991 2991 95645.6
c_2990_2991_i 2990 2990_2991 9.36084e-12
r_3550_3551_e 3550 3551 13758.3
r_3550_3551_i 3550_3551 3551 95645.6
c_3550_3551_i 3550 3550_3551 9.36084e-12
r_191_192_e 191 192 13376.4
r_191_192_i 191_192 192 93218.1
c_191_192_i 191 191_192 2.08965e-09
r_751_752_e 751 752 13376.4
r_751_752_i 751_752 752 93218.1
c_751_752_i 751 751_752 2.08965e-09
r_1311_1312_e 1311 1312 836.944
r_1311_1312_i 1311_1312 1312 4256.89
c_1311_1312_i 1311 1311_1312 4.67522e-10
r_1871_1872_e 1871 1872 836.944
r_1871_1872_i 1871_1872 1872 4256.89
c_1871_1872_i 1871 1871_1872 4.67522e-10
r_2431_2432_e 2431 2432 836.944
r_2431_2432_i 2431_2432 2432 4256.89
c_2431_2432_i 2431 2431_2432 4.67522e-10
r_2991_2992_e 2991 2992 13758.3
r_2991_2992_i 2991_2992 2992 95645.6
c_2991_2992_i 2991 2991_2992 9.36084e-12
r_3551_3552_e 3551 3552 13758.3
r_3551_3552_i 3551_3552 3552 95645.6
c_3551_3552_i 3551 3551_3552 9.36084e-12
r_193_194_e 193 194 13376.4
r_193_194_i 193_194 194 93218.1
c_193_194_i 193 193_194 2.08965e-09
r_753_754_e 753 754 13376.4
r_753_754_i 753_754 754 93218.1
c_753_754_i 753 753_754 2.08965e-09
r_1313_1314_e 1313 1314 13376.4
r_1313_1314_i 1313_1314 1314 93218.1
c_1313_1314_i 1313 1313_1314 2.08965e-09
r_1873_1874_e 1873 1874 13376.4
r_1873_1874_i 1873_1874 1874 93218.1
c_1873_1874_i 1873 1873_1874 2.08965e-09
r_2433_2434_e 2433 2434 13376.4
r_2433_2434_i 2433_2434 2434 93218.1
c_2433_2434_i 2433 2433_2434 2.08965e-09
r_2993_2994_e 2993 2994 13376.4
r_2993_2994_i 2993_2994 2994 93218.1
c_2993_2994_i 2993 2993_2994 2.08965e-09
r_3553_3554_e 3553 3554 13376.4
r_3553_3554_i 3553_3554 3554 93218.1
c_3553_3554_i 3553 3553_3554 2.08965e-09
r_194_195_e 194 195 13376.4
r_194_195_i 194_195 195 93218.1
c_194_195_i 194 194_195 2.08965e-09
r_754_755_e 754 755 13376.4
r_754_755_i 754_755 755 93218.1
c_754_755_i 754 754_755 2.08965e-09
r_1314_1315_e 1314 1315 13376.4
r_1314_1315_i 1314_1315 1315 93218.1
c_1314_1315_i 1314 1314_1315 2.08965e-09
r_1874_1875_e 1874 1875 13376.4
r_1874_1875_i 1874_1875 1875 93218.1
c_1874_1875_i 1874 1874_1875 2.08965e-09
r_2434_2435_e 2434 2435 13376.4
r_2434_2435_i 2434_2435 2435 93218.1
c_2434_2435_i 2434 2434_2435 2.08965e-09
r_2994_2995_e 2994 2995 13376.4
r_2994_2995_i 2994_2995 2995 93218.1
c_2994_2995_i 2994 2994_2995 2.08965e-09
r_3554_3555_e 3554 3555 13376.4
r_3554_3555_i 3554_3555 3555 93218.1
c_3554_3555_i 3554 3554_3555 2.08965e-09
r_195_196_e 195 196 13376.4
r_195_196_i 195_196 196 93218.1
c_195_196_i 195 195_196 2.08965e-09
r_755_756_e 755 756 13376.4
r_755_756_i 755_756 756 93218.1
c_755_756_i 755 755_756 2.08965e-09
r_1315_1316_e 1315 1316 836.944
r_1315_1316_i 1315_1316 1316 4256.89
c_1315_1316_i 1315 1315_1316 4.67522e-10
r_1875_1876_e 1875 1876 836.944
r_1875_1876_i 1875_1876 1876 4256.89
c_1875_1876_i 1875 1875_1876 4.67522e-10
r_2435_2436_e 2435 2436 836.944
r_2435_2436_i 2435_2436 2436 4256.89
c_2435_2436_i 2435 2435_2436 4.67522e-10
r_2995_2996_e 2995 2996 836.944
r_2995_2996_i 2995_2996 2996 4256.89
c_2995_2996_i 2995 2995_2996 4.67522e-10
r_3555_3556_e 3555 3556 836.944
r_3555_3556_i 3555_3556 3556 4256.89
c_3555_3556_i 3555 3555_3556 4.67522e-10
r_196_197_e 196 197 13376.4
r_196_197_i 196_197 197 93218.1
c_196_197_i 196 196_197 2.08965e-09
r_756_757_e 756 757 13376.4
r_756_757_i 756_757 757 93218.1
c_756_757_i 756 756_757 2.08965e-09
r_1316_1317_e 1316 1317 836.944
r_1316_1317_i 1316_1317 1317 4256.89
c_1316_1317_i 1316 1316_1317 4.67522e-10
r_1876_1877_e 1876 1877 836.944
r_1876_1877_i 1876_1877 1877 4256.89
c_1876_1877_i 1876 1876_1877 4.67522e-10
r_2436_2437_e 2436 2437 836.944
r_2436_2437_i 2436_2437 2437 4256.89
c_2436_2437_i 2436 2436_2437 4.67522e-10
r_2996_2997_e 2996 2997 13758.3
r_2996_2997_i 2996_2997 2997 95645.6
c_2996_2997_i 2996 2996_2997 9.36084e-12
r_3556_3557_e 3556 3557 13758.3
r_3556_3557_i 3556_3557 3557 95645.6
c_3556_3557_i 3556 3556_3557 9.36084e-12
r_197_198_e 197 198 13376.4
r_197_198_i 197_198 198 93218.1
c_197_198_i 197 197_198 2.08965e-09
r_757_758_e 757 758 13376.4
r_757_758_i 757_758 758 93218.1
c_757_758_i 757 757_758 2.08965e-09
r_1317_1318_e 1317 1318 836.944
r_1317_1318_i 1317_1318 1318 4256.89
c_1317_1318_i 1317 1317_1318 4.67522e-10
r_1877_1878_e 1877 1878 836.944
r_1877_1878_i 1877_1878 1878 4256.89
c_1877_1878_i 1877 1877_1878 4.67522e-10
r_2437_2438_e 2437 2438 836.944
r_2437_2438_i 2437_2438 2438 4256.89
c_2437_2438_i 2437 2437_2438 4.67522e-10
r_2997_2998_e 2997 2998 13758.3
r_2997_2998_i 2997_2998 2998 95645.6
c_2997_2998_i 2997 2997_2998 9.36084e-12
r_3557_3558_e 3557 3558 13758.3
r_3557_3558_i 3557_3558 3558 95645.6
c_3557_3558_i 3557 3557_3558 9.36084e-12
r_198_199_e 198 199 13376.4
r_198_199_i 198_199 199 93218.1
c_198_199_i 198 198_199 2.08965e-09
r_758_759_e 758 759 13376.4
r_758_759_i 758_759 759 93218.1
c_758_759_i 758 758_759 2.08965e-09
r_1318_1319_e 1318 1319 836.944
r_1318_1319_i 1318_1319 1319 4256.89
c_1318_1319_i 1318 1318_1319 4.67522e-10
r_1878_1879_e 1878 1879 836.944
r_1878_1879_i 1878_1879 1879 4256.89
c_1878_1879_i 1878 1878_1879 4.67522e-10
r_2438_2439_e 2438 2439 836.944
r_2438_2439_i 2438_2439 2439 4256.89
c_2438_2439_i 2438 2438_2439 4.67522e-10
r_2998_2999_e 2998 2999 13758.3
r_2998_2999_i 2998_2999 2999 95645.6
c_2998_2999_i 2998 2998_2999 9.36084e-12
r_3558_3559_e 3558 3559 13758.3
r_3558_3559_i 3558_3559 3559 95645.6
c_3558_3559_i 3558 3558_3559 9.36084e-12
r_199_200_e 199 200 13376.4
r_199_200_i 199_200 200 93218.1
c_199_200_i 199 199_200 2.08965e-09
r_759_760_e 759 760 13376.4
r_759_760_i 759_760 760 93218.1
c_759_760_i 759 759_760 2.08965e-09
r_1319_1320_e 1319 1320 836.944
r_1319_1320_i 1319_1320 1320 4256.89
c_1319_1320_i 1319 1319_1320 4.67522e-10
r_1879_1880_e 1879 1880 836.944
r_1879_1880_i 1879_1880 1880 4256.89
c_1879_1880_i 1879 1879_1880 4.67522e-10
r_2439_2440_e 2439 2440 836.944
r_2439_2440_i 2439_2440 2440 4256.89
c_2439_2440_i 2439 2439_2440 4.67522e-10
r_2999_3000_e 2999 3000 13758.3
r_2999_3000_i 2999_3000 3000 95645.6
c_2999_3000_i 2999 2999_3000 9.36084e-12
r_3559_3560_e 3559 3560 13758.3
r_3559_3560_i 3559_3560 3560 95645.6
c_3559_3560_i 3559 3559_3560 9.36084e-12
r_200_201_e 200 201 13376.4
r_200_201_i 200_201 201 93218.1
c_200_201_i 200 200_201 2.08965e-09
r_760_761_e 760 761 13376.4
r_760_761_i 760_761 761 93218.1
c_760_761_i 760 760_761 2.08965e-09
r_1320_1321_e 1320 1321 836.944
r_1320_1321_i 1320_1321 1321 4256.89
c_1320_1321_i 1320 1320_1321 4.67522e-10
r_1880_1881_e 1880 1881 836.944
r_1880_1881_i 1880_1881 1881 4256.89
c_1880_1881_i 1880 1880_1881 4.67522e-10
r_2440_2441_e 2440 2441 836.944
r_2440_2441_i 2440_2441 2441 4256.89
c_2440_2441_i 2440 2440_2441 4.67522e-10
r_3000_3001_e 3000 3001 13758.3
r_3000_3001_i 3000_3001 3001 95645.6
c_3000_3001_i 3000 3000_3001 9.36084e-12
r_3560_3561_e 3560 3561 13758.3
r_3560_3561_i 3560_3561 3561 95645.6
c_3560_3561_i 3560 3560_3561 9.36084e-12
r_201_202_e 201 202 13376.4
r_201_202_i 201_202 202 93218.1
c_201_202_i 201 201_202 2.08965e-09
r_761_762_e 761 762 13376.4
r_761_762_i 761_762 762 93218.1
c_761_762_i 761 761_762 2.08965e-09
r_1321_1322_e 1321 1322 836.944
r_1321_1322_i 1321_1322 1322 4256.89
c_1321_1322_i 1321 1321_1322 4.67522e-10
r_1881_1882_e 1881 1882 836.944
r_1881_1882_i 1881_1882 1882 4256.89
c_1881_1882_i 1881 1881_1882 4.67522e-10
r_2441_2442_e 2441 2442 836.944
r_2441_2442_i 2441_2442 2442 4256.89
c_2441_2442_i 2441 2441_2442 4.67522e-10
r_3001_3002_e 3001 3002 13758.3
r_3001_3002_i 3001_3002 3002 95645.6
c_3001_3002_i 3001 3001_3002 9.36084e-12
r_3561_3562_e 3561 3562 13758.3
r_3561_3562_i 3561_3562 3562 95645.6
c_3561_3562_i 3561 3561_3562 9.36084e-12
r_202_203_e 202 203 13376.4
r_202_203_i 202_203 203 93218.1
c_202_203_i 202 202_203 2.08965e-09
r_762_763_e 762 763 13376.4
r_762_763_i 762_763 763 93218.1
c_762_763_i 762 762_763 2.08965e-09
r_1322_1323_e 1322 1323 836.944
r_1322_1323_i 1322_1323 1323 4256.89
c_1322_1323_i 1322 1322_1323 4.67522e-10
r_1882_1883_e 1882 1883 836.944
r_1882_1883_i 1882_1883 1883 4256.89
c_1882_1883_i 1882 1882_1883 4.67522e-10
r_2442_2443_e 2442 2443 836.944
r_2442_2443_i 2442_2443 2443 4256.89
c_2442_2443_i 2442 2442_2443 4.67522e-10
r_3002_3003_e 3002 3003 13758.3
r_3002_3003_i 3002_3003 3003 95645.6
c_3002_3003_i 3002 3002_3003 9.36084e-12
r_3562_3563_e 3562 3563 13758.3
r_3562_3563_i 3562_3563 3563 95645.6
c_3562_3563_i 3562 3562_3563 9.36084e-12
r_203_204_e 203 204 13376.4
r_203_204_i 203_204 204 93218.1
c_203_204_i 203 203_204 2.08965e-09
r_763_764_e 763 764 13376.4
r_763_764_i 763_764 764 93218.1
c_763_764_i 763 763_764 2.08965e-09
r_1323_1324_e 1323 1324 396.671
r_1323_1324_i 1323_1324 1324 1005.2
c_1323_1324_i 1323 1323_1324 1.65806e-10
r_1883_1884_e 1883 1884 396.671
r_1883_1884_i 1883_1884 1884 1005.2
c_1883_1884_i 1883 1883_1884 1.65806e-10
r_2443_2444_e 2443 2444 836.944
r_2443_2444_i 2443_2444 2444 4256.89
c_2443_2444_i 2443 2443_2444 4.67522e-10
r_3003_3004_e 3003 3004 13758.3
r_3003_3004_i 3003_3004 3004 95645.6
c_3003_3004_i 3003 3003_3004 9.36084e-12
r_3563_3564_e 3563 3564 13758.3
r_3563_3564_i 3563_3564 3564 95645.6
c_3563_3564_i 3563 3563_3564 9.36084e-12
r_204_205_e 204 205 13376.4
r_204_205_i 204_205 205 93218.1
c_204_205_i 204 204_205 2.08965e-09
r_764_765_e 764 765 13376.4
r_764_765_i 764_765 765 93218.1
c_764_765_i 764 764_765 2.08965e-09
r_1324_1325_e 1324 1325 836.944
r_1324_1325_i 1324_1325 1325 4256.89
c_1324_1325_i 1324 1324_1325 4.67522e-10
r_1884_1885_e 1884 1885 836.944
r_1884_1885_i 1884_1885 1885 4256.89
c_1884_1885_i 1884 1884_1885 4.67522e-10
r_2444_2445_e 2444 2445 836.944
r_2444_2445_i 2444_2445 2445 4256.89
c_2444_2445_i 2444 2444_2445 4.67522e-10
r_3004_3005_e 3004 3005 13758.3
r_3004_3005_i 3004_3005 3005 95645.6
c_3004_3005_i 3004 3004_3005 9.36084e-12
r_3564_3565_e 3564 3565 13758.3
r_3564_3565_i 3564_3565 3565 95645.6
c_3564_3565_i 3564 3564_3565 9.36084e-12
r_205_206_e 205 206 13376.4
r_205_206_i 205_206 206 93218.1
c_205_206_i 205 205_206 2.08965e-09
r_765_766_e 765 766 13376.4
r_765_766_i 765_766 766 93218.1
c_765_766_i 765 765_766 2.08965e-09
r_1325_1326_e 1325 1326 836.944
r_1325_1326_i 1325_1326 1326 4256.89
c_1325_1326_i 1325 1325_1326 4.67522e-10
r_1885_1886_e 1885 1886 836.944
r_1885_1886_i 1885_1886 1886 4256.89
c_1885_1886_i 1885 1885_1886 4.67522e-10
r_2445_2446_e 2445 2446 836.944
r_2445_2446_i 2445_2446 2446 4256.89
c_2445_2446_i 2445 2445_2446 4.67522e-10
r_3005_3006_e 3005 3006 13758.3
r_3005_3006_i 3005_3006 3006 95645.6
c_3005_3006_i 3005 3005_3006 9.36084e-12
r_3565_3566_e 3565 3566 13758.3
r_3565_3566_i 3565_3566 3566 95645.6
c_3565_3566_i 3565 3565_3566 9.36084e-12
r_206_207_e 206 207 13376.4
r_206_207_i 206_207 207 93218.1
c_206_207_i 206 206_207 2.08965e-09
r_766_767_e 766 767 13376.4
r_766_767_i 766_767 767 93218.1
c_766_767_i 766 766_767 2.08965e-09
r_1326_1327_e 1326 1327 836.944
r_1326_1327_i 1326_1327 1327 4256.89
c_1326_1327_i 1326 1326_1327 4.67522e-10
r_1886_1887_e 1886 1887 836.944
r_1886_1887_i 1886_1887 1887 4256.89
c_1886_1887_i 1886 1886_1887 4.67522e-10
r_2446_2447_e 2446 2447 836.944
r_2446_2447_i 2446_2447 2447 4256.89
c_2446_2447_i 2446 2446_2447 4.67522e-10
r_3006_3007_e 3006 3007 13758.3
r_3006_3007_i 3006_3007 3007 95645.6
c_3006_3007_i 3006 3006_3007 9.36084e-12
r_3566_3567_e 3566 3567 13758.3
r_3566_3567_i 3566_3567 3567 95645.6
c_3566_3567_i 3566 3566_3567 9.36084e-12
r_207_208_e 207 208 13376.4
r_207_208_i 207_208 208 93218.1
c_207_208_i 207 207_208 2.08965e-09
r_767_768_e 767 768 13376.4
r_767_768_i 767_768 768 93218.1
c_767_768_i 767 767_768 2.08965e-09
r_1327_1328_e 1327 1328 836.944
r_1327_1328_i 1327_1328 1328 4256.89
c_1327_1328_i 1327 1327_1328 4.67522e-10
r_1887_1888_e 1887 1888 836.944
r_1887_1888_i 1887_1888 1888 4256.89
c_1887_1888_i 1887 1887_1888 4.67522e-10
r_2447_2448_e 2447 2448 836.944
r_2447_2448_i 2447_2448 2448 4256.89
c_2447_2448_i 2447 2447_2448 4.67522e-10
r_3007_3008_e 3007 3008 13758.3
r_3007_3008_i 3007_3008 3008 95645.6
c_3007_3008_i 3007 3007_3008 9.36084e-12
r_3567_3568_e 3567 3568 13758.3
r_3567_3568_i 3567_3568 3568 95645.6
c_3567_3568_i 3567 3567_3568 9.36084e-12
r_209_210_e 209 210 13376.4
r_209_210_i 209_210 210 93218.1
c_209_210_i 209 209_210 2.08965e-09
r_769_770_e 769 770 13376.4
r_769_770_i 769_770 770 93218.1
c_769_770_i 769 769_770 2.08965e-09
r_1329_1330_e 1329 1330 13376.4
r_1329_1330_i 1329_1330 1330 93218.1
c_1329_1330_i 1329 1329_1330 2.08965e-09
r_1889_1890_e 1889 1890 13376.4
r_1889_1890_i 1889_1890 1890 93218.1
c_1889_1890_i 1889 1889_1890 2.08965e-09
r_2449_2450_e 2449 2450 13376.4
r_2449_2450_i 2449_2450 2450 93218.1
c_2449_2450_i 2449 2449_2450 2.08965e-09
r_3009_3010_e 3009 3010 13376.4
r_3009_3010_i 3009_3010 3010 93218.1
c_3009_3010_i 3009 3009_3010 2.08965e-09
r_3569_3570_e 3569 3570 13376.4
r_3569_3570_i 3569_3570 3570 93218.1
c_3569_3570_i 3569 3569_3570 2.08965e-09
r_210_211_e 210 211 13376.4
r_210_211_i 210_211 211 93218.1
c_210_211_i 210 210_211 2.08965e-09
r_770_771_e 770 771 13376.4
r_770_771_i 770_771 771 93218.1
c_770_771_i 770 770_771 2.08965e-09
r_1330_1331_e 1330 1331 13376.4
r_1330_1331_i 1330_1331 1331 93218.1
c_1330_1331_i 1330 1330_1331 2.08965e-09
r_1890_1891_e 1890 1891 13376.4
r_1890_1891_i 1890_1891 1891 93218.1
c_1890_1891_i 1890 1890_1891 2.08965e-09
r_2450_2451_e 2450 2451 13376.4
r_2450_2451_i 2450_2451 2451 93218.1
c_2450_2451_i 2450 2450_2451 2.08965e-09
r_3010_3011_e 3010 3011 13376.4
r_3010_3011_i 3010_3011 3011 93218.1
c_3010_3011_i 3010 3010_3011 2.08965e-09
r_3570_3571_e 3570 3571 13376.4
r_3570_3571_i 3570_3571 3571 93218.1
c_3570_3571_i 3570 3570_3571 2.08965e-09
r_211_212_e 211 212 13376.4
r_211_212_i 211_212 212 93218.1
c_211_212_i 211 211_212 2.08965e-09
r_771_772_e 771 772 13376.4
r_771_772_i 771_772 772 93218.1
c_771_772_i 771 771_772 2.08965e-09
r_1331_1332_e 1331 1332 836.944
r_1331_1332_i 1331_1332 1332 4256.89
c_1331_1332_i 1331 1331_1332 4.67522e-10
r_1891_1892_e 1891 1892 836.944
r_1891_1892_i 1891_1892 1892 4256.89
c_1891_1892_i 1891 1891_1892 4.67522e-10
r_2451_2452_e 2451 2452 836.944
r_2451_2452_i 2451_2452 2452 4256.89
c_2451_2452_i 2451 2451_2452 4.67522e-10
r_3011_3012_e 3011 3012 836.944
r_3011_3012_i 3011_3012 3012 4256.89
c_3011_3012_i 3011 3011_3012 4.67522e-10
r_3571_3572_e 3571 3572 836.944
r_3571_3572_i 3571_3572 3572 4256.89
c_3571_3572_i 3571 3571_3572 4.67522e-10
r_212_213_e 212 213 13376.4
r_212_213_i 212_213 213 93218.1
c_212_213_i 212 212_213 2.08965e-09
r_772_773_e 772 773 13376.4
r_772_773_i 772_773 773 93218.1
c_772_773_i 772 772_773 2.08965e-09
r_1332_1333_e 1332 1333 836.944
r_1332_1333_i 1332_1333 1333 4256.89
c_1332_1333_i 1332 1332_1333 4.67522e-10
r_1892_1893_e 1892 1893 836.944
r_1892_1893_i 1892_1893 1893 4256.89
c_1892_1893_i 1892 1892_1893 4.67522e-10
r_2452_2453_e 2452 2453 836.944
r_2452_2453_i 2452_2453 2453 4256.89
c_2452_2453_i 2452 2452_2453 4.67522e-10
r_3012_3013_e 3012 3013 13758.3
r_3012_3013_i 3012_3013 3013 95645.6
c_3012_3013_i 3012 3012_3013 9.36084e-12
r_3572_3573_e 3572 3573 13758.3
r_3572_3573_i 3572_3573 3573 95645.6
c_3572_3573_i 3572 3572_3573 9.36084e-12
r_213_214_e 213 214 13376.4
r_213_214_i 213_214 214 93218.1
c_213_214_i 213 213_214 2.08965e-09
r_773_774_e 773 774 13376.4
r_773_774_i 773_774 774 93218.1
c_773_774_i 773 773_774 2.08965e-09
r_1333_1334_e 1333 1334 836.944
r_1333_1334_i 1333_1334 1334 4256.89
c_1333_1334_i 1333 1333_1334 4.67522e-10
r_1893_1894_e 1893 1894 836.944
r_1893_1894_i 1893_1894 1894 4256.89
c_1893_1894_i 1893 1893_1894 4.67522e-10
r_2453_2454_e 2453 2454 836.944
r_2453_2454_i 2453_2454 2454 4256.89
c_2453_2454_i 2453 2453_2454 4.67522e-10
r_3013_3014_e 3013 3014 13758.3
r_3013_3014_i 3013_3014 3014 95645.6
c_3013_3014_i 3013 3013_3014 9.36084e-12
r_3573_3574_e 3573 3574 13758.3
r_3573_3574_i 3573_3574 3574 95645.6
c_3573_3574_i 3573 3573_3574 9.36084e-12
r_214_215_e 214 215 13376.4
r_214_215_i 214_215 215 93218.1
c_214_215_i 214 214_215 2.08965e-09
r_774_775_e 774 775 13376.4
r_774_775_i 774_775 775 93218.1
c_774_775_i 774 774_775 2.08965e-09
r_1334_1335_e 1334 1335 836.944
r_1334_1335_i 1334_1335 1335 4256.89
c_1334_1335_i 1334 1334_1335 4.67522e-10
r_1894_1895_e 1894 1895 836.944
r_1894_1895_i 1894_1895 1895 4256.89
c_1894_1895_i 1894 1894_1895 4.67522e-10
r_2454_2455_e 2454 2455 836.944
r_2454_2455_i 2454_2455 2455 4256.89
c_2454_2455_i 2454 2454_2455 4.67522e-10
r_3014_3015_e 3014 3015 13758.3
r_3014_3015_i 3014_3015 3015 95645.6
c_3014_3015_i 3014 3014_3015 9.36084e-12
r_3574_3575_e 3574 3575 13758.3
r_3574_3575_i 3574_3575 3575 95645.6
c_3574_3575_i 3574 3574_3575 9.36084e-12
r_215_216_e 215 216 13376.4
r_215_216_i 215_216 216 93218.1
c_215_216_i 215 215_216 2.08965e-09
r_775_776_e 775 776 13376.4
r_775_776_i 775_776 776 93218.1
c_775_776_i 775 775_776 2.08965e-09
r_1335_1336_e 1335 1336 836.944
r_1335_1336_i 1335_1336 1336 4256.89
c_1335_1336_i 1335 1335_1336 4.67522e-10
r_1895_1896_e 1895 1896 836.944
r_1895_1896_i 1895_1896 1896 4256.89
c_1895_1896_i 1895 1895_1896 4.67522e-10
r_2455_2456_e 2455 2456 836.944
r_2455_2456_i 2455_2456 2456 4256.89
c_2455_2456_i 2455 2455_2456 4.67522e-10
r_3015_3016_e 3015 3016 13758.3
r_3015_3016_i 3015_3016 3016 95645.6
c_3015_3016_i 3015 3015_3016 9.36084e-12
r_3575_3576_e 3575 3576 13758.3
r_3575_3576_i 3575_3576 3576 95645.6
c_3575_3576_i 3575 3575_3576 9.36084e-12
r_216_217_e 216 217 13376.4
r_216_217_i 216_217 217 93218.1
c_216_217_i 216 216_217 2.08965e-09
r_776_777_e 776 777 13376.4
r_776_777_i 776_777 777 93218.1
c_776_777_i 776 776_777 2.08965e-09
r_1336_1337_e 1336 1337 836.944
r_1336_1337_i 1336_1337 1337 4256.89
c_1336_1337_i 1336 1336_1337 4.67522e-10
r_1896_1897_e 1896 1897 836.944
r_1896_1897_i 1896_1897 1897 4256.89
c_1896_1897_i 1896 1896_1897 4.67522e-10
r_2456_2457_e 2456 2457 836.944
r_2456_2457_i 2456_2457 2457 4256.89
c_2456_2457_i 2456 2456_2457 4.67522e-10
r_3016_3017_e 3016 3017 13758.3
r_3016_3017_i 3016_3017 3017 95645.6
c_3016_3017_i 3016 3016_3017 9.36084e-12
r_3576_3577_e 3576 3577 13758.3
r_3576_3577_i 3576_3577 3577 95645.6
c_3576_3577_i 3576 3576_3577 9.36084e-12
r_217_218_e 217 218 13376.4
r_217_218_i 217_218 218 93218.1
c_217_218_i 217 217_218 2.08965e-09
r_777_778_e 777 778 13376.4
r_777_778_i 777_778 778 93218.1
c_777_778_i 777 777_778 2.08965e-09
r_1337_1338_e 1337 1338 836.944
r_1337_1338_i 1337_1338 1338 4256.89
c_1337_1338_i 1337 1337_1338 4.67522e-10
r_1897_1898_e 1897 1898 836.944
r_1897_1898_i 1897_1898 1898 4256.89
c_1897_1898_i 1897 1897_1898 4.67522e-10
r_2457_2458_e 2457 2458 836.944
r_2457_2458_i 2457_2458 2458 4256.89
c_2457_2458_i 2457 2457_2458 4.67522e-10
r_3017_3018_e 3017 3018 13758.3
r_3017_3018_i 3017_3018 3018 95645.6
c_3017_3018_i 3017 3017_3018 9.36084e-12
r_3577_3578_e 3577 3578 13758.3
r_3577_3578_i 3577_3578 3578 95645.6
c_3577_3578_i 3577 3577_3578 9.36084e-12
r_218_219_e 218 219 13376.4
r_218_219_i 218_219 219 93218.1
c_218_219_i 218 218_219 2.08965e-09
r_778_779_e 778 779 13376.4
r_778_779_i 778_779 779 93218.1
c_778_779_i 778 778_779 2.08965e-09
r_1338_1339_e 1338 1339 836.944
r_1338_1339_i 1338_1339 1339 4256.89
c_1338_1339_i 1338 1338_1339 4.67522e-10
r_1898_1899_e 1898 1899 836.944
r_1898_1899_i 1898_1899 1899 4256.89
c_1898_1899_i 1898 1898_1899 4.67522e-10
r_2458_2459_e 2458 2459 836.944
r_2458_2459_i 2458_2459 2459 4256.89
c_2458_2459_i 2458 2458_2459 4.67522e-10
r_3018_3019_e 3018 3019 13758.3
r_3018_3019_i 3018_3019 3019 95645.6
c_3018_3019_i 3018 3018_3019 9.36084e-12
r_3578_3579_e 3578 3579 13758.3
r_3578_3579_i 3578_3579 3579 95645.6
c_3578_3579_i 3578 3578_3579 9.36084e-12
r_219_220_e 219 220 13376.4
r_219_220_i 219_220 220 93218.1
c_219_220_i 219 219_220 2.08965e-09
r_779_780_e 779 780 13376.4
r_779_780_i 779_780 780 93218.1
c_779_780_i 779 779_780 2.08965e-09
r_1339_1340_e 1339 1340 396.662
r_1339_1340_i 1339_1340 1340 1005.18
c_1339_1340_i 1339 1339_1340 1.6581e-10
r_1899_1900_e 1899 1900 396.662
r_1899_1900_i 1899_1900 1900 1005.18
c_1899_1900_i 1899 1899_1900 1.6581e-10
r_2459_2460_e 2459 2460 836.944
r_2459_2460_i 2459_2460 2460 4256.89
c_2459_2460_i 2459 2459_2460 4.67522e-10
r_3019_3020_e 3019 3020 13758.3
r_3019_3020_i 3019_3020 3020 95645.6
c_3019_3020_i 3019 3019_3020 9.36084e-12
r_3579_3580_e 3579 3580 13758.3
r_3579_3580_i 3579_3580 3580 95645.6
c_3579_3580_i 3579 3579_3580 9.36084e-12
r_220_221_e 220 221 13376.4
r_220_221_i 220_221 221 93218.1
c_220_221_i 220 220_221 2.08965e-09
r_780_781_e 780 781 13376.4
r_780_781_i 780_781 781 93218.1
c_780_781_i 780 780_781 2.08965e-09
r_1340_1341_e 1340 1341 836.944
r_1340_1341_i 1340_1341 1341 4256.89
c_1340_1341_i 1340 1340_1341 4.67522e-10
r_1900_1901_e 1900 1901 836.944
r_1900_1901_i 1900_1901 1901 4256.89
c_1900_1901_i 1900 1900_1901 4.67522e-10
r_2460_2461_e 2460 2461 836.944
r_2460_2461_i 2460_2461 2461 4256.89
c_2460_2461_i 2460 2460_2461 4.67522e-10
r_3020_3021_e 3020 3021 13758.3
r_3020_3021_i 3020_3021 3021 95645.6
c_3020_3021_i 3020 3020_3021 9.36084e-12
r_3580_3581_e 3580 3581 13758.3
r_3580_3581_i 3580_3581 3581 95645.6
c_3580_3581_i 3580 3580_3581 9.36084e-12
r_221_222_e 221 222 13376.4
r_221_222_i 221_222 222 93218.1
c_221_222_i 221 221_222 2.08965e-09
r_781_782_e 781 782 13376.4
r_781_782_i 781_782 782 93218.1
c_781_782_i 781 781_782 2.08965e-09
r_1341_1342_e 1341 1342 836.944
r_1341_1342_i 1341_1342 1342 4256.89
c_1341_1342_i 1341 1341_1342 4.67522e-10
r_1901_1902_e 1901 1902 836.944
r_1901_1902_i 1901_1902 1902 4256.89
c_1901_1902_i 1901 1901_1902 4.67522e-10
r_2461_2462_e 2461 2462 836.944
r_2461_2462_i 2461_2462 2462 4256.89
c_2461_2462_i 2461 2461_2462 4.67522e-10
r_3021_3022_e 3021 3022 13758.3
r_3021_3022_i 3021_3022 3022 95645.6
c_3021_3022_i 3021 3021_3022 9.36084e-12
r_3581_3582_e 3581 3582 13758.3
r_3581_3582_i 3581_3582 3582 95645.6
c_3581_3582_i 3581 3581_3582 9.36084e-12
r_222_223_e 222 223 13376.4
r_222_223_i 222_223 223 93218.1
c_222_223_i 222 222_223 2.08965e-09
r_782_783_e 782 783 13376.4
r_782_783_i 782_783 783 93218.1
c_782_783_i 782 782_783 2.08965e-09
r_1342_1343_e 1342 1343 836.944
r_1342_1343_i 1342_1343 1343 4256.89
c_1342_1343_i 1342 1342_1343 4.67522e-10
r_1902_1903_e 1902 1903 836.944
r_1902_1903_i 1902_1903 1903 4256.89
c_1902_1903_i 1902 1902_1903 4.67522e-10
r_2462_2463_e 2462 2463 836.944
r_2462_2463_i 2462_2463 2463 4256.89
c_2462_2463_i 2462 2462_2463 4.67522e-10
r_3022_3023_e 3022 3023 13758.3
r_3022_3023_i 3022_3023 3023 95645.6
c_3022_3023_i 3022 3022_3023 9.36084e-12
r_3582_3583_e 3582 3583 13758.3
r_3582_3583_i 3582_3583 3583 95645.6
c_3582_3583_i 3582 3582_3583 9.36084e-12
r_223_224_e 223 224 13376.4
r_223_224_i 223_224 224 93218.1
c_223_224_i 223 223_224 2.08965e-09
r_783_784_e 783 784 13376.4
r_783_784_i 783_784 784 93218.1
c_783_784_i 783 783_784 2.08965e-09
r_1343_1344_e 1343 1344 836.944
r_1343_1344_i 1343_1344 1344 4256.89
c_1343_1344_i 1343 1343_1344 4.67522e-10
r_1903_1904_e 1903 1904 836.944
r_1903_1904_i 1903_1904 1904 4256.89
c_1903_1904_i 1903 1903_1904 4.67522e-10
r_2463_2464_e 2463 2464 836.944
r_2463_2464_i 2463_2464 2464 4256.89
c_2463_2464_i 2463 2463_2464 4.67522e-10
r_3023_3024_e 3023 3024 13758.3
r_3023_3024_i 3023_3024 3024 95645.6
c_3023_3024_i 3023 3023_3024 9.36084e-12
r_3583_3584_e 3583 3584 13758.3
r_3583_3584_i 3583_3584 3584 95645.6
c_3583_3584_i 3583 3583_3584 9.36084e-12
r_225_226_e 225 226 13376.4
r_225_226_i 225_226 226 93218.1
c_225_226_i 225 225_226 2.08965e-09
r_785_786_e 785 786 13376.4
r_785_786_i 785_786 786 93218.1
c_785_786_i 785 785_786 2.08965e-09
r_1345_1346_e 1345 1346 13376.4
r_1345_1346_i 1345_1346 1346 93218.1
c_1345_1346_i 1345 1345_1346 2.08965e-09
r_1905_1906_e 1905 1906 13376.4
r_1905_1906_i 1905_1906 1906 93218.1
c_1905_1906_i 1905 1905_1906 2.08965e-09
r_2465_2466_e 2465 2466 13376.4
r_2465_2466_i 2465_2466 2466 93218.1
c_2465_2466_i 2465 2465_2466 2.08965e-09
r_3025_3026_e 3025 3026 13376.4
r_3025_3026_i 3025_3026 3026 93218.1
c_3025_3026_i 3025 3025_3026 2.08965e-09
r_3585_3586_e 3585 3586 13376.4
r_3585_3586_i 3585_3586 3586 93218.1
c_3585_3586_i 3585 3585_3586 2.08965e-09
r_226_227_e 226 227 13376.4
r_226_227_i 226_227 227 93218.1
c_226_227_i 226 226_227 2.08965e-09
r_786_787_e 786 787 13376.4
r_786_787_i 786_787 787 93218.1
c_786_787_i 786 786_787 2.08965e-09
r_1346_1347_e 1346 1347 13376.4
r_1346_1347_i 1346_1347 1347 93218.1
c_1346_1347_i 1346 1346_1347 2.08965e-09
r_1906_1907_e 1906 1907 13376.4
r_1906_1907_i 1906_1907 1907 93218.1
c_1906_1907_i 1906 1906_1907 2.08965e-09
r_2466_2467_e 2466 2467 13376.4
r_2466_2467_i 2466_2467 2467 93218.1
c_2466_2467_i 2466 2466_2467 2.08965e-09
r_3026_3027_e 3026 3027 13376.4
r_3026_3027_i 3026_3027 3027 93218.1
c_3026_3027_i 3026 3026_3027 2.08965e-09
r_3586_3587_e 3586 3587 13376.4
r_3586_3587_i 3586_3587 3587 93218.1
c_3586_3587_i 3586 3586_3587 2.08965e-09
r_227_228_e 227 228 13376.4
r_227_228_i 227_228 228 93218.1
c_227_228_i 227 227_228 2.08965e-09
r_787_788_e 787 788 13376.4
r_787_788_i 787_788 788 93218.1
c_787_788_i 787 787_788 2.08965e-09
r_1347_1348_e 1347 1348 836.944
r_1347_1348_i 1347_1348 1348 4256.89
c_1347_1348_i 1347 1347_1348 4.67522e-10
r_1907_1908_e 1907 1908 836.944
r_1907_1908_i 1907_1908 1908 4256.89
c_1907_1908_i 1907 1907_1908 4.67522e-10
r_2467_2468_e 2467 2468 836.944
r_2467_2468_i 2467_2468 2468 4256.89
c_2467_2468_i 2467 2467_2468 4.67522e-10
r_3027_3028_e 3027 3028 836.944
r_3027_3028_i 3027_3028 3028 4256.89
c_3027_3028_i 3027 3027_3028 4.67522e-10
r_3587_3588_e 3587 3588 836.944
r_3587_3588_i 3587_3588 3588 4256.89
c_3587_3588_i 3587 3587_3588 4.67522e-10
r_228_229_e 228 229 13376.4
r_228_229_i 228_229 229 93218.1
c_228_229_i 228 228_229 2.08965e-09
r_788_789_e 788 789 13376.4
r_788_789_i 788_789 789 93218.1
c_788_789_i 788 788_789 2.08965e-09
r_1348_1349_e 1348 1349 836.944
r_1348_1349_i 1348_1349 1349 4256.89
c_1348_1349_i 1348 1348_1349 4.67522e-10
r_1908_1909_e 1908 1909 836.944
r_1908_1909_i 1908_1909 1909 4256.89
c_1908_1909_i 1908 1908_1909 4.67522e-10
r_2468_2469_e 2468 2469 836.944
r_2468_2469_i 2468_2469 2469 4256.89
c_2468_2469_i 2468 2468_2469 4.67522e-10
r_3028_3029_e 3028 3029 13758.3
r_3028_3029_i 3028_3029 3029 95645.6
c_3028_3029_i 3028 3028_3029 9.36084e-12
r_3588_3589_e 3588 3589 13758.3
r_3588_3589_i 3588_3589 3589 95645.6
c_3588_3589_i 3588 3588_3589 9.36084e-12
r_229_230_e 229 230 13376.4
r_229_230_i 229_230 230 93218.1
c_229_230_i 229 229_230 2.08965e-09
r_789_790_e 789 790 13376.4
r_789_790_i 789_790 790 93218.1
c_789_790_i 789 789_790 2.08965e-09
r_1349_1350_e 1349 1350 836.944
r_1349_1350_i 1349_1350 1350 4256.89
c_1349_1350_i 1349 1349_1350 4.67522e-10
r_1909_1910_e 1909 1910 836.944
r_1909_1910_i 1909_1910 1910 4256.89
c_1909_1910_i 1909 1909_1910 4.67522e-10
r_2469_2470_e 2469 2470 836.944
r_2469_2470_i 2469_2470 2470 4256.89
c_2469_2470_i 2469 2469_2470 4.67522e-10
r_3029_3030_e 3029 3030 13758.3
r_3029_3030_i 3029_3030 3030 95645.6
c_3029_3030_i 3029 3029_3030 9.36084e-12
r_3589_3590_e 3589 3590 13758.3
r_3589_3590_i 3589_3590 3590 95645.6
c_3589_3590_i 3589 3589_3590 9.36084e-12
r_230_231_e 230 231 13376.4
r_230_231_i 230_231 231 93218.1
c_230_231_i 230 230_231 2.08965e-09
r_790_791_e 790 791 13376.4
r_790_791_i 790_791 791 93218.1
c_790_791_i 790 790_791 2.08965e-09
r_1350_1351_e 1350 1351 836.944
r_1350_1351_i 1350_1351 1351 4256.89
c_1350_1351_i 1350 1350_1351 4.67522e-10
r_1910_1911_e 1910 1911 836.944
r_1910_1911_i 1910_1911 1911 4256.89
c_1910_1911_i 1910 1910_1911 4.67522e-10
r_2470_2471_e 2470 2471 836.944
r_2470_2471_i 2470_2471 2471 4256.89
c_2470_2471_i 2470 2470_2471 4.67522e-10
r_3030_3031_e 3030 3031 13758.3
r_3030_3031_i 3030_3031 3031 95645.6
c_3030_3031_i 3030 3030_3031 9.36084e-12
r_3590_3591_e 3590 3591 13758.3
r_3590_3591_i 3590_3591 3591 95645.6
c_3590_3591_i 3590 3590_3591 9.36084e-12
r_231_232_e 231 232 13376.4
r_231_232_i 231_232 232 93218.1
c_231_232_i 231 231_232 2.08965e-09
r_791_792_e 791 792 13376.4
r_791_792_i 791_792 792 93218.1
c_791_792_i 791 791_792 2.08965e-09
r_1351_1352_e 1351 1352 836.944
r_1351_1352_i 1351_1352 1352 4256.89
c_1351_1352_i 1351 1351_1352 4.67522e-10
r_1911_1912_e 1911 1912 836.944
r_1911_1912_i 1911_1912 1912 4256.89
c_1911_1912_i 1911 1911_1912 4.67522e-10
r_2471_2472_e 2471 2472 836.944
r_2471_2472_i 2471_2472 2472 4256.89
c_2471_2472_i 2471 2471_2472 4.67522e-10
r_3031_3032_e 3031 3032 13758.3
r_3031_3032_i 3031_3032 3032 95645.6
c_3031_3032_i 3031 3031_3032 9.36084e-12
r_3591_3592_e 3591 3592 13758.3
r_3591_3592_i 3591_3592 3592 95645.6
c_3591_3592_i 3591 3591_3592 9.36084e-12
r_232_233_e 232 233 13376.4
r_232_233_i 232_233 233 93218.1
c_232_233_i 232 232_233 2.08965e-09
r_792_793_e 792 793 13376.4
r_792_793_i 792_793 793 93218.1
c_792_793_i 792 792_793 2.08965e-09
r_1352_1353_e 1352 1353 836.944
r_1352_1353_i 1352_1353 1353 4256.89
c_1352_1353_i 1352 1352_1353 4.67522e-10
r_1912_1913_e 1912 1913 836.944
r_1912_1913_i 1912_1913 1913 4256.89
c_1912_1913_i 1912 1912_1913 4.67522e-10
r_2472_2473_e 2472 2473 836.944
r_2472_2473_i 2472_2473 2473 4256.89
c_2472_2473_i 2472 2472_2473 4.67522e-10
r_3032_3033_e 3032 3033 13758.3
r_3032_3033_i 3032_3033 3033 95645.6
c_3032_3033_i 3032 3032_3033 9.36084e-12
r_3592_3593_e 3592 3593 13758.3
r_3592_3593_i 3592_3593 3593 95645.6
c_3592_3593_i 3592 3592_3593 9.36084e-12
r_233_234_e 233 234 13376.4
r_233_234_i 233_234 234 93218.1
c_233_234_i 233 233_234 2.08965e-09
r_793_794_e 793 794 13376.4
r_793_794_i 793_794 794 93218.1
c_793_794_i 793 793_794 2.08965e-09
r_1353_1354_e 1353 1354 836.944
r_1353_1354_i 1353_1354 1354 4256.89
c_1353_1354_i 1353 1353_1354 4.67522e-10
r_1913_1914_e 1913 1914 836.944
r_1913_1914_i 1913_1914 1914 4256.89
c_1913_1914_i 1913 1913_1914 4.67522e-10
r_2473_2474_e 2473 2474 836.944
r_2473_2474_i 2473_2474 2474 4256.89
c_2473_2474_i 2473 2473_2474 4.67522e-10
r_3033_3034_e 3033 3034 13758.3
r_3033_3034_i 3033_3034 3034 95645.6
c_3033_3034_i 3033 3033_3034 9.36084e-12
r_3593_3594_e 3593 3594 13758.3
r_3593_3594_i 3593_3594 3594 95645.6
c_3593_3594_i 3593 3593_3594 9.36084e-12
r_234_235_e 234 235 13376.4
r_234_235_i 234_235 235 93218.1
c_234_235_i 234 234_235 2.08965e-09
r_794_795_e 794 795 13376.4
r_794_795_i 794_795 795 93218.1
c_794_795_i 794 794_795 2.08965e-09
r_1354_1355_e 1354 1355 836.944
r_1354_1355_i 1354_1355 1355 4256.89
c_1354_1355_i 1354 1354_1355 4.67522e-10
r_1914_1915_e 1914 1915 836.944
r_1914_1915_i 1914_1915 1915 4256.89
c_1914_1915_i 1914 1914_1915 4.67522e-10
r_2474_2475_e 2474 2475 836.944
r_2474_2475_i 2474_2475 2475 4256.89
c_2474_2475_i 2474 2474_2475 4.67522e-10
r_3034_3035_e 3034 3035 13758.3
r_3034_3035_i 3034_3035 3035 95645.6
c_3034_3035_i 3034 3034_3035 9.36084e-12
r_3594_3595_e 3594 3595 13758.3
r_3594_3595_i 3594_3595 3595 95645.6
c_3594_3595_i 3594 3594_3595 9.36084e-12
r_235_236_e 235 236 13376.4
r_235_236_i 235_236 236 93218.1
c_235_236_i 235 235_236 2.08965e-09
r_795_796_e 795 796 13376.4
r_795_796_i 795_796 796 93218.1
c_795_796_i 795 795_796 2.08965e-09
r_1355_1356_e 1355 1356 396.654
r_1355_1356_i 1355_1356 1356 1005.16
c_1355_1356_i 1355 1355_1356 1.65814e-10
r_1915_1916_e 1915 1916 396.654
r_1915_1916_i 1915_1916 1916 1005.16
c_1915_1916_i 1915 1915_1916 1.65814e-10
r_2475_2476_e 2475 2476 836.944
r_2475_2476_i 2475_2476 2476 4256.89
c_2475_2476_i 2475 2475_2476 4.67522e-10
r_3035_3036_e 3035 3036 13758.3
r_3035_3036_i 3035_3036 3036 95645.6
c_3035_3036_i 3035 3035_3036 9.36084e-12
r_3595_3596_e 3595 3596 13758.3
r_3595_3596_i 3595_3596 3596 95645.6
c_3595_3596_i 3595 3595_3596 9.36084e-12
r_236_237_e 236 237 13376.4
r_236_237_i 236_237 237 93218.1
c_236_237_i 236 236_237 2.08965e-09
r_796_797_e 796 797 13376.4
r_796_797_i 796_797 797 93218.1
c_796_797_i 796 796_797 2.08965e-09
r_1356_1357_e 1356 1357 836.944
r_1356_1357_i 1356_1357 1357 4256.89
c_1356_1357_i 1356 1356_1357 4.67522e-10
r_1916_1917_e 1916 1917 836.944
r_1916_1917_i 1916_1917 1917 4256.89
c_1916_1917_i 1916 1916_1917 4.67522e-10
r_2476_2477_e 2476 2477 836.944
r_2476_2477_i 2476_2477 2477 4256.89
c_2476_2477_i 2476 2476_2477 4.67522e-10
r_3036_3037_e 3036 3037 13758.3
r_3036_3037_i 3036_3037 3037 95645.6
c_3036_3037_i 3036 3036_3037 9.36084e-12
r_3596_3597_e 3596 3597 13758.3
r_3596_3597_i 3596_3597 3597 95645.6
c_3596_3597_i 3596 3596_3597 9.36084e-12
r_237_238_e 237 238 13376.4
r_237_238_i 237_238 238 93218.1
c_237_238_i 237 237_238 2.08965e-09
r_797_798_e 797 798 13376.4
r_797_798_i 797_798 798 93218.1
c_797_798_i 797 797_798 2.08965e-09
r_1357_1358_e 1357 1358 836.944
r_1357_1358_i 1357_1358 1358 4256.89
c_1357_1358_i 1357 1357_1358 4.67522e-10
r_1917_1918_e 1917 1918 836.944
r_1917_1918_i 1917_1918 1918 4256.89
c_1917_1918_i 1917 1917_1918 4.67522e-10
r_2477_2478_e 2477 2478 836.944
r_2477_2478_i 2477_2478 2478 4256.89
c_2477_2478_i 2477 2477_2478 4.67522e-10
r_3037_3038_e 3037 3038 13758.3
r_3037_3038_i 3037_3038 3038 95645.6
c_3037_3038_i 3037 3037_3038 9.36084e-12
r_3597_3598_e 3597 3598 13758.3
r_3597_3598_i 3597_3598 3598 95645.6
c_3597_3598_i 3597 3597_3598 9.36084e-12
r_238_239_e 238 239 13376.4
r_238_239_i 238_239 239 93218.1
c_238_239_i 238 238_239 2.08965e-09
r_798_799_e 798 799 13376.4
r_798_799_i 798_799 799 93218.1
c_798_799_i 798 798_799 2.08965e-09
r_1358_1359_e 1358 1359 836.944
r_1358_1359_i 1358_1359 1359 4256.89
c_1358_1359_i 1358 1358_1359 4.67522e-10
r_1918_1919_e 1918 1919 836.944
r_1918_1919_i 1918_1919 1919 4256.89
c_1918_1919_i 1918 1918_1919 4.67522e-10
r_2478_2479_e 2478 2479 836.944
r_2478_2479_i 2478_2479 2479 4256.89
c_2478_2479_i 2478 2478_2479 4.67522e-10
r_3038_3039_e 3038 3039 13758.3
r_3038_3039_i 3038_3039 3039 95645.6
c_3038_3039_i 3038 3038_3039 9.36084e-12
r_3598_3599_e 3598 3599 13758.3
r_3598_3599_i 3598_3599 3599 95645.6
c_3598_3599_i 3598 3598_3599 9.36084e-12
r_239_240_e 239 240 13376.4
r_239_240_i 239_240 240 93218.1
c_239_240_i 239 239_240 2.08965e-09
r_799_800_e 799 800 13376.4
r_799_800_i 799_800 800 93218.1
c_799_800_i 799 799_800 2.08965e-09
r_1359_1360_e 1359 1360 836.944
r_1359_1360_i 1359_1360 1360 4256.89
c_1359_1360_i 1359 1359_1360 4.67522e-10
r_1919_1920_e 1919 1920 836.944
r_1919_1920_i 1919_1920 1920 4256.89
c_1919_1920_i 1919 1919_1920 4.67522e-10
r_2479_2480_e 2479 2480 836.944
r_2479_2480_i 2479_2480 2480 4256.89
c_2479_2480_i 2479 2479_2480 4.67522e-10
r_3039_3040_e 3039 3040 13758.3
r_3039_3040_i 3039_3040 3040 95645.6
c_3039_3040_i 3039 3039_3040 9.36084e-12
r_3599_3600_e 3599 3600 13758.3
r_3599_3600_i 3599_3600 3600 95645.6
c_3599_3600_i 3599 3599_3600 9.36084e-12
r_241_242_e 241 242 13376.4
r_241_242_i 241_242 242 93218.1
c_241_242_i 241 241_242 2.08965e-09
r_801_802_e 801 802 13376.4
r_801_802_i 801_802 802 93218.1
c_801_802_i 801 801_802 2.08965e-09
r_1361_1362_e 1361 1362 13376.4
r_1361_1362_i 1361_1362 1362 93218.1
c_1361_1362_i 1361 1361_1362 2.08965e-09
r_1921_1922_e 1921 1922 13376.4
r_1921_1922_i 1921_1922 1922 93218.1
c_1921_1922_i 1921 1921_1922 2.08965e-09
r_2481_2482_e 2481 2482 13376.4
r_2481_2482_i 2481_2482 2482 93218.1
c_2481_2482_i 2481 2481_2482 2.08965e-09
r_3041_3042_e 3041 3042 13376.4
r_3041_3042_i 3041_3042 3042 93218.1
c_3041_3042_i 3041 3041_3042 2.08965e-09
r_3601_3602_e 3601 3602 13376.4
r_3601_3602_i 3601_3602 3602 93218.1
c_3601_3602_i 3601 3601_3602 2.08965e-09
r_242_243_e 242 243 13376.4
r_242_243_i 242_243 243 93218.1
c_242_243_i 242 242_243 2.08965e-09
r_802_803_e 802 803 13376.4
r_802_803_i 802_803 803 93218.1
c_802_803_i 802 802_803 2.08965e-09
r_1362_1363_e 1362 1363 13376.4
r_1362_1363_i 1362_1363 1363 93218.1
c_1362_1363_i 1362 1362_1363 2.08965e-09
r_1922_1923_e 1922 1923 13376.4
r_1922_1923_i 1922_1923 1923 93218.1
c_1922_1923_i 1922 1922_1923 2.08965e-09
r_2482_2483_e 2482 2483 13376.4
r_2482_2483_i 2482_2483 2483 93218.1
c_2482_2483_i 2482 2482_2483 2.08965e-09
r_3042_3043_e 3042 3043 13376.4
r_3042_3043_i 3042_3043 3043 93218.1
c_3042_3043_i 3042 3042_3043 2.08965e-09
r_3602_3603_e 3602 3603 13376.4
r_3602_3603_i 3602_3603 3603 93218.1
c_3602_3603_i 3602 3602_3603 2.08965e-09
r_243_244_e 243 244 13376.4
r_243_244_i 243_244 244 93218.1
c_243_244_i 243 243_244 2.08965e-09
r_803_804_e 803 804 13376.4
r_803_804_i 803_804 804 93218.1
c_803_804_i 803 803_804 2.08965e-09
r_1363_1364_e 1363 1364 836.944
r_1363_1364_i 1363_1364 1364 4256.89
c_1363_1364_i 1363 1363_1364 4.67522e-10
r_1923_1924_e 1923 1924 836.944
r_1923_1924_i 1923_1924 1924 4256.89
c_1923_1924_i 1923 1923_1924 4.67522e-10
r_2483_2484_e 2483 2484 836.944
r_2483_2484_i 2483_2484 2484 4256.89
c_2483_2484_i 2483 2483_2484 4.67522e-10
r_3043_3044_e 3043 3044 836.944
r_3043_3044_i 3043_3044 3044 4256.89
c_3043_3044_i 3043 3043_3044 4.67522e-10
r_3603_3604_e 3603 3604 836.944
r_3603_3604_i 3603_3604 3604 4256.89
c_3603_3604_i 3603 3603_3604 4.67522e-10
r_244_245_e 244 245 13376.4
r_244_245_i 244_245 245 93218.1
c_244_245_i 244 244_245 2.08965e-09
r_804_805_e 804 805 13376.4
r_804_805_i 804_805 805 93218.1
c_804_805_i 804 804_805 2.08965e-09
r_1364_1365_e 1364 1365 836.944
r_1364_1365_i 1364_1365 1365 4256.89
c_1364_1365_i 1364 1364_1365 4.67522e-10
r_1924_1925_e 1924 1925 836.944
r_1924_1925_i 1924_1925 1925 4256.89
c_1924_1925_i 1924 1924_1925 4.67522e-10
r_2484_2485_e 2484 2485 836.944
r_2484_2485_i 2484_2485 2485 4256.89
c_2484_2485_i 2484 2484_2485 4.67522e-10
r_3044_3045_e 3044 3045 13758.3
r_3044_3045_i 3044_3045 3045 95645.6
c_3044_3045_i 3044 3044_3045 9.36084e-12
r_3604_3605_e 3604 3605 13758.3
r_3604_3605_i 3604_3605 3605 95645.6
c_3604_3605_i 3604 3604_3605 9.36084e-12
r_245_246_e 245 246 13376.4
r_245_246_i 245_246 246 93218.1
c_245_246_i 245 245_246 2.08965e-09
r_805_806_e 805 806 13376.4
r_805_806_i 805_806 806 93218.1
c_805_806_i 805 805_806 2.08965e-09
r_1365_1366_e 1365 1366 836.944
r_1365_1366_i 1365_1366 1366 4256.89
c_1365_1366_i 1365 1365_1366 4.67522e-10
r_1925_1926_e 1925 1926 836.944
r_1925_1926_i 1925_1926 1926 4256.89
c_1925_1926_i 1925 1925_1926 4.67522e-10
r_2485_2486_e 2485 2486 836.944
r_2485_2486_i 2485_2486 2486 4256.89
c_2485_2486_i 2485 2485_2486 4.67522e-10
r_3045_3046_e 3045 3046 13758.3
r_3045_3046_i 3045_3046 3046 95645.6
c_3045_3046_i 3045 3045_3046 9.36084e-12
r_3605_3606_e 3605 3606 13758.3
r_3605_3606_i 3605_3606 3606 95645.6
c_3605_3606_i 3605 3605_3606 9.36084e-12
r_246_247_e 246 247 13376.4
r_246_247_i 246_247 247 93218.1
c_246_247_i 246 246_247 2.08965e-09
r_806_807_e 806 807 13376.4
r_806_807_i 806_807 807 93218.1
c_806_807_i 806 806_807 2.08965e-09
r_1366_1367_e 1366 1367 836.944
r_1366_1367_i 1366_1367 1367 4256.89
c_1366_1367_i 1366 1366_1367 4.67522e-10
r_1926_1927_e 1926 1927 836.944
r_1926_1927_i 1926_1927 1927 4256.89
c_1926_1927_i 1926 1926_1927 4.67522e-10
r_2486_2487_e 2486 2487 836.944
r_2486_2487_i 2486_2487 2487 4256.89
c_2486_2487_i 2486 2486_2487 4.67522e-10
r_3046_3047_e 3046 3047 13758.3
r_3046_3047_i 3046_3047 3047 95645.6
c_3046_3047_i 3046 3046_3047 9.36084e-12
r_3606_3607_e 3606 3607 13758.3
r_3606_3607_i 3606_3607 3607 95645.6
c_3606_3607_i 3606 3606_3607 9.36084e-12
r_247_248_e 247 248 13376.4
r_247_248_i 247_248 248 93218.1
c_247_248_i 247 247_248 2.08965e-09
r_807_808_e 807 808 13376.4
r_807_808_i 807_808 808 93218.1
c_807_808_i 807 807_808 2.08965e-09
r_1367_1368_e 1367 1368 836.944
r_1367_1368_i 1367_1368 1368 4256.89
c_1367_1368_i 1367 1367_1368 4.67522e-10
r_1927_1928_e 1927 1928 836.944
r_1927_1928_i 1927_1928 1928 4256.89
c_1927_1928_i 1927 1927_1928 4.67522e-10
r_2487_2488_e 2487 2488 836.944
r_2487_2488_i 2487_2488 2488 4256.89
c_2487_2488_i 2487 2487_2488 4.67522e-10
r_3047_3048_e 3047 3048 13758.3
r_3047_3048_i 3047_3048 3048 95645.6
c_3047_3048_i 3047 3047_3048 9.36084e-12
r_3607_3608_e 3607 3608 13758.3
r_3607_3608_i 3607_3608 3608 95645.6
c_3607_3608_i 3607 3607_3608 9.36084e-12
r_248_249_e 248 249 13376.4
r_248_249_i 248_249 249 93218.1
c_248_249_i 248 248_249 2.08965e-09
r_808_809_e 808 809 13376.4
r_808_809_i 808_809 809 93218.1
c_808_809_i 808 808_809 2.08965e-09
r_1368_1369_e 1368 1369 836.944
r_1368_1369_i 1368_1369 1369 4256.89
c_1368_1369_i 1368 1368_1369 4.67522e-10
r_1928_1929_e 1928 1929 836.944
r_1928_1929_i 1928_1929 1929 4256.89
c_1928_1929_i 1928 1928_1929 4.67522e-10
r_2488_2489_e 2488 2489 836.944
r_2488_2489_i 2488_2489 2489 4256.89
c_2488_2489_i 2488 2488_2489 4.67522e-10
r_3048_3049_e 3048 3049 13758.3
r_3048_3049_i 3048_3049 3049 95645.6
c_3048_3049_i 3048 3048_3049 9.36084e-12
r_3608_3609_e 3608 3609 13758.3
r_3608_3609_i 3608_3609 3609 95645.6
c_3608_3609_i 3608 3608_3609 9.36084e-12
r_249_250_e 249 250 13376.4
r_249_250_i 249_250 250 93218.1
c_249_250_i 249 249_250 2.08965e-09
r_809_810_e 809 810 13376.4
r_809_810_i 809_810 810 93218.1
c_809_810_i 809 809_810 2.08965e-09
r_1369_1370_e 1369 1370 836.944
r_1369_1370_i 1369_1370 1370 4256.89
c_1369_1370_i 1369 1369_1370 4.67522e-10
r_1929_1930_e 1929 1930 836.944
r_1929_1930_i 1929_1930 1930 4256.89
c_1929_1930_i 1929 1929_1930 4.67522e-10
r_2489_2490_e 2489 2490 836.944
r_2489_2490_i 2489_2490 2490 4256.89
c_2489_2490_i 2489 2489_2490 4.67522e-10
r_3049_3050_e 3049 3050 13758.3
r_3049_3050_i 3049_3050 3050 95645.6
c_3049_3050_i 3049 3049_3050 9.36084e-12
r_3609_3610_e 3609 3610 13758.3
r_3609_3610_i 3609_3610 3610 95645.6
c_3609_3610_i 3609 3609_3610 9.36084e-12
r_250_251_e 250 251 13376.4
r_250_251_i 250_251 251 93218.1
c_250_251_i 250 250_251 2.08965e-09
r_810_811_e 810 811 13376.4
r_810_811_i 810_811 811 93218.1
c_810_811_i 810 810_811 2.08965e-09
r_1370_1371_e 1370 1371 836.944
r_1370_1371_i 1370_1371 1371 4256.89
c_1370_1371_i 1370 1370_1371 4.67522e-10
r_1930_1931_e 1930 1931 836.944
r_1930_1931_i 1930_1931 1931 4256.89
c_1930_1931_i 1930 1930_1931 4.67522e-10
r_2490_2491_e 2490 2491 836.944
r_2490_2491_i 2490_2491 2491 4256.89
c_2490_2491_i 2490 2490_2491 4.67522e-10
r_3050_3051_e 3050 3051 13758.3
r_3050_3051_i 3050_3051 3051 95645.6
c_3050_3051_i 3050 3050_3051 9.36084e-12
r_3610_3611_e 3610 3611 13758.3
r_3610_3611_i 3610_3611 3611 95645.6
c_3610_3611_i 3610 3610_3611 9.36084e-12
r_251_252_e 251 252 13376.4
r_251_252_i 251_252 252 93218.1
c_251_252_i 251 251_252 2.08965e-09
r_811_812_e 811 812 13376.4
r_811_812_i 811_812 812 93218.1
c_811_812_i 811 811_812 2.08965e-09
r_1371_1372_e 1371 1372 396.645
r_1371_1372_i 1371_1372 1372 1005.14
c_1371_1372_i 1371 1371_1372 1.65817e-10
r_1931_1932_e 1931 1932 396.645
r_1931_1932_i 1931_1932 1932 1005.14
c_1931_1932_i 1931 1931_1932 1.65817e-10
r_2491_2492_e 2491 2492 836.944
r_2491_2492_i 2491_2492 2492 4256.89
c_2491_2492_i 2491 2491_2492 4.67522e-10
r_3051_3052_e 3051 3052 13758.3
r_3051_3052_i 3051_3052 3052 95645.6
c_3051_3052_i 3051 3051_3052 9.36084e-12
r_3611_3612_e 3611 3612 13758.3
r_3611_3612_i 3611_3612 3612 95645.6
c_3611_3612_i 3611 3611_3612 9.36084e-12
r_252_253_e 252 253 13376.4
r_252_253_i 252_253 253 93218.1
c_252_253_i 252 252_253 2.08965e-09
r_812_813_e 812 813 13376.4
r_812_813_i 812_813 813 93218.1
c_812_813_i 812 812_813 2.08965e-09
r_1372_1373_e 1372 1373 836.944
r_1372_1373_i 1372_1373 1373 4256.89
c_1372_1373_i 1372 1372_1373 4.67522e-10
r_1932_1933_e 1932 1933 836.944
r_1932_1933_i 1932_1933 1933 4256.89
c_1932_1933_i 1932 1932_1933 4.67522e-10
r_2492_2493_e 2492 2493 836.944
r_2492_2493_i 2492_2493 2493 4256.89
c_2492_2493_i 2492 2492_2493 4.67522e-10
r_3052_3053_e 3052 3053 13758.3
r_3052_3053_i 3052_3053 3053 95645.6
c_3052_3053_i 3052 3052_3053 9.36084e-12
r_3612_3613_e 3612 3613 13758.3
r_3612_3613_i 3612_3613 3613 95645.6
c_3612_3613_i 3612 3612_3613 9.36084e-12
r_253_254_e 253 254 13376.4
r_253_254_i 253_254 254 93218.1
c_253_254_i 253 253_254 2.08965e-09
r_813_814_e 813 814 13376.4
r_813_814_i 813_814 814 93218.1
c_813_814_i 813 813_814 2.08965e-09
r_1373_1374_e 1373 1374 836.944
r_1373_1374_i 1373_1374 1374 4256.89
c_1373_1374_i 1373 1373_1374 4.67522e-10
r_1933_1934_e 1933 1934 836.944
r_1933_1934_i 1933_1934 1934 4256.89
c_1933_1934_i 1933 1933_1934 4.67522e-10
r_2493_2494_e 2493 2494 836.944
r_2493_2494_i 2493_2494 2494 4256.89
c_2493_2494_i 2493 2493_2494 4.67522e-10
r_3053_3054_e 3053 3054 13758.3
r_3053_3054_i 3053_3054 3054 95645.6
c_3053_3054_i 3053 3053_3054 9.36084e-12
r_3613_3614_e 3613 3614 13758.3
r_3613_3614_i 3613_3614 3614 95645.6
c_3613_3614_i 3613 3613_3614 9.36084e-12
r_254_255_e 254 255 13376.4
r_254_255_i 254_255 255 93218.1
c_254_255_i 254 254_255 2.08965e-09
r_814_815_e 814 815 13376.4
r_814_815_i 814_815 815 93218.1
c_814_815_i 814 814_815 2.08965e-09
r_1374_1375_e 1374 1375 836.944
r_1374_1375_i 1374_1375 1375 4256.89
c_1374_1375_i 1374 1374_1375 4.67522e-10
r_1934_1935_e 1934 1935 836.944
r_1934_1935_i 1934_1935 1935 4256.89
c_1934_1935_i 1934 1934_1935 4.67522e-10
r_2494_2495_e 2494 2495 836.944
r_2494_2495_i 2494_2495 2495 4256.89
c_2494_2495_i 2494 2494_2495 4.67522e-10
r_3054_3055_e 3054 3055 13758.3
r_3054_3055_i 3054_3055 3055 95645.6
c_3054_3055_i 3054 3054_3055 9.36084e-12
r_3614_3615_e 3614 3615 13758.3
r_3614_3615_i 3614_3615 3615 95645.6
c_3614_3615_i 3614 3614_3615 9.36084e-12
r_255_256_e 255 256 13376.4
r_255_256_i 255_256 256 93218.1
c_255_256_i 255 255_256 2.08965e-09
r_815_816_e 815 816 13376.4
r_815_816_i 815_816 816 93218.1
c_815_816_i 815 815_816 2.08965e-09
r_1375_1376_e 1375 1376 836.944
r_1375_1376_i 1375_1376 1376 4256.89
c_1375_1376_i 1375 1375_1376 4.67522e-10
r_1935_1936_e 1935 1936 836.944
r_1935_1936_i 1935_1936 1936 4256.89
c_1935_1936_i 1935 1935_1936 4.67522e-10
r_2495_2496_e 2495 2496 836.944
r_2495_2496_i 2495_2496 2496 4256.89
c_2495_2496_i 2495 2495_2496 4.67522e-10
r_3055_3056_e 3055 3056 13758.3
r_3055_3056_i 3055_3056 3056 95645.6
c_3055_3056_i 3055 3055_3056 9.36084e-12
r_3615_3616_e 3615 3616 13758.3
r_3615_3616_i 3615_3616 3616 95645.6
c_3615_3616_i 3615 3615_3616 9.36084e-12
r_257_258_e 257 258 13376.4
r_257_258_i 257_258 258 93218.1
c_257_258_i 257 257_258 2.08965e-09
r_817_818_e 817 818 13376.4
r_817_818_i 817_818 818 93218.1
c_817_818_i 817 817_818 2.08965e-09
r_1377_1378_e 1377 1378 13376.4
r_1377_1378_i 1377_1378 1378 93218.1
c_1377_1378_i 1377 1377_1378 2.08965e-09
r_1937_1938_e 1937 1938 13376.4
r_1937_1938_i 1937_1938 1938 93218.1
c_1937_1938_i 1937 1937_1938 2.08965e-09
r_2497_2498_e 2497 2498 13376.4
r_2497_2498_i 2497_2498 2498 93218.1
c_2497_2498_i 2497 2497_2498 2.08965e-09
r_3057_3058_e 3057 3058 13376.4
r_3057_3058_i 3057_3058 3058 93218.1
c_3057_3058_i 3057 3057_3058 2.08965e-09
r_3617_3618_e 3617 3618 13376.4
r_3617_3618_i 3617_3618 3618 93218.1
c_3617_3618_i 3617 3617_3618 2.08965e-09
r_258_259_e 258 259 13376.4
r_258_259_i 258_259 259 93218.1
c_258_259_i 258 258_259 2.08965e-09
r_818_819_e 818 819 13376.4
r_818_819_i 818_819 819 93218.1
c_818_819_i 818 818_819 2.08965e-09
r_1378_1379_e 1378 1379 13376.4
r_1378_1379_i 1378_1379 1379 93218.1
c_1378_1379_i 1378 1378_1379 2.08965e-09
r_1938_1939_e 1938 1939 13376.4
r_1938_1939_i 1938_1939 1939 93218.1
c_1938_1939_i 1938 1938_1939 2.08965e-09
r_2498_2499_e 2498 2499 13376.4
r_2498_2499_i 2498_2499 2499 93218.1
c_2498_2499_i 2498 2498_2499 2.08965e-09
r_3058_3059_e 3058 3059 13376.4
r_3058_3059_i 3058_3059 3059 93218.1
c_3058_3059_i 3058 3058_3059 2.08965e-09
r_3618_3619_e 3618 3619 13376.4
r_3618_3619_i 3618_3619 3619 93218.1
c_3618_3619_i 3618 3618_3619 2.08965e-09
r_259_260_e 259 260 13376.4
r_259_260_i 259_260 260 93218.1
c_259_260_i 259 259_260 2.08965e-09
r_819_820_e 819 820 13376.4
r_819_820_i 819_820 820 93218.1
c_819_820_i 819 819_820 2.08965e-09
r_1379_1380_e 1379 1380 836.944
r_1379_1380_i 1379_1380 1380 4256.89
c_1379_1380_i 1379 1379_1380 4.67522e-10
r_1939_1940_e 1939 1940 836.944
r_1939_1940_i 1939_1940 1940 4256.89
c_1939_1940_i 1939 1939_1940 4.67522e-10
r_2499_2500_e 2499 2500 836.944
r_2499_2500_i 2499_2500 2500 4256.89
c_2499_2500_i 2499 2499_2500 4.67522e-10
r_3059_3060_e 3059 3060 836.944
r_3059_3060_i 3059_3060 3060 4256.89
c_3059_3060_i 3059 3059_3060 4.67522e-10
r_3619_3620_e 3619 3620 836.944
r_3619_3620_i 3619_3620 3620 4256.89
c_3619_3620_i 3619 3619_3620 4.67522e-10
r_260_261_e 260 261 13376.4
r_260_261_i 260_261 261 93218.1
c_260_261_i 260 260_261 2.08965e-09
r_820_821_e 820 821 13376.4
r_820_821_i 820_821 821 93218.1
c_820_821_i 820 820_821 2.08965e-09
r_1380_1381_e 1380 1381 836.944
r_1380_1381_i 1380_1381 1381 4256.89
c_1380_1381_i 1380 1380_1381 4.67522e-10
r_1940_1941_e 1940 1941 836.944
r_1940_1941_i 1940_1941 1941 4256.89
c_1940_1941_i 1940 1940_1941 4.67522e-10
r_2500_2501_e 2500 2501 836.944
r_2500_2501_i 2500_2501 2501 4256.89
c_2500_2501_i 2500 2500_2501 4.67522e-10
r_3060_3061_e 3060 3061 13758.3
r_3060_3061_i 3060_3061 3061 95645.6
c_3060_3061_i 3060 3060_3061 9.36084e-12
r_3620_3621_e 3620 3621 13758.3
r_3620_3621_i 3620_3621 3621 95645.6
c_3620_3621_i 3620 3620_3621 9.36084e-12
r_261_262_e 261 262 13376.4
r_261_262_i 261_262 262 93218.1
c_261_262_i 261 261_262 2.08965e-09
r_821_822_e 821 822 13376.4
r_821_822_i 821_822 822 93218.1
c_821_822_i 821 821_822 2.08965e-09
r_1381_1382_e 1381 1382 836.944
r_1381_1382_i 1381_1382 1382 4256.89
c_1381_1382_i 1381 1381_1382 4.67522e-10
r_1941_1942_e 1941 1942 836.944
r_1941_1942_i 1941_1942 1942 4256.89
c_1941_1942_i 1941 1941_1942 4.67522e-10
r_2501_2502_e 2501 2502 836.944
r_2501_2502_i 2501_2502 2502 4256.89
c_2501_2502_i 2501 2501_2502 4.67522e-10
r_3061_3062_e 3061 3062 13758.3
r_3061_3062_i 3061_3062 3062 95645.6
c_3061_3062_i 3061 3061_3062 9.36084e-12
r_3621_3622_e 3621 3622 13758.3
r_3621_3622_i 3621_3622 3622 95645.6
c_3621_3622_i 3621 3621_3622 9.36084e-12
r_262_263_e 262 263 13376.4
r_262_263_i 262_263 263 93218.1
c_262_263_i 262 262_263 2.08965e-09
r_822_823_e 822 823 13376.4
r_822_823_i 822_823 823 93218.1
c_822_823_i 822 822_823 2.08965e-09
r_1382_1383_e 1382 1383 836.944
r_1382_1383_i 1382_1383 1383 4256.89
c_1382_1383_i 1382 1382_1383 4.67522e-10
r_1942_1943_e 1942 1943 836.944
r_1942_1943_i 1942_1943 1943 4256.89
c_1942_1943_i 1942 1942_1943 4.67522e-10
r_2502_2503_e 2502 2503 836.944
r_2502_2503_i 2502_2503 2503 4256.89
c_2502_2503_i 2502 2502_2503 4.67522e-10
r_3062_3063_e 3062 3063 13758.3
r_3062_3063_i 3062_3063 3063 95645.6
c_3062_3063_i 3062 3062_3063 9.36084e-12
r_3622_3623_e 3622 3623 13758.3
r_3622_3623_i 3622_3623 3623 95645.6
c_3622_3623_i 3622 3622_3623 9.36084e-12
r_263_264_e 263 264 13376.4
r_263_264_i 263_264 264 93218.1
c_263_264_i 263 263_264 2.08965e-09
r_823_824_e 823 824 13376.4
r_823_824_i 823_824 824 93218.1
c_823_824_i 823 823_824 2.08965e-09
r_1383_1384_e 1383 1384 836.944
r_1383_1384_i 1383_1384 1384 4256.89
c_1383_1384_i 1383 1383_1384 4.67522e-10
r_1943_1944_e 1943 1944 836.944
r_1943_1944_i 1943_1944 1944 4256.89
c_1943_1944_i 1943 1943_1944 4.67522e-10
r_2503_2504_e 2503 2504 836.944
r_2503_2504_i 2503_2504 2504 4256.89
c_2503_2504_i 2503 2503_2504 4.67522e-10
r_3063_3064_e 3063 3064 13758.3
r_3063_3064_i 3063_3064 3064 95645.6
c_3063_3064_i 3063 3063_3064 9.36084e-12
r_3623_3624_e 3623 3624 13758.3
r_3623_3624_i 3623_3624 3624 95645.6
c_3623_3624_i 3623 3623_3624 9.36084e-12
r_264_265_e 264 265 13376.4
r_264_265_i 264_265 265 93218.1
c_264_265_i 264 264_265 2.08965e-09
r_824_825_e 824 825 13376.4
r_824_825_i 824_825 825 93218.1
c_824_825_i 824 824_825 2.08965e-09
r_1384_1385_e 1384 1385 836.944
r_1384_1385_i 1384_1385 1385 4256.89
c_1384_1385_i 1384 1384_1385 4.67522e-10
r_1944_1945_e 1944 1945 836.944
r_1944_1945_i 1944_1945 1945 4256.89
c_1944_1945_i 1944 1944_1945 4.67522e-10
r_2504_2505_e 2504 2505 836.944
r_2504_2505_i 2504_2505 2505 4256.89
c_2504_2505_i 2504 2504_2505 4.67522e-10
r_3064_3065_e 3064 3065 13758.3
r_3064_3065_i 3064_3065 3065 95645.6
c_3064_3065_i 3064 3064_3065 9.36084e-12
r_3624_3625_e 3624 3625 13758.3
r_3624_3625_i 3624_3625 3625 95645.6
c_3624_3625_i 3624 3624_3625 9.36084e-12
r_265_266_e 265 266 13376.4
r_265_266_i 265_266 266 93218.1
c_265_266_i 265 265_266 2.08965e-09
r_825_826_e 825 826 13376.4
r_825_826_i 825_826 826 93218.1
c_825_826_i 825 825_826 2.08965e-09
r_1385_1386_e 1385 1386 836.944
r_1385_1386_i 1385_1386 1386 4256.89
c_1385_1386_i 1385 1385_1386 4.67522e-10
r_1945_1946_e 1945 1946 836.944
r_1945_1946_i 1945_1946 1946 4256.89
c_1945_1946_i 1945 1945_1946 4.67522e-10
r_2505_2506_e 2505 2506 836.944
r_2505_2506_i 2505_2506 2506 4256.89
c_2505_2506_i 2505 2505_2506 4.67522e-10
r_3065_3066_e 3065 3066 13758.3
r_3065_3066_i 3065_3066 3066 95645.6
c_3065_3066_i 3065 3065_3066 9.36084e-12
r_3625_3626_e 3625 3626 13758.3
r_3625_3626_i 3625_3626 3626 95645.6
c_3625_3626_i 3625 3625_3626 9.36084e-12
r_266_267_e 266 267 13376.4
r_266_267_i 266_267 267 93218.1
c_266_267_i 266 266_267 2.08965e-09
r_826_827_e 826 827 13376.4
r_826_827_i 826_827 827 93218.1
c_826_827_i 826 826_827 2.08965e-09
r_1386_1387_e 1386 1387 836.944
r_1386_1387_i 1386_1387 1387 4256.89
c_1386_1387_i 1386 1386_1387 4.67522e-10
r_1946_1947_e 1946 1947 836.944
r_1946_1947_i 1946_1947 1947 4256.89
c_1946_1947_i 1946 1946_1947 4.67522e-10
r_2506_2507_e 2506 2507 836.944
r_2506_2507_i 2506_2507 2507 4256.89
c_2506_2507_i 2506 2506_2507 4.67522e-10
r_3066_3067_e 3066 3067 13758.3
r_3066_3067_i 3066_3067 3067 95645.6
c_3066_3067_i 3066 3066_3067 9.36084e-12
r_3626_3627_e 3626 3627 13758.3
r_3626_3627_i 3626_3627 3627 95645.6
c_3626_3627_i 3626 3626_3627 9.36084e-12
r_267_268_e 267 268 13376.4
r_267_268_i 267_268 268 93218.1
c_267_268_i 267 267_268 2.08965e-09
r_827_828_e 827 828 13376.4
r_827_828_i 827_828 828 93218.1
c_827_828_i 827 827_828 2.08965e-09
r_1387_1388_e 1387 1388 396.636
r_1387_1388_i 1387_1388 1388 1005.11
c_1387_1388_i 1387 1387_1388 1.65821e-10
r_1947_1948_e 1947 1948 396.636
r_1947_1948_i 1947_1948 1948 1005.11
c_1947_1948_i 1947 1947_1948 1.65821e-10
r_2507_2508_e 2507 2508 836.944
r_2507_2508_i 2507_2508 2508 4256.89
c_2507_2508_i 2507 2507_2508 4.67522e-10
r_3067_3068_e 3067 3068 13758.3
r_3067_3068_i 3067_3068 3068 95645.6
c_3067_3068_i 3067 3067_3068 9.36084e-12
r_3627_3628_e 3627 3628 13758.3
r_3627_3628_i 3627_3628 3628 95645.6
c_3627_3628_i 3627 3627_3628 9.36084e-12
r_268_269_e 268 269 13376.4
r_268_269_i 268_269 269 93218.1
c_268_269_i 268 268_269 2.08965e-09
r_828_829_e 828 829 13376.4
r_828_829_i 828_829 829 93218.1
c_828_829_i 828 828_829 2.08965e-09
r_1388_1389_e 1388 1389 836.944
r_1388_1389_i 1388_1389 1389 4256.89
c_1388_1389_i 1388 1388_1389 4.67522e-10
r_1948_1949_e 1948 1949 836.944
r_1948_1949_i 1948_1949 1949 4256.89
c_1948_1949_i 1948 1948_1949 4.67522e-10
r_2508_2509_e 2508 2509 836.944
r_2508_2509_i 2508_2509 2509 4256.89
c_2508_2509_i 2508 2508_2509 4.67522e-10
r_3068_3069_e 3068 3069 13758.3
r_3068_3069_i 3068_3069 3069 95645.6
c_3068_3069_i 3068 3068_3069 9.36084e-12
r_3628_3629_e 3628 3629 13758.3
r_3628_3629_i 3628_3629 3629 95645.6
c_3628_3629_i 3628 3628_3629 9.36084e-12
r_269_270_e 269 270 13376.4
r_269_270_i 269_270 270 93218.1
c_269_270_i 269 269_270 2.08965e-09
r_829_830_e 829 830 13376.4
r_829_830_i 829_830 830 93218.1
c_829_830_i 829 829_830 2.08965e-09
r_1389_1390_e 1389 1390 836.944
r_1389_1390_i 1389_1390 1390 4256.89
c_1389_1390_i 1389 1389_1390 4.67522e-10
r_1949_1950_e 1949 1950 836.944
r_1949_1950_i 1949_1950 1950 4256.89
c_1949_1950_i 1949 1949_1950 4.67522e-10
r_2509_2510_e 2509 2510 836.944
r_2509_2510_i 2509_2510 2510 4256.89
c_2509_2510_i 2509 2509_2510 4.67522e-10
r_3069_3070_e 3069 3070 13758.3
r_3069_3070_i 3069_3070 3070 95645.6
c_3069_3070_i 3069 3069_3070 9.36084e-12
r_3629_3630_e 3629 3630 13758.3
r_3629_3630_i 3629_3630 3630 95645.6
c_3629_3630_i 3629 3629_3630 9.36084e-12
r_270_271_e 270 271 13376.4
r_270_271_i 270_271 271 93218.1
c_270_271_i 270 270_271 2.08965e-09
r_830_831_e 830 831 13376.4
r_830_831_i 830_831 831 93218.1
c_830_831_i 830 830_831 2.08965e-09
r_1390_1391_e 1390 1391 836.944
r_1390_1391_i 1390_1391 1391 4256.89
c_1390_1391_i 1390 1390_1391 4.67522e-10
r_1950_1951_e 1950 1951 836.944
r_1950_1951_i 1950_1951 1951 4256.89
c_1950_1951_i 1950 1950_1951 4.67522e-10
r_2510_2511_e 2510 2511 836.944
r_2510_2511_i 2510_2511 2511 4256.89
c_2510_2511_i 2510 2510_2511 4.67522e-10
r_3070_3071_e 3070 3071 13758.3
r_3070_3071_i 3070_3071 3071 95645.6
c_3070_3071_i 3070 3070_3071 9.36084e-12
r_3630_3631_e 3630 3631 13758.3
r_3630_3631_i 3630_3631 3631 95645.6
c_3630_3631_i 3630 3630_3631 9.36084e-12
r_271_272_e 271 272 13376.4
r_271_272_i 271_272 272 93218.1
c_271_272_i 271 271_272 2.08965e-09
r_831_832_e 831 832 13376.4
r_831_832_i 831_832 832 93218.1
c_831_832_i 831 831_832 2.08965e-09
r_1391_1392_e 1391 1392 836.944
r_1391_1392_i 1391_1392 1392 4256.89
c_1391_1392_i 1391 1391_1392 4.67522e-10
r_1951_1952_e 1951 1952 836.944
r_1951_1952_i 1951_1952 1952 4256.89
c_1951_1952_i 1951 1951_1952 4.67522e-10
r_2511_2512_e 2511 2512 836.944
r_2511_2512_i 2511_2512 2512 4256.89
c_2511_2512_i 2511 2511_2512 4.67522e-10
r_3071_3072_e 3071 3072 13758.3
r_3071_3072_i 3071_3072 3072 95645.6
c_3071_3072_i 3071 3071_3072 9.36084e-12
r_3631_3632_e 3631 3632 13758.3
r_3631_3632_i 3631_3632 3632 95645.6
c_3631_3632_i 3631 3631_3632 9.36084e-12
r_273_274_e 273 274 13376.4
r_273_274_i 273_274 274 93218.1
c_273_274_i 273 273_274 2.08965e-09
r_833_834_e 833 834 13376.4
r_833_834_i 833_834 834 93218.1
c_833_834_i 833 833_834 2.08965e-09
r_1393_1394_e 1393 1394 13376.4
r_1393_1394_i 1393_1394 1394 93218.1
c_1393_1394_i 1393 1393_1394 2.08965e-09
r_1953_1954_e 1953 1954 13376.4
r_1953_1954_i 1953_1954 1954 93218.1
c_1953_1954_i 1953 1953_1954 2.08965e-09
r_2513_2514_e 2513 2514 13376.4
r_2513_2514_i 2513_2514 2514 93218.1
c_2513_2514_i 2513 2513_2514 2.08965e-09
r_3073_3074_e 3073 3074 13376.4
r_3073_3074_i 3073_3074 3074 93218.1
c_3073_3074_i 3073 3073_3074 2.08965e-09
r_3633_3634_e 3633 3634 13376.4
r_3633_3634_i 3633_3634 3634 93218.1
c_3633_3634_i 3633 3633_3634 2.08965e-09
r_274_275_e 274 275 13376.4
r_274_275_i 274_275 275 93218.1
c_274_275_i 274 274_275 2.08965e-09
r_834_835_e 834 835 13376.4
r_834_835_i 834_835 835 93218.1
c_834_835_i 834 834_835 2.08965e-09
r_1394_1395_e 1394 1395 13376.4
r_1394_1395_i 1394_1395 1395 93218.1
c_1394_1395_i 1394 1394_1395 2.08965e-09
r_1954_1955_e 1954 1955 13376.4
r_1954_1955_i 1954_1955 1955 93218.1
c_1954_1955_i 1954 1954_1955 2.08965e-09
r_2514_2515_e 2514 2515 13376.4
r_2514_2515_i 2514_2515 2515 93218.1
c_2514_2515_i 2514 2514_2515 2.08965e-09
r_3074_3075_e 3074 3075 13376.4
r_3074_3075_i 3074_3075 3075 93218.1
c_3074_3075_i 3074 3074_3075 2.08965e-09
r_3634_3635_e 3634 3635 13376.4
r_3634_3635_i 3634_3635 3635 93218.1
c_3634_3635_i 3634 3634_3635 2.08965e-09
r_275_276_e 275 276 13376.4
r_275_276_i 275_276 276 93218.1
c_275_276_i 275 275_276 2.08965e-09
r_835_836_e 835 836 13376.4
r_835_836_i 835_836 836 93218.1
c_835_836_i 835 835_836 2.08965e-09
r_1395_1396_e 1395 1396 836.944
r_1395_1396_i 1395_1396 1396 4256.89
c_1395_1396_i 1395 1395_1396 4.67522e-10
r_1955_1956_e 1955 1956 836.944
r_1955_1956_i 1955_1956 1956 4256.89
c_1955_1956_i 1955 1955_1956 4.67522e-10
r_2515_2516_e 2515 2516 836.944
r_2515_2516_i 2515_2516 2516 4256.89
c_2515_2516_i 2515 2515_2516 4.67522e-10
r_3075_3076_e 3075 3076 836.944
r_3075_3076_i 3075_3076 3076 4256.89
c_3075_3076_i 3075 3075_3076 4.67522e-10
r_3635_3636_e 3635 3636 836.944
r_3635_3636_i 3635_3636 3636 4256.89
c_3635_3636_i 3635 3635_3636 4.67522e-10
r_276_277_e 276 277 13376.4
r_276_277_i 276_277 277 93218.1
c_276_277_i 276 276_277 2.08965e-09
r_836_837_e 836 837 13376.4
r_836_837_i 836_837 837 93218.1
c_836_837_i 836 836_837 2.08965e-09
r_1396_1397_e 1396 1397 836.944
r_1396_1397_i 1396_1397 1397 4256.89
c_1396_1397_i 1396 1396_1397 4.67522e-10
r_1956_1957_e 1956 1957 836.944
r_1956_1957_i 1956_1957 1957 4256.89
c_1956_1957_i 1956 1956_1957 4.67522e-10
r_2516_2517_e 2516 2517 836.944
r_2516_2517_i 2516_2517 2517 4256.89
c_2516_2517_i 2516 2516_2517 4.67522e-10
r_3076_3077_e 3076 3077 13758.3
r_3076_3077_i 3076_3077 3077 95645.6
c_3076_3077_i 3076 3076_3077 9.36084e-12
r_3636_3637_e 3636 3637 13758.3
r_3636_3637_i 3636_3637 3637 95645.6
c_3636_3637_i 3636 3636_3637 9.36084e-12
r_277_278_e 277 278 13376.4
r_277_278_i 277_278 278 93218.1
c_277_278_i 277 277_278 2.08965e-09
r_837_838_e 837 838 13376.4
r_837_838_i 837_838 838 93218.1
c_837_838_i 837 837_838 2.08965e-09
r_1397_1398_e 1397 1398 836.944
r_1397_1398_i 1397_1398 1398 4256.89
c_1397_1398_i 1397 1397_1398 4.67522e-10
r_1957_1958_e 1957 1958 836.944
r_1957_1958_i 1957_1958 1958 4256.89
c_1957_1958_i 1957 1957_1958 4.67522e-10
r_2517_2518_e 2517 2518 836.944
r_2517_2518_i 2517_2518 2518 4256.89
c_2517_2518_i 2517 2517_2518 4.67522e-10
r_3077_3078_e 3077 3078 13758.3
r_3077_3078_i 3077_3078 3078 95645.6
c_3077_3078_i 3077 3077_3078 9.36084e-12
r_3637_3638_e 3637 3638 13758.3
r_3637_3638_i 3637_3638 3638 95645.6
c_3637_3638_i 3637 3637_3638 9.36084e-12
r_278_279_e 278 279 13376.4
r_278_279_i 278_279 279 93218.1
c_278_279_i 278 278_279 2.08965e-09
r_838_839_e 838 839 13376.4
r_838_839_i 838_839 839 93218.1
c_838_839_i 838 838_839 2.08965e-09
r_1398_1399_e 1398 1399 836.944
r_1398_1399_i 1398_1399 1399 4256.89
c_1398_1399_i 1398 1398_1399 4.67522e-10
r_1958_1959_e 1958 1959 836.944
r_1958_1959_i 1958_1959 1959 4256.89
c_1958_1959_i 1958 1958_1959 4.67522e-10
r_2518_2519_e 2518 2519 836.944
r_2518_2519_i 2518_2519 2519 4256.89
c_2518_2519_i 2518 2518_2519 4.67522e-10
r_3078_3079_e 3078 3079 13758.3
r_3078_3079_i 3078_3079 3079 95645.6
c_3078_3079_i 3078 3078_3079 9.36084e-12
r_3638_3639_e 3638 3639 13758.3
r_3638_3639_i 3638_3639 3639 95645.6
c_3638_3639_i 3638 3638_3639 9.36084e-12
r_279_280_e 279 280 13376.4
r_279_280_i 279_280 280 93218.1
c_279_280_i 279 279_280 2.08965e-09
r_839_840_e 839 840 13376.4
r_839_840_i 839_840 840 93218.1
c_839_840_i 839 839_840 2.08965e-09
r_1399_1400_e 1399 1400 836.944
r_1399_1400_i 1399_1400 1400 4256.89
c_1399_1400_i 1399 1399_1400 4.67522e-10
r_1959_1960_e 1959 1960 836.944
r_1959_1960_i 1959_1960 1960 4256.89
c_1959_1960_i 1959 1959_1960 4.67522e-10
r_2519_2520_e 2519 2520 836.944
r_2519_2520_i 2519_2520 2520 4256.89
c_2519_2520_i 2519 2519_2520 4.67522e-10
r_3079_3080_e 3079 3080 13758.3
r_3079_3080_i 3079_3080 3080 95645.6
c_3079_3080_i 3079 3079_3080 9.36084e-12
r_3639_3640_e 3639 3640 13758.3
r_3639_3640_i 3639_3640 3640 95645.6
c_3639_3640_i 3639 3639_3640 9.36084e-12
r_280_281_e 280 281 13376.4
r_280_281_i 280_281 281 93218.1
c_280_281_i 280 280_281 2.08965e-09
r_840_841_e 840 841 13376.4
r_840_841_i 840_841 841 93218.1
c_840_841_i 840 840_841 2.08965e-09
r_1400_1401_e 1400 1401 836.944
r_1400_1401_i 1400_1401 1401 4256.89
c_1400_1401_i 1400 1400_1401 4.67522e-10
r_1960_1961_e 1960 1961 836.944
r_1960_1961_i 1960_1961 1961 4256.89
c_1960_1961_i 1960 1960_1961 4.67522e-10
r_2520_2521_e 2520 2521 836.944
r_2520_2521_i 2520_2521 2521 4256.89
c_2520_2521_i 2520 2520_2521 4.67522e-10
r_3080_3081_e 3080 3081 13758.3
r_3080_3081_i 3080_3081 3081 95645.6
c_3080_3081_i 3080 3080_3081 9.36084e-12
r_3640_3641_e 3640 3641 13758.3
r_3640_3641_i 3640_3641 3641 95645.6
c_3640_3641_i 3640 3640_3641 9.36084e-12
r_281_282_e 281 282 13376.4
r_281_282_i 281_282 282 93218.1
c_281_282_i 281 281_282 2.08965e-09
r_841_842_e 841 842 13376.4
r_841_842_i 841_842 842 93218.1
c_841_842_i 841 841_842 2.08965e-09
r_1401_1402_e 1401 1402 836.944
r_1401_1402_i 1401_1402 1402 4256.89
c_1401_1402_i 1401 1401_1402 4.67522e-10
r_1961_1962_e 1961 1962 836.944
r_1961_1962_i 1961_1962 1962 4256.89
c_1961_1962_i 1961 1961_1962 4.67522e-10
r_2521_2522_e 2521 2522 836.944
r_2521_2522_i 2521_2522 2522 4256.89
c_2521_2522_i 2521 2521_2522 4.67522e-10
r_3081_3082_e 3081 3082 13758.3
r_3081_3082_i 3081_3082 3082 95645.6
c_3081_3082_i 3081 3081_3082 9.36084e-12
r_3641_3642_e 3641 3642 13758.3
r_3641_3642_i 3641_3642 3642 95645.6
c_3641_3642_i 3641 3641_3642 9.36084e-12
r_282_283_e 282 283 13376.4
r_282_283_i 282_283 283 93218.1
c_282_283_i 282 282_283 2.08965e-09
r_842_843_e 842 843 13376.4
r_842_843_i 842_843 843 93218.1
c_842_843_i 842 842_843 2.08965e-09
r_1402_1403_e 1402 1403 836.944
r_1402_1403_i 1402_1403 1403 4256.89
c_1402_1403_i 1402 1402_1403 4.67522e-10
r_1962_1963_e 1962 1963 836.944
r_1962_1963_i 1962_1963 1963 4256.89
c_1962_1963_i 1962 1962_1963 4.67522e-10
r_2522_2523_e 2522 2523 836.944
r_2522_2523_i 2522_2523 2523 4256.89
c_2522_2523_i 2522 2522_2523 4.67522e-10
r_3082_3083_e 3082 3083 13758.3
r_3082_3083_i 3082_3083 3083 95645.6
c_3082_3083_i 3082 3082_3083 9.36084e-12
r_3642_3643_e 3642 3643 13758.3
r_3642_3643_i 3642_3643 3643 95645.6
c_3642_3643_i 3642 3642_3643 9.36084e-12
r_283_284_e 283 284 13376.4
r_283_284_i 283_284 284 93218.1
c_283_284_i 283 283_284 2.08965e-09
r_843_844_e 843 844 13376.4
r_843_844_i 843_844 844 93218.1
c_843_844_i 843 843_844 2.08965e-09
r_1403_1404_e 1403 1404 396.628
r_1403_1404_i 1403_1404 1404 1005.09
c_1403_1404_i 1403 1403_1404 1.65824e-10
r_1963_1964_e 1963 1964 396.628
r_1963_1964_i 1963_1964 1964 1005.09
c_1963_1964_i 1963 1963_1964 1.65824e-10
r_2523_2524_e 2523 2524 836.944
r_2523_2524_i 2523_2524 2524 4256.89
c_2523_2524_i 2523 2523_2524 4.67522e-10
r_3083_3084_e 3083 3084 13758.3
r_3083_3084_i 3083_3084 3084 95645.6
c_3083_3084_i 3083 3083_3084 9.36084e-12
r_3643_3644_e 3643 3644 13758.3
r_3643_3644_i 3643_3644 3644 95645.6
c_3643_3644_i 3643 3643_3644 9.36084e-12
r_284_285_e 284 285 13376.4
r_284_285_i 284_285 285 93218.1
c_284_285_i 284 284_285 2.08965e-09
r_844_845_e 844 845 13376.4
r_844_845_i 844_845 845 93218.1
c_844_845_i 844 844_845 2.08965e-09
r_1404_1405_e 1404 1405 836.944
r_1404_1405_i 1404_1405 1405 4256.89
c_1404_1405_i 1404 1404_1405 4.67522e-10
r_1964_1965_e 1964 1965 836.944
r_1964_1965_i 1964_1965 1965 4256.89
c_1964_1965_i 1964 1964_1965 4.67522e-10
r_2524_2525_e 2524 2525 836.944
r_2524_2525_i 2524_2525 2525 4256.89
c_2524_2525_i 2524 2524_2525 4.67522e-10
r_3084_3085_e 3084 3085 13758.3
r_3084_3085_i 3084_3085 3085 95645.6
c_3084_3085_i 3084 3084_3085 9.36084e-12
r_3644_3645_e 3644 3645 13758.3
r_3644_3645_i 3644_3645 3645 95645.6
c_3644_3645_i 3644 3644_3645 9.36084e-12
r_285_286_e 285 286 13376.4
r_285_286_i 285_286 286 93218.1
c_285_286_i 285 285_286 2.08965e-09
r_845_846_e 845 846 13376.4
r_845_846_i 845_846 846 93218.1
c_845_846_i 845 845_846 2.08965e-09
r_1405_1406_e 1405 1406 836.944
r_1405_1406_i 1405_1406 1406 4256.89
c_1405_1406_i 1405 1405_1406 4.67522e-10
r_1965_1966_e 1965 1966 836.944
r_1965_1966_i 1965_1966 1966 4256.89
c_1965_1966_i 1965 1965_1966 4.67522e-10
r_2525_2526_e 2525 2526 836.944
r_2525_2526_i 2525_2526 2526 4256.89
c_2525_2526_i 2525 2525_2526 4.67522e-10
r_3085_3086_e 3085 3086 13758.3
r_3085_3086_i 3085_3086 3086 95645.6
c_3085_3086_i 3085 3085_3086 9.36084e-12
r_3645_3646_e 3645 3646 13758.3
r_3645_3646_i 3645_3646 3646 95645.6
c_3645_3646_i 3645 3645_3646 9.36084e-12
r_286_287_e 286 287 13376.4
r_286_287_i 286_287 287 93218.1
c_286_287_i 286 286_287 2.08965e-09
r_846_847_e 846 847 13376.4
r_846_847_i 846_847 847 93218.1
c_846_847_i 846 846_847 2.08965e-09
r_1406_1407_e 1406 1407 836.944
r_1406_1407_i 1406_1407 1407 4256.89
c_1406_1407_i 1406 1406_1407 4.67522e-10
r_1966_1967_e 1966 1967 836.944
r_1966_1967_i 1966_1967 1967 4256.89
c_1966_1967_i 1966 1966_1967 4.67522e-10
r_2526_2527_e 2526 2527 836.944
r_2526_2527_i 2526_2527 2527 4256.89
c_2526_2527_i 2526 2526_2527 4.67522e-10
r_3086_3087_e 3086 3087 13758.3
r_3086_3087_i 3086_3087 3087 95645.6
c_3086_3087_i 3086 3086_3087 9.36084e-12
r_3646_3647_e 3646 3647 13758.3
r_3646_3647_i 3646_3647 3647 95645.6
c_3646_3647_i 3646 3646_3647 9.36084e-12
r_287_288_e 287 288 13376.4
r_287_288_i 287_288 288 93218.1
c_287_288_i 287 287_288 2.08965e-09
r_847_848_e 847 848 13376.4
r_847_848_i 847_848 848 93218.1
c_847_848_i 847 847_848 2.08965e-09
r_1407_1408_e 1407 1408 836.944
r_1407_1408_i 1407_1408 1408 4256.89
c_1407_1408_i 1407 1407_1408 4.67522e-10
r_1967_1968_e 1967 1968 836.944
r_1967_1968_i 1967_1968 1968 4256.89
c_1967_1968_i 1967 1967_1968 4.67522e-10
r_2527_2528_e 2527 2528 836.944
r_2527_2528_i 2527_2528 2528 4256.89
c_2527_2528_i 2527 2527_2528 4.67522e-10
r_3087_3088_e 3087 3088 13758.3
r_3087_3088_i 3087_3088 3088 95645.6
c_3087_3088_i 3087 3087_3088 9.36084e-12
r_3647_3648_e 3647 3648 13758.3
r_3647_3648_i 3647_3648 3648 95645.6
c_3647_3648_i 3647 3647_3648 9.36084e-12
r_289_290_e 289 290 13376.4
r_289_290_i 289_290 290 93218.1
c_289_290_i 289 289_290 2.08965e-09
r_849_850_e 849 850 13376.4
r_849_850_i 849_850 850 93218.1
c_849_850_i 849 849_850 2.08965e-09
r_1409_1410_e 1409 1410 13376.4
r_1409_1410_i 1409_1410 1410 93218.1
c_1409_1410_i 1409 1409_1410 2.08965e-09
r_1969_1970_e 1969 1970 13376.4
r_1969_1970_i 1969_1970 1970 93218.1
c_1969_1970_i 1969 1969_1970 2.08965e-09
r_2529_2530_e 2529 2530 13376.4
r_2529_2530_i 2529_2530 2530 93218.1
c_2529_2530_i 2529 2529_2530 2.08965e-09
r_3089_3090_e 3089 3090 13376.4
r_3089_3090_i 3089_3090 3090 93218.1
c_3089_3090_i 3089 3089_3090 2.08965e-09
r_3649_3650_e 3649 3650 13376.4
r_3649_3650_i 3649_3650 3650 93218.1
c_3649_3650_i 3649 3649_3650 2.08965e-09
r_290_291_e 290 291 13376.4
r_290_291_i 290_291 291 93218.1
c_290_291_i 290 290_291 2.08965e-09
r_850_851_e 850 851 13376.4
r_850_851_i 850_851 851 93218.1
c_850_851_i 850 850_851 2.08965e-09
r_1410_1411_e 1410 1411 13376.4
r_1410_1411_i 1410_1411 1411 93218.1
c_1410_1411_i 1410 1410_1411 2.08965e-09
r_1970_1971_e 1970 1971 13376.4
r_1970_1971_i 1970_1971 1971 93218.1
c_1970_1971_i 1970 1970_1971 2.08965e-09
r_2530_2531_e 2530 2531 13376.4
r_2530_2531_i 2530_2531 2531 93218.1
c_2530_2531_i 2530 2530_2531 2.08965e-09
r_3090_3091_e 3090 3091 13376.4
r_3090_3091_i 3090_3091 3091 93218.1
c_3090_3091_i 3090 3090_3091 2.08965e-09
r_3650_3651_e 3650 3651 13376.4
r_3650_3651_i 3650_3651 3651 93218.1
c_3650_3651_i 3650 3650_3651 2.08965e-09
r_291_292_e 291 292 13376.4
r_291_292_i 291_292 292 93218.1
c_291_292_i 291 291_292 2.08965e-09
r_851_852_e 851 852 13376.4
r_851_852_i 851_852 852 93218.1
c_851_852_i 851 851_852 2.08965e-09
r_1411_1412_e 1411 1412 836.944
r_1411_1412_i 1411_1412 1412 4256.89
c_1411_1412_i 1411 1411_1412 4.67522e-10
r_1971_1972_e 1971 1972 836.944
r_1971_1972_i 1971_1972 1972 4256.89
c_1971_1972_i 1971 1971_1972 4.67522e-10
r_2531_2532_e 2531 2532 836.944
r_2531_2532_i 2531_2532 2532 4256.89
c_2531_2532_i 2531 2531_2532 4.67522e-10
r_3091_3092_e 3091 3092 836.944
r_3091_3092_i 3091_3092 3092 4256.89
c_3091_3092_i 3091 3091_3092 4.67522e-10
r_3651_3652_e 3651 3652 836.944
r_3651_3652_i 3651_3652 3652 4256.89
c_3651_3652_i 3651 3651_3652 4.67522e-10
r_292_293_e 292 293 13376.4
r_292_293_i 292_293 293 93218.1
c_292_293_i 292 292_293 2.08965e-09
r_852_853_e 852 853 13376.4
r_852_853_i 852_853 853 93218.1
c_852_853_i 852 852_853 2.08965e-09
r_1412_1413_e 1412 1413 836.944
r_1412_1413_i 1412_1413 1413 4256.89
c_1412_1413_i 1412 1412_1413 4.67522e-10
r_1972_1973_e 1972 1973 836.944
r_1972_1973_i 1972_1973 1973 4256.89
c_1972_1973_i 1972 1972_1973 4.67522e-10
r_2532_2533_e 2532 2533 836.944
r_2532_2533_i 2532_2533 2533 4256.89
c_2532_2533_i 2532 2532_2533 4.67522e-10
r_3092_3093_e 3092 3093 13758.3
r_3092_3093_i 3092_3093 3093 95645.6
c_3092_3093_i 3092 3092_3093 9.36084e-12
r_3652_3653_e 3652 3653 13758.3
r_3652_3653_i 3652_3653 3653 95645.6
c_3652_3653_i 3652 3652_3653 9.36084e-12
r_293_294_e 293 294 13376.4
r_293_294_i 293_294 294 93218.1
c_293_294_i 293 293_294 2.08965e-09
r_853_854_e 853 854 13376.4
r_853_854_i 853_854 854 93218.1
c_853_854_i 853 853_854 2.08965e-09
r_1413_1414_e 1413 1414 836.944
r_1413_1414_i 1413_1414 1414 4256.89
c_1413_1414_i 1413 1413_1414 4.67522e-10
r_1973_1974_e 1973 1974 836.944
r_1973_1974_i 1973_1974 1974 4256.89
c_1973_1974_i 1973 1973_1974 4.67522e-10
r_2533_2534_e 2533 2534 836.944
r_2533_2534_i 2533_2534 2534 4256.89
c_2533_2534_i 2533 2533_2534 4.67522e-10
r_3093_3094_e 3093 3094 13758.3
r_3093_3094_i 3093_3094 3094 95645.6
c_3093_3094_i 3093 3093_3094 9.36084e-12
r_3653_3654_e 3653 3654 13758.3
r_3653_3654_i 3653_3654 3654 95645.6
c_3653_3654_i 3653 3653_3654 9.36084e-12
r_294_295_e 294 295 13376.4
r_294_295_i 294_295 295 93218.1
c_294_295_i 294 294_295 2.08965e-09
r_854_855_e 854 855 13376.4
r_854_855_i 854_855 855 93218.1
c_854_855_i 854 854_855 2.08965e-09
r_1414_1415_e 1414 1415 836.944
r_1414_1415_i 1414_1415 1415 4256.89
c_1414_1415_i 1414 1414_1415 4.67522e-10
r_1974_1975_e 1974 1975 836.944
r_1974_1975_i 1974_1975 1975 4256.89
c_1974_1975_i 1974 1974_1975 4.67522e-10
r_2534_2535_e 2534 2535 836.944
r_2534_2535_i 2534_2535 2535 4256.89
c_2534_2535_i 2534 2534_2535 4.67522e-10
r_3094_3095_e 3094 3095 13758.3
r_3094_3095_i 3094_3095 3095 95645.6
c_3094_3095_i 3094 3094_3095 9.36084e-12
r_3654_3655_e 3654 3655 13758.3
r_3654_3655_i 3654_3655 3655 95645.6
c_3654_3655_i 3654 3654_3655 9.36084e-12
r_295_296_e 295 296 13376.4
r_295_296_i 295_296 296 93218.1
c_295_296_i 295 295_296 2.08965e-09
r_855_856_e 855 856 13376.4
r_855_856_i 855_856 856 93218.1
c_855_856_i 855 855_856 2.08965e-09
r_1415_1416_e 1415 1416 836.944
r_1415_1416_i 1415_1416 1416 4256.89
c_1415_1416_i 1415 1415_1416 4.67522e-10
r_1975_1976_e 1975 1976 836.944
r_1975_1976_i 1975_1976 1976 4256.89
c_1975_1976_i 1975 1975_1976 4.67522e-10
r_2535_2536_e 2535 2536 836.944
r_2535_2536_i 2535_2536 2536 4256.89
c_2535_2536_i 2535 2535_2536 4.67522e-10
r_3095_3096_e 3095 3096 13758.3
r_3095_3096_i 3095_3096 3096 95645.6
c_3095_3096_i 3095 3095_3096 9.36084e-12
r_3655_3656_e 3655 3656 13758.3
r_3655_3656_i 3655_3656 3656 95645.6
c_3655_3656_i 3655 3655_3656 9.36084e-12
r_296_297_e 296 297 13376.4
r_296_297_i 296_297 297 93218.1
c_296_297_i 296 296_297 2.08965e-09
r_856_857_e 856 857 13376.4
r_856_857_i 856_857 857 93218.1
c_856_857_i 856 856_857 2.08965e-09
r_1416_1417_e 1416 1417 836.944
r_1416_1417_i 1416_1417 1417 4256.89
c_1416_1417_i 1416 1416_1417 4.67522e-10
r_1976_1977_e 1976 1977 836.944
r_1976_1977_i 1976_1977 1977 4256.89
c_1976_1977_i 1976 1976_1977 4.67522e-10
r_2536_2537_e 2536 2537 836.944
r_2536_2537_i 2536_2537 2537 4256.89
c_2536_2537_i 2536 2536_2537 4.67522e-10
r_3096_3097_e 3096 3097 13758.3
r_3096_3097_i 3096_3097 3097 95645.6
c_3096_3097_i 3096 3096_3097 9.36084e-12
r_3656_3657_e 3656 3657 13758.3
r_3656_3657_i 3656_3657 3657 95645.6
c_3656_3657_i 3656 3656_3657 9.36084e-12
r_297_298_e 297 298 13376.4
r_297_298_i 297_298 298 93218.1
c_297_298_i 297 297_298 2.08965e-09
r_857_858_e 857 858 13376.4
r_857_858_i 857_858 858 93218.1
c_857_858_i 857 857_858 2.08965e-09
r_1417_1418_e 1417 1418 836.944
r_1417_1418_i 1417_1418 1418 4256.89
c_1417_1418_i 1417 1417_1418 4.67522e-10
r_1977_1978_e 1977 1978 836.944
r_1977_1978_i 1977_1978 1978 4256.89
c_1977_1978_i 1977 1977_1978 4.67522e-10
r_2537_2538_e 2537 2538 836.944
r_2537_2538_i 2537_2538 2538 4256.89
c_2537_2538_i 2537 2537_2538 4.67522e-10
r_3097_3098_e 3097 3098 13758.3
r_3097_3098_i 3097_3098 3098 95645.6
c_3097_3098_i 3097 3097_3098 9.36084e-12
r_3657_3658_e 3657 3658 13758.3
r_3657_3658_i 3657_3658 3658 95645.6
c_3657_3658_i 3657 3657_3658 9.36084e-12
r_298_299_e 298 299 13376.4
r_298_299_i 298_299 299 93218.1
c_298_299_i 298 298_299 2.08965e-09
r_858_859_e 858 859 13376.4
r_858_859_i 858_859 859 93218.1
c_858_859_i 858 858_859 2.08965e-09
r_1418_1419_e 1418 1419 836.944
r_1418_1419_i 1418_1419 1419 4256.89
c_1418_1419_i 1418 1418_1419 4.67522e-10
r_1978_1979_e 1978 1979 836.944
r_1978_1979_i 1978_1979 1979 4256.89
c_1978_1979_i 1978 1978_1979 4.67522e-10
r_2538_2539_e 2538 2539 836.944
r_2538_2539_i 2538_2539 2539 4256.89
c_2538_2539_i 2538 2538_2539 4.67522e-10
r_3098_3099_e 3098 3099 13758.3
r_3098_3099_i 3098_3099 3099 95645.6
c_3098_3099_i 3098 3098_3099 9.36084e-12
r_3658_3659_e 3658 3659 13758.3
r_3658_3659_i 3658_3659 3659 95645.6
c_3658_3659_i 3658 3658_3659 9.36084e-12
r_299_300_e 299 300 13376.4
r_299_300_i 299_300 300 93218.1
c_299_300_i 299 299_300 2.08965e-09
r_859_860_e 859 860 396.619
r_859_860_i 859_860 860 1005.07
c_859_860_i 859 859_860 1.65828e-10
r_1419_1420_e 1419 1420 396.619
r_1419_1420_i 1419_1420 1420 1005.07
c_1419_1420_i 1419 1419_1420 1.65828e-10
r_1979_1980_e 1979 1980 836.944
r_1979_1980_i 1979_1980 1980 4256.89
c_1979_1980_i 1979 1979_1980 4.67522e-10
r_2539_2540_e 2539 2540 836.944
r_2539_2540_i 2539_2540 2540 4256.89
c_2539_2540_i 2539 2539_2540 4.67522e-10
r_3099_3100_e 3099 3100 13758.3
r_3099_3100_i 3099_3100 3100 95645.6
c_3099_3100_i 3099 3099_3100 9.36084e-12
r_3659_3660_e 3659 3660 13758.3
r_3659_3660_i 3659_3660 3660 95645.6
c_3659_3660_i 3659 3659_3660 9.36084e-12
r_300_301_e 300 301 13376.4
r_300_301_i 300_301 301 93218.1
c_300_301_i 300 300_301 2.08965e-09
r_860_861_e 860 861 13376.4
r_860_861_i 860_861 861 93218.1
c_860_861_i 860 860_861 2.08965e-09
r_1420_1421_e 1420 1421 836.944
r_1420_1421_i 1420_1421 1421 4256.89
c_1420_1421_i 1420 1420_1421 4.67522e-10
r_1980_1981_e 1980 1981 836.944
r_1980_1981_i 1980_1981 1981 4256.89
c_1980_1981_i 1980 1980_1981 4.67522e-10
r_2540_2541_e 2540 2541 836.944
r_2540_2541_i 2540_2541 2541 4256.89
c_2540_2541_i 2540 2540_2541 4.67522e-10
r_3100_3101_e 3100 3101 13758.3
r_3100_3101_i 3100_3101 3101 95645.6
c_3100_3101_i 3100 3100_3101 9.36084e-12
r_3660_3661_e 3660 3661 13758.3
r_3660_3661_i 3660_3661 3661 95645.6
c_3660_3661_i 3660 3660_3661 9.36084e-12
r_301_302_e 301 302 13376.4
r_301_302_i 301_302 302 93218.1
c_301_302_i 301 301_302 2.08965e-09
r_861_862_e 861 862 13376.4
r_861_862_i 861_862 862 93218.1
c_861_862_i 861 861_862 2.08965e-09
r_1421_1422_e 1421 1422 836.944
r_1421_1422_i 1421_1422 1422 4256.89
c_1421_1422_i 1421 1421_1422 4.67522e-10
r_1981_1982_e 1981 1982 836.944
r_1981_1982_i 1981_1982 1982 4256.89
c_1981_1982_i 1981 1981_1982 4.67522e-10
r_2541_2542_e 2541 2542 836.944
r_2541_2542_i 2541_2542 2542 4256.89
c_2541_2542_i 2541 2541_2542 4.67522e-10
r_3101_3102_e 3101 3102 13758.3
r_3101_3102_i 3101_3102 3102 95645.6
c_3101_3102_i 3101 3101_3102 9.36084e-12
r_3661_3662_e 3661 3662 13758.3
r_3661_3662_i 3661_3662 3662 95645.6
c_3661_3662_i 3661 3661_3662 9.36084e-12
r_302_303_e 302 303 13376.4
r_302_303_i 302_303 303 93218.1
c_302_303_i 302 302_303 2.08965e-09
r_862_863_e 862 863 13376.4
r_862_863_i 862_863 863 93218.1
c_862_863_i 862 862_863 2.08965e-09
r_1422_1423_e 1422 1423 836.944
r_1422_1423_i 1422_1423 1423 4256.89
c_1422_1423_i 1422 1422_1423 4.67522e-10
r_1982_1983_e 1982 1983 836.944
r_1982_1983_i 1982_1983 1983 4256.89
c_1982_1983_i 1982 1982_1983 4.67522e-10
r_2542_2543_e 2542 2543 836.944
r_2542_2543_i 2542_2543 2543 4256.89
c_2542_2543_i 2542 2542_2543 4.67522e-10
r_3102_3103_e 3102 3103 13758.3
r_3102_3103_i 3102_3103 3103 95645.6
c_3102_3103_i 3102 3102_3103 9.36084e-12
r_3662_3663_e 3662 3663 13758.3
r_3662_3663_i 3662_3663 3663 95645.6
c_3662_3663_i 3662 3662_3663 9.36084e-12
r_303_304_e 303 304 13376.4
r_303_304_i 303_304 304 93218.1
c_303_304_i 303 303_304 2.08965e-09
r_863_864_e 863 864 13376.4
r_863_864_i 863_864 864 93218.1
c_863_864_i 863 863_864 2.08965e-09
r_1423_1424_e 1423 1424 836.944
r_1423_1424_i 1423_1424 1424 4256.89
c_1423_1424_i 1423 1423_1424 4.67522e-10
r_1983_1984_e 1983 1984 836.944
r_1983_1984_i 1983_1984 1984 4256.89
c_1983_1984_i 1983 1983_1984 4.67522e-10
r_2543_2544_e 2543 2544 836.944
r_2543_2544_i 2543_2544 2544 4256.89
c_2543_2544_i 2543 2543_2544 4.67522e-10
r_3103_3104_e 3103 3104 13758.3
r_3103_3104_i 3103_3104 3104 95645.6
c_3103_3104_i 3103 3103_3104 9.36084e-12
r_3663_3664_e 3663 3664 13758.3
r_3663_3664_i 3663_3664 3664 95645.6
c_3663_3664_i 3663 3663_3664 9.36084e-12
r_305_306_e 305 306 13376.4
r_305_306_i 305_306 306 93218.1
c_305_306_i 305 305_306 2.08965e-09
r_865_866_e 865 866 13376.4
r_865_866_i 865_866 866 93218.1
c_865_866_i 865 865_866 2.08965e-09
r_1425_1426_e 1425 1426 13376.4
r_1425_1426_i 1425_1426 1426 93218.1
c_1425_1426_i 1425 1425_1426 2.08965e-09
r_1985_1986_e 1985 1986 13376.4
r_1985_1986_i 1985_1986 1986 93218.1
c_1985_1986_i 1985 1985_1986 2.08965e-09
r_2545_2546_e 2545 2546 13376.4
r_2545_2546_i 2545_2546 2546 93218.1
c_2545_2546_i 2545 2545_2546 2.08965e-09
r_3105_3106_e 3105 3106 13376.4
r_3105_3106_i 3105_3106 3106 93218.1
c_3105_3106_i 3105 3105_3106 2.08965e-09
r_3665_3666_e 3665 3666 13376.4
r_3665_3666_i 3665_3666 3666 93218.1
c_3665_3666_i 3665 3665_3666 2.08965e-09
r_306_307_e 306 307 13376.4
r_306_307_i 306_307 307 93218.1
c_306_307_i 306 306_307 2.08965e-09
r_866_867_e 866 867 13376.4
r_866_867_i 866_867 867 93218.1
c_866_867_i 866 866_867 2.08965e-09
r_1426_1427_e 1426 1427 13376.4
r_1426_1427_i 1426_1427 1427 93218.1
c_1426_1427_i 1426 1426_1427 2.08965e-09
r_1986_1987_e 1986 1987 13376.4
r_1986_1987_i 1986_1987 1987 93218.1
c_1986_1987_i 1986 1986_1987 2.08965e-09
r_2546_2547_e 2546 2547 13376.4
r_2546_2547_i 2546_2547 2547 93218.1
c_2546_2547_i 2546 2546_2547 2.08965e-09
r_3106_3107_e 3106 3107 13376.4
r_3106_3107_i 3106_3107 3107 93218.1
c_3106_3107_i 3106 3106_3107 2.08965e-09
r_3666_3667_e 3666 3667 13376.4
r_3666_3667_i 3666_3667 3667 93218.1
c_3666_3667_i 3666 3666_3667 2.08965e-09
r_307_308_e 307 308 13376.4
r_307_308_i 307_308 308 93218.1
c_307_308_i 307 307_308 2.08965e-09
r_867_868_e 867 868 13376.4
r_867_868_i 867_868 868 93218.1
c_867_868_i 867 867_868 2.08965e-09
r_1427_1428_e 1427 1428 836.944
r_1427_1428_i 1427_1428 1428 4256.89
c_1427_1428_i 1427 1427_1428 4.67522e-10
r_1987_1988_e 1987 1988 836.944
r_1987_1988_i 1987_1988 1988 4256.89
c_1987_1988_i 1987 1987_1988 4.67522e-10
r_2547_2548_e 2547 2548 836.944
r_2547_2548_i 2547_2548 2548 4256.89
c_2547_2548_i 2547 2547_2548 4.67522e-10
r_3107_3108_e 3107 3108 836.944
r_3107_3108_i 3107_3108 3108 4256.89
c_3107_3108_i 3107 3107_3108 4.67522e-10
r_3667_3668_e 3667 3668 836.944
r_3667_3668_i 3667_3668 3668 4256.89
c_3667_3668_i 3667 3667_3668 4.67522e-10
r_308_309_e 308 309 13376.4
r_308_309_i 308_309 309 93218.1
c_308_309_i 308 308_309 2.08965e-09
r_868_869_e 868 869 13376.4
r_868_869_i 868_869 869 93218.1
c_868_869_i 868 868_869 2.08965e-09
r_1428_1429_e 1428 1429 836.944
r_1428_1429_i 1428_1429 1429 4256.89
c_1428_1429_i 1428 1428_1429 4.67522e-10
r_1988_1989_e 1988 1989 836.944
r_1988_1989_i 1988_1989 1989 4256.89
c_1988_1989_i 1988 1988_1989 4.67522e-10
r_2548_2549_e 2548 2549 836.944
r_2548_2549_i 2548_2549 2549 4256.89
c_2548_2549_i 2548 2548_2549 4.67522e-10
r_3108_3109_e 3108 3109 13758.3
r_3108_3109_i 3108_3109 3109 95645.6
c_3108_3109_i 3108 3108_3109 9.36084e-12
r_3668_3669_e 3668 3669 13758.3
r_3668_3669_i 3668_3669 3669 95645.6
c_3668_3669_i 3668 3668_3669 9.36084e-12
r_309_310_e 309 310 13376.4
r_309_310_i 309_310 310 93218.1
c_309_310_i 309 309_310 2.08965e-09
r_869_870_e 869 870 13376.4
r_869_870_i 869_870 870 93218.1
c_869_870_i 869 869_870 2.08965e-09
r_1429_1430_e 1429 1430 836.944
r_1429_1430_i 1429_1430 1430 4256.89
c_1429_1430_i 1429 1429_1430 4.67522e-10
r_1989_1990_e 1989 1990 836.944
r_1989_1990_i 1989_1990 1990 4256.89
c_1989_1990_i 1989 1989_1990 4.67522e-10
r_2549_2550_e 2549 2550 836.944
r_2549_2550_i 2549_2550 2550 4256.89
c_2549_2550_i 2549 2549_2550 4.67522e-10
r_3109_3110_e 3109 3110 13758.3
r_3109_3110_i 3109_3110 3110 95645.6
c_3109_3110_i 3109 3109_3110 9.36084e-12
r_3669_3670_e 3669 3670 13758.3
r_3669_3670_i 3669_3670 3670 95645.6
c_3669_3670_i 3669 3669_3670 9.36084e-12
r_310_311_e 310 311 13376.4
r_310_311_i 310_311 311 93218.1
c_310_311_i 310 310_311 2.08965e-09
r_870_871_e 870 871 13376.4
r_870_871_i 870_871 871 93218.1
c_870_871_i 870 870_871 2.08965e-09
r_1430_1431_e 1430 1431 836.944
r_1430_1431_i 1430_1431 1431 4256.89
c_1430_1431_i 1430 1430_1431 4.67522e-10
r_1990_1991_e 1990 1991 836.944
r_1990_1991_i 1990_1991 1991 4256.89
c_1990_1991_i 1990 1990_1991 4.67522e-10
r_2550_2551_e 2550 2551 836.944
r_2550_2551_i 2550_2551 2551 4256.89
c_2550_2551_i 2550 2550_2551 4.67522e-10
r_3110_3111_e 3110 3111 13758.3
r_3110_3111_i 3110_3111 3111 95645.6
c_3110_3111_i 3110 3110_3111 9.36084e-12
r_3670_3671_e 3670 3671 13758.3
r_3670_3671_i 3670_3671 3671 95645.6
c_3670_3671_i 3670 3670_3671 9.36084e-12
r_311_312_e 311 312 13376.4
r_311_312_i 311_312 312 93218.1
c_311_312_i 311 311_312 2.08965e-09
r_871_872_e 871 872 13376.4
r_871_872_i 871_872 872 93218.1
c_871_872_i 871 871_872 2.08965e-09
r_1431_1432_e 1431 1432 836.944
r_1431_1432_i 1431_1432 1432 4256.89
c_1431_1432_i 1431 1431_1432 4.67522e-10
r_1991_1992_e 1991 1992 836.944
r_1991_1992_i 1991_1992 1992 4256.89
c_1991_1992_i 1991 1991_1992 4.67522e-10
r_2551_2552_e 2551 2552 836.944
r_2551_2552_i 2551_2552 2552 4256.89
c_2551_2552_i 2551 2551_2552 4.67522e-10
r_3111_3112_e 3111 3112 13758.3
r_3111_3112_i 3111_3112 3112 95645.6
c_3111_3112_i 3111 3111_3112 9.36084e-12
r_3671_3672_e 3671 3672 13758.3
r_3671_3672_i 3671_3672 3672 95645.6
c_3671_3672_i 3671 3671_3672 9.36084e-12
r_312_313_e 312 313 13376.4
r_312_313_i 312_313 313 93218.1
c_312_313_i 312 312_313 2.08965e-09
r_872_873_e 872 873 13376.4
r_872_873_i 872_873 873 93218.1
c_872_873_i 872 872_873 2.08965e-09
r_1432_1433_e 1432 1433 836.944
r_1432_1433_i 1432_1433 1433 4256.89
c_1432_1433_i 1432 1432_1433 4.67522e-10
r_1992_1993_e 1992 1993 836.944
r_1992_1993_i 1992_1993 1993 4256.89
c_1992_1993_i 1992 1992_1993 4.67522e-10
r_2552_2553_e 2552 2553 836.944
r_2552_2553_i 2552_2553 2553 4256.89
c_2552_2553_i 2552 2552_2553 4.67522e-10
r_3112_3113_e 3112 3113 13758.3
r_3112_3113_i 3112_3113 3113 95645.6
c_3112_3113_i 3112 3112_3113 9.36084e-12
r_3672_3673_e 3672 3673 13758.3
r_3672_3673_i 3672_3673 3673 95645.6
c_3672_3673_i 3672 3672_3673 9.36084e-12
r_313_314_e 313 314 13376.4
r_313_314_i 313_314 314 93218.1
c_313_314_i 313 313_314 2.08965e-09
r_873_874_e 873 874 13376.4
r_873_874_i 873_874 874 93218.1
c_873_874_i 873 873_874 2.08965e-09
r_1433_1434_e 1433 1434 836.944
r_1433_1434_i 1433_1434 1434 4256.89
c_1433_1434_i 1433 1433_1434 4.67522e-10
r_1993_1994_e 1993 1994 836.944
r_1993_1994_i 1993_1994 1994 4256.89
c_1993_1994_i 1993 1993_1994 4.67522e-10
r_2553_2554_e 2553 2554 836.944
r_2553_2554_i 2553_2554 2554 4256.89
c_2553_2554_i 2553 2553_2554 4.67522e-10
r_3113_3114_e 3113 3114 13758.3
r_3113_3114_i 3113_3114 3114 95645.6
c_3113_3114_i 3113 3113_3114 9.36084e-12
r_3673_3674_e 3673 3674 13758.3
r_3673_3674_i 3673_3674 3674 95645.6
c_3673_3674_i 3673 3673_3674 9.36084e-12
r_314_315_e 314 315 13376.4
r_314_315_i 314_315 315 93218.1
c_314_315_i 314 314_315 2.08965e-09
r_874_875_e 874 875 13376.4
r_874_875_i 874_875 875 93218.1
c_874_875_i 874 874_875 2.08965e-09
r_1434_1435_e 1434 1435 836.944
r_1434_1435_i 1434_1435 1435 4256.89
c_1434_1435_i 1434 1434_1435 4.67522e-10
r_1994_1995_e 1994 1995 836.944
r_1994_1995_i 1994_1995 1995 4256.89
c_1994_1995_i 1994 1994_1995 4.67522e-10
r_2554_2555_e 2554 2555 836.944
r_2554_2555_i 2554_2555 2555 4256.89
c_2554_2555_i 2554 2554_2555 4.67522e-10
r_3114_3115_e 3114 3115 13758.3
r_3114_3115_i 3114_3115 3115 95645.6
c_3114_3115_i 3114 3114_3115 9.36084e-12
r_3674_3675_e 3674 3675 13758.3
r_3674_3675_i 3674_3675 3675 95645.6
c_3674_3675_i 3674 3674_3675 9.36084e-12
r_315_316_e 315 316 13376.4
r_315_316_i 315_316 316 93218.1
c_315_316_i 315 315_316 2.08965e-09
r_875_876_e 875 876 396.61
r_875_876_i 875_876 876 1005.05
c_875_876_i 875 875_876 1.65831e-10
r_1435_1436_e 1435 1436 396.61
r_1435_1436_i 1435_1436 1436 1005.05
c_1435_1436_i 1435 1435_1436 1.65831e-10
r_1995_1996_e 1995 1996 836.944
r_1995_1996_i 1995_1996 1996 4256.89
c_1995_1996_i 1995 1995_1996 4.67522e-10
r_2555_2556_e 2555 2556 836.944
r_2555_2556_i 2555_2556 2556 4256.89
c_2555_2556_i 2555 2555_2556 4.67522e-10
r_3115_3116_e 3115 3116 13758.3
r_3115_3116_i 3115_3116 3116 95645.6
c_3115_3116_i 3115 3115_3116 9.36084e-12
r_3675_3676_e 3675 3676 13758.3
r_3675_3676_i 3675_3676 3676 95645.6
c_3675_3676_i 3675 3675_3676 9.36084e-12
r_316_317_e 316 317 13376.4
r_316_317_i 316_317 317 93218.1
c_316_317_i 316 316_317 2.08965e-09
r_876_877_e 876 877 13376.4
r_876_877_i 876_877 877 93218.1
c_876_877_i 876 876_877 2.08965e-09
r_1436_1437_e 1436 1437 836.944
r_1436_1437_i 1436_1437 1437 4256.89
c_1436_1437_i 1436 1436_1437 4.67522e-10
r_1996_1997_e 1996 1997 836.944
r_1996_1997_i 1996_1997 1997 4256.89
c_1996_1997_i 1996 1996_1997 4.67522e-10
r_2556_2557_e 2556 2557 836.944
r_2556_2557_i 2556_2557 2557 4256.89
c_2556_2557_i 2556 2556_2557 4.67522e-10
r_3116_3117_e 3116 3117 13758.3
r_3116_3117_i 3116_3117 3117 95645.6
c_3116_3117_i 3116 3116_3117 9.36084e-12
r_3676_3677_e 3676 3677 13758.3
r_3676_3677_i 3676_3677 3677 95645.6
c_3676_3677_i 3676 3676_3677 9.36084e-12
r_317_318_e 317 318 13376.4
r_317_318_i 317_318 318 93218.1
c_317_318_i 317 317_318 2.08965e-09
r_877_878_e 877 878 13376.4
r_877_878_i 877_878 878 93218.1
c_877_878_i 877 877_878 2.08965e-09
r_1437_1438_e 1437 1438 836.944
r_1437_1438_i 1437_1438 1438 4256.89
c_1437_1438_i 1437 1437_1438 4.67522e-10
r_1997_1998_e 1997 1998 836.944
r_1997_1998_i 1997_1998 1998 4256.89
c_1997_1998_i 1997 1997_1998 4.67522e-10
r_2557_2558_e 2557 2558 836.944
r_2557_2558_i 2557_2558 2558 4256.89
c_2557_2558_i 2557 2557_2558 4.67522e-10
r_3117_3118_e 3117 3118 13758.3
r_3117_3118_i 3117_3118 3118 95645.6
c_3117_3118_i 3117 3117_3118 9.36084e-12
r_3677_3678_e 3677 3678 13758.3
r_3677_3678_i 3677_3678 3678 95645.6
c_3677_3678_i 3677 3677_3678 9.36084e-12
r_318_319_e 318 319 13376.4
r_318_319_i 318_319 319 93218.1
c_318_319_i 318 318_319 2.08965e-09
r_878_879_e 878 879 13376.4
r_878_879_i 878_879 879 93218.1
c_878_879_i 878 878_879 2.08965e-09
r_1438_1439_e 1438 1439 836.944
r_1438_1439_i 1438_1439 1439 4256.89
c_1438_1439_i 1438 1438_1439 4.67522e-10
r_1998_1999_e 1998 1999 836.944
r_1998_1999_i 1998_1999 1999 4256.89
c_1998_1999_i 1998 1998_1999 4.67522e-10
r_2558_2559_e 2558 2559 836.944
r_2558_2559_i 2558_2559 2559 4256.89
c_2558_2559_i 2558 2558_2559 4.67522e-10
r_3118_3119_e 3118 3119 13758.3
r_3118_3119_i 3118_3119 3119 95645.6
c_3118_3119_i 3118 3118_3119 9.36084e-12
r_3678_3679_e 3678 3679 13758.3
r_3678_3679_i 3678_3679 3679 95645.6
c_3678_3679_i 3678 3678_3679 9.36084e-12
r_319_320_e 319 320 13376.4
r_319_320_i 319_320 320 93218.1
c_319_320_i 319 319_320 2.08965e-09
r_879_880_e 879 880 13376.4
r_879_880_i 879_880 880 93218.1
c_879_880_i 879 879_880 2.08965e-09
r_1439_1440_e 1439 1440 836.944
r_1439_1440_i 1439_1440 1440 4256.89
c_1439_1440_i 1439 1439_1440 4.67522e-10
r_1999_2000_e 1999 2000 836.944
r_1999_2000_i 1999_2000 2000 4256.89
c_1999_2000_i 1999 1999_2000 4.67522e-10
r_2559_2560_e 2559 2560 836.944
r_2559_2560_i 2559_2560 2560 4256.89
c_2559_2560_i 2559 2559_2560 4.67522e-10
r_3119_3120_e 3119 3120 13758.3
r_3119_3120_i 3119_3120 3120 95645.6
c_3119_3120_i 3119 3119_3120 9.36084e-12
r_3679_3680_e 3679 3680 13758.3
r_3679_3680_i 3679_3680 3680 95645.6
c_3679_3680_i 3679 3679_3680 9.36084e-12
r_321_322_e 321 322 13376.4
r_321_322_i 321_322 322 93218.1
c_321_322_i 321 321_322 2.08965e-09
r_881_882_e 881 882 13376.4
r_881_882_i 881_882 882 93218.1
c_881_882_i 881 881_882 2.08965e-09
r_1441_1442_e 1441 1442 13376.4
r_1441_1442_i 1441_1442 1442 93218.1
c_1441_1442_i 1441 1441_1442 2.08965e-09
r_2001_2002_e 2001 2002 13376.4
r_2001_2002_i 2001_2002 2002 93218.1
c_2001_2002_i 2001 2001_2002 2.08965e-09
r_2561_2562_e 2561 2562 13376.4
r_2561_2562_i 2561_2562 2562 93218.1
c_2561_2562_i 2561 2561_2562 2.08965e-09
r_3121_3122_e 3121 3122 13376.4
r_3121_3122_i 3121_3122 3122 93218.1
c_3121_3122_i 3121 3121_3122 2.08965e-09
r_3681_3682_e 3681 3682 13376.4
r_3681_3682_i 3681_3682 3682 93218.1
c_3681_3682_i 3681 3681_3682 2.08965e-09
r_322_323_e 322 323 13376.4
r_322_323_i 322_323 323 93218.1
c_322_323_i 322 322_323 2.08965e-09
r_882_883_e 882 883 13376.4
r_882_883_i 882_883 883 93218.1
c_882_883_i 882 882_883 2.08965e-09
r_1442_1443_e 1442 1443 13376.4
r_1442_1443_i 1442_1443 1443 93218.1
c_1442_1443_i 1442 1442_1443 2.08965e-09
r_2002_2003_e 2002 2003 13376.4
r_2002_2003_i 2002_2003 2003 93218.1
c_2002_2003_i 2002 2002_2003 2.08965e-09
r_2562_2563_e 2562 2563 13376.4
r_2562_2563_i 2562_2563 2563 93218.1
c_2562_2563_i 2562 2562_2563 2.08965e-09
r_3122_3123_e 3122 3123 13376.4
r_3122_3123_i 3122_3123 3123 93218.1
c_3122_3123_i 3122 3122_3123 2.08965e-09
r_3682_3683_e 3682 3683 13376.4
r_3682_3683_i 3682_3683 3683 93218.1
c_3682_3683_i 3682 3682_3683 2.08965e-09
r_323_324_e 323 324 13376.4
r_323_324_i 323_324 324 93218.1
c_323_324_i 323 323_324 2.08965e-09
r_883_884_e 883 884 13376.4
r_883_884_i 883_884 884 93218.1
c_883_884_i 883 883_884 2.08965e-09
r_1443_1444_e 1443 1444 836.944
r_1443_1444_i 1443_1444 1444 4256.89
c_1443_1444_i 1443 1443_1444 4.67522e-10
r_2003_2004_e 2003 2004 836.944
r_2003_2004_i 2003_2004 2004 4256.89
c_2003_2004_i 2003 2003_2004 4.67522e-10
r_2563_2564_e 2563 2564 836.944
r_2563_2564_i 2563_2564 2564 4256.89
c_2563_2564_i 2563 2563_2564 4.67522e-10
r_3123_3124_e 3123 3124 836.944
r_3123_3124_i 3123_3124 3124 4256.89
c_3123_3124_i 3123 3123_3124 4.67522e-10
r_3683_3684_e 3683 3684 836.944
r_3683_3684_i 3683_3684 3684 4256.89
c_3683_3684_i 3683 3683_3684 4.67522e-10
r_324_325_e 324 325 13376.4
r_324_325_i 324_325 325 93218.1
c_324_325_i 324 324_325 2.08965e-09
r_884_885_e 884 885 13376.4
r_884_885_i 884_885 885 93218.1
c_884_885_i 884 884_885 2.08965e-09
r_1444_1445_e 1444 1445 836.944
r_1444_1445_i 1444_1445 1445 4256.89
c_1444_1445_i 1444 1444_1445 4.67522e-10
r_2004_2005_e 2004 2005 836.944
r_2004_2005_i 2004_2005 2005 4256.89
c_2004_2005_i 2004 2004_2005 4.67522e-10
r_2564_2565_e 2564 2565 836.944
r_2564_2565_i 2564_2565 2565 4256.89
c_2564_2565_i 2564 2564_2565 4.67522e-10
r_3124_3125_e 3124 3125 13758.3
r_3124_3125_i 3124_3125 3125 95645.6
c_3124_3125_i 3124 3124_3125 9.36084e-12
r_3684_3685_e 3684 3685 13758.3
r_3684_3685_i 3684_3685 3685 95645.6
c_3684_3685_i 3684 3684_3685 9.36084e-12
r_325_326_e 325 326 13376.4
r_325_326_i 325_326 326 93218.1
c_325_326_i 325 325_326 2.08965e-09
r_885_886_e 885 886 13376.4
r_885_886_i 885_886 886 93218.1
c_885_886_i 885 885_886 2.08965e-09
r_1445_1446_e 1445 1446 836.944
r_1445_1446_i 1445_1446 1446 4256.89
c_1445_1446_i 1445 1445_1446 4.67522e-10
r_2005_2006_e 2005 2006 836.944
r_2005_2006_i 2005_2006 2006 4256.89
c_2005_2006_i 2005 2005_2006 4.67522e-10
r_2565_2566_e 2565 2566 836.944
r_2565_2566_i 2565_2566 2566 4256.89
c_2565_2566_i 2565 2565_2566 4.67522e-10
r_3125_3126_e 3125 3126 13758.3
r_3125_3126_i 3125_3126 3126 95645.6
c_3125_3126_i 3125 3125_3126 9.36084e-12
r_3685_3686_e 3685 3686 13758.3
r_3685_3686_i 3685_3686 3686 95645.6
c_3685_3686_i 3685 3685_3686 9.36084e-12
r_326_327_e 326 327 13376.4
r_326_327_i 326_327 327 93218.1
c_326_327_i 326 326_327 2.08965e-09
r_886_887_e 886 887 13376.4
r_886_887_i 886_887 887 93218.1
c_886_887_i 886 886_887 2.08965e-09
r_1446_1447_e 1446 1447 836.944
r_1446_1447_i 1446_1447 1447 4256.89
c_1446_1447_i 1446 1446_1447 4.67522e-10
r_2006_2007_e 2006 2007 836.944
r_2006_2007_i 2006_2007 2007 4256.89
c_2006_2007_i 2006 2006_2007 4.67522e-10
r_2566_2567_e 2566 2567 836.944
r_2566_2567_i 2566_2567 2567 4256.89
c_2566_2567_i 2566 2566_2567 4.67522e-10
r_3126_3127_e 3126 3127 13758.3
r_3126_3127_i 3126_3127 3127 95645.6
c_3126_3127_i 3126 3126_3127 9.36084e-12
r_3686_3687_e 3686 3687 13758.3
r_3686_3687_i 3686_3687 3687 95645.6
c_3686_3687_i 3686 3686_3687 9.36084e-12
r_327_328_e 327 328 13376.4
r_327_328_i 327_328 328 93218.1
c_327_328_i 327 327_328 2.08965e-09
r_887_888_e 887 888 13376.4
r_887_888_i 887_888 888 93218.1
c_887_888_i 887 887_888 2.08965e-09
r_1447_1448_e 1447 1448 836.944
r_1447_1448_i 1447_1448 1448 4256.89
c_1447_1448_i 1447 1447_1448 4.67522e-10
r_2007_2008_e 2007 2008 836.944
r_2007_2008_i 2007_2008 2008 4256.89
c_2007_2008_i 2007 2007_2008 4.67522e-10
r_2567_2568_e 2567 2568 836.944
r_2567_2568_i 2567_2568 2568 4256.89
c_2567_2568_i 2567 2567_2568 4.67522e-10
r_3127_3128_e 3127 3128 13758.3
r_3127_3128_i 3127_3128 3128 95645.6
c_3127_3128_i 3127 3127_3128 9.36084e-12
r_3687_3688_e 3687 3688 13758.3
r_3687_3688_i 3687_3688 3688 95645.6
c_3687_3688_i 3687 3687_3688 9.36084e-12
r_328_329_e 328 329 13376.4
r_328_329_i 328_329 329 93218.1
c_328_329_i 328 328_329 2.08965e-09
r_888_889_e 888 889 13376.4
r_888_889_i 888_889 889 93218.1
c_888_889_i 888 888_889 2.08965e-09
r_1448_1449_e 1448 1449 836.944
r_1448_1449_i 1448_1449 1449 4256.89
c_1448_1449_i 1448 1448_1449 4.67522e-10
r_2008_2009_e 2008 2009 836.944
r_2008_2009_i 2008_2009 2009 4256.89
c_2008_2009_i 2008 2008_2009 4.67522e-10
r_2568_2569_e 2568 2569 836.944
r_2568_2569_i 2568_2569 2569 4256.89
c_2568_2569_i 2568 2568_2569 4.67522e-10
r_3128_3129_e 3128 3129 13758.3
r_3128_3129_i 3128_3129 3129 95645.6
c_3128_3129_i 3128 3128_3129 9.36084e-12
r_3688_3689_e 3688 3689 13758.3
r_3688_3689_i 3688_3689 3689 95645.6
c_3688_3689_i 3688 3688_3689 9.36084e-12
r_329_330_e 329 330 13376.4
r_329_330_i 329_330 330 93218.1
c_329_330_i 329 329_330 2.08965e-09
r_889_890_e 889 890 13376.4
r_889_890_i 889_890 890 93218.1
c_889_890_i 889 889_890 2.08965e-09
r_1449_1450_e 1449 1450 836.944
r_1449_1450_i 1449_1450 1450 4256.89
c_1449_1450_i 1449 1449_1450 4.67522e-10
r_2009_2010_e 2009 2010 836.944
r_2009_2010_i 2009_2010 2010 4256.89
c_2009_2010_i 2009 2009_2010 4.67522e-10
r_2569_2570_e 2569 2570 836.944
r_2569_2570_i 2569_2570 2570 4256.89
c_2569_2570_i 2569 2569_2570 4.67522e-10
r_3129_3130_e 3129 3130 13758.3
r_3129_3130_i 3129_3130 3130 95645.6
c_3129_3130_i 3129 3129_3130 9.36084e-12
r_3689_3690_e 3689 3690 13758.3
r_3689_3690_i 3689_3690 3690 95645.6
c_3689_3690_i 3689 3689_3690 9.36084e-12
r_330_331_e 330 331 13376.4
r_330_331_i 330_331 331 93218.1
c_330_331_i 330 330_331 2.08965e-09
r_890_891_e 890 891 13376.4
r_890_891_i 890_891 891 93218.1
c_890_891_i 890 890_891 2.08965e-09
r_1450_1451_e 1450 1451 836.944
r_1450_1451_i 1450_1451 1451 4256.89
c_1450_1451_i 1450 1450_1451 4.67522e-10
r_2010_2011_e 2010 2011 836.944
r_2010_2011_i 2010_2011 2011 4256.89
c_2010_2011_i 2010 2010_2011 4.67522e-10
r_2570_2571_e 2570 2571 836.944
r_2570_2571_i 2570_2571 2571 4256.89
c_2570_2571_i 2570 2570_2571 4.67522e-10
r_3130_3131_e 3130 3131 13758.3
r_3130_3131_i 3130_3131 3131 95645.6
c_3130_3131_i 3130 3130_3131 9.36084e-12
r_3690_3691_e 3690 3691 13758.3
r_3690_3691_i 3690_3691 3691 95645.6
c_3690_3691_i 3690 3690_3691 9.36084e-12
r_331_332_e 331 332 13376.4
r_331_332_i 331_332 332 93218.1
c_331_332_i 331 331_332 2.08965e-09
r_891_892_e 891 892 396.602
r_891_892_i 891_892 892 1005.03
c_891_892_i 891 891_892 1.65835e-10
r_1451_1452_e 1451 1452 396.602
r_1451_1452_i 1451_1452 1452 1005.03
c_1451_1452_i 1451 1451_1452 1.65835e-10
r_2011_2012_e 2011 2012 836.944
r_2011_2012_i 2011_2012 2012 4256.89
c_2011_2012_i 2011 2011_2012 4.67522e-10
r_2571_2572_e 2571 2572 836.944
r_2571_2572_i 2571_2572 2572 4256.89
c_2571_2572_i 2571 2571_2572 4.67522e-10
r_3131_3132_e 3131 3132 13758.3
r_3131_3132_i 3131_3132 3132 95645.6
c_3131_3132_i 3131 3131_3132 9.36084e-12
r_3691_3692_e 3691 3692 13758.3
r_3691_3692_i 3691_3692 3692 95645.6
c_3691_3692_i 3691 3691_3692 9.36084e-12
r_332_333_e 332 333 13376.4
r_332_333_i 332_333 333 93218.1
c_332_333_i 332 332_333 2.08965e-09
r_892_893_e 892 893 13376.4
r_892_893_i 892_893 893 93218.1
c_892_893_i 892 892_893 2.08965e-09
r_1452_1453_e 1452 1453 836.944
r_1452_1453_i 1452_1453 1453 4256.89
c_1452_1453_i 1452 1452_1453 4.67522e-10
r_2012_2013_e 2012 2013 836.944
r_2012_2013_i 2012_2013 2013 4256.89
c_2012_2013_i 2012 2012_2013 4.67522e-10
r_2572_2573_e 2572 2573 836.944
r_2572_2573_i 2572_2573 2573 4256.89
c_2572_2573_i 2572 2572_2573 4.67522e-10
r_3132_3133_e 3132 3133 13758.3
r_3132_3133_i 3132_3133 3133 95645.6
c_3132_3133_i 3132 3132_3133 9.36084e-12
r_3692_3693_e 3692 3693 13758.3
r_3692_3693_i 3692_3693 3693 95645.6
c_3692_3693_i 3692 3692_3693 9.36084e-12
r_333_334_e 333 334 13376.4
r_333_334_i 333_334 334 93218.1
c_333_334_i 333 333_334 2.08965e-09
r_893_894_e 893 894 13376.4
r_893_894_i 893_894 894 93218.1
c_893_894_i 893 893_894 2.08965e-09
r_1453_1454_e 1453 1454 836.944
r_1453_1454_i 1453_1454 1454 4256.89
c_1453_1454_i 1453 1453_1454 4.67522e-10
r_2013_2014_e 2013 2014 836.944
r_2013_2014_i 2013_2014 2014 4256.89
c_2013_2014_i 2013 2013_2014 4.67522e-10
r_2573_2574_e 2573 2574 836.944
r_2573_2574_i 2573_2574 2574 4256.89
c_2573_2574_i 2573 2573_2574 4.67522e-10
r_3133_3134_e 3133 3134 13758.3
r_3133_3134_i 3133_3134 3134 95645.6
c_3133_3134_i 3133 3133_3134 9.36084e-12
r_3693_3694_e 3693 3694 13758.3
r_3693_3694_i 3693_3694 3694 95645.6
c_3693_3694_i 3693 3693_3694 9.36084e-12
r_334_335_e 334 335 13376.4
r_334_335_i 334_335 335 93218.1
c_334_335_i 334 334_335 2.08965e-09
r_894_895_e 894 895 13376.4
r_894_895_i 894_895 895 93218.1
c_894_895_i 894 894_895 2.08965e-09
r_1454_1455_e 1454 1455 836.944
r_1454_1455_i 1454_1455 1455 4256.89
c_1454_1455_i 1454 1454_1455 4.67522e-10
r_2014_2015_e 2014 2015 836.944
r_2014_2015_i 2014_2015 2015 4256.89
c_2014_2015_i 2014 2014_2015 4.67522e-10
r_2574_2575_e 2574 2575 836.944
r_2574_2575_i 2574_2575 2575 4256.89
c_2574_2575_i 2574 2574_2575 4.67522e-10
r_3134_3135_e 3134 3135 13758.3
r_3134_3135_i 3134_3135 3135 95645.6
c_3134_3135_i 3134 3134_3135 9.36084e-12
r_3694_3695_e 3694 3695 13758.3
r_3694_3695_i 3694_3695 3695 95645.6
c_3694_3695_i 3694 3694_3695 9.36084e-12
r_335_336_e 335 336 13376.4
r_335_336_i 335_336 336 93218.1
c_335_336_i 335 335_336 2.08965e-09
r_895_896_e 895 896 13376.4
r_895_896_i 895_896 896 93218.1
c_895_896_i 895 895_896 2.08965e-09
r_1455_1456_e 1455 1456 836.944
r_1455_1456_i 1455_1456 1456 4256.89
c_1455_1456_i 1455 1455_1456 4.67522e-10
r_2015_2016_e 2015 2016 836.944
r_2015_2016_i 2015_2016 2016 4256.89
c_2015_2016_i 2015 2015_2016 4.67522e-10
r_2575_2576_e 2575 2576 836.944
r_2575_2576_i 2575_2576 2576 4256.89
c_2575_2576_i 2575 2575_2576 4.67522e-10
r_3135_3136_e 3135 3136 13758.3
r_3135_3136_i 3135_3136 3136 95645.6
c_3135_3136_i 3135 3135_3136 9.36084e-12
r_3695_3696_e 3695 3696 13758.3
r_3695_3696_i 3695_3696 3696 95645.6
c_3695_3696_i 3695 3695_3696 9.36084e-12
r_337_338_e 337 338 13376.4
r_337_338_i 337_338 338 93218.1
c_337_338_i 337 337_338 2.08965e-09
r_897_898_e 897 898 13376.4
r_897_898_i 897_898 898 93218.1
c_897_898_i 897 897_898 2.08965e-09
r_1457_1458_e 1457 1458 13376.4
r_1457_1458_i 1457_1458 1458 93218.1
c_1457_1458_i 1457 1457_1458 2.08965e-09
r_2017_2018_e 2017 2018 13376.4
r_2017_2018_i 2017_2018 2018 93218.1
c_2017_2018_i 2017 2017_2018 2.08965e-09
r_2577_2578_e 2577 2578 13376.4
r_2577_2578_i 2577_2578 2578 93218.1
c_2577_2578_i 2577 2577_2578 2.08965e-09
r_3137_3138_e 3137 3138 13376.4
r_3137_3138_i 3137_3138 3138 93218.1
c_3137_3138_i 3137 3137_3138 2.08965e-09
r_3697_3698_e 3697 3698 13376.4
r_3697_3698_i 3697_3698 3698 93218.1
c_3697_3698_i 3697 3697_3698 2.08965e-09
r_338_339_e 338 339 13376.4
r_338_339_i 338_339 339 93218.1
c_338_339_i 338 338_339 2.08965e-09
r_898_899_e 898 899 13376.4
r_898_899_i 898_899 899 93218.1
c_898_899_i 898 898_899 2.08965e-09
r_1458_1459_e 1458 1459 13376.4
r_1458_1459_i 1458_1459 1459 93218.1
c_1458_1459_i 1458 1458_1459 2.08965e-09
r_2018_2019_e 2018 2019 13376.4
r_2018_2019_i 2018_2019 2019 93218.1
c_2018_2019_i 2018 2018_2019 2.08965e-09
r_2578_2579_e 2578 2579 13376.4
r_2578_2579_i 2578_2579 2579 93218.1
c_2578_2579_i 2578 2578_2579 2.08965e-09
r_3138_3139_e 3138 3139 13376.4
r_3138_3139_i 3138_3139 3139 93218.1
c_3138_3139_i 3138 3138_3139 2.08965e-09
r_3698_3699_e 3698 3699 13376.4
r_3698_3699_i 3698_3699 3699 93218.1
c_3698_3699_i 3698 3698_3699 2.08965e-09
r_339_340_e 339 340 13376.4
r_339_340_i 339_340 340 93218.1
c_339_340_i 339 339_340 2.08965e-09
r_899_900_e 899 900 13376.4
r_899_900_i 899_900 900 93218.1
c_899_900_i 899 899_900 2.08965e-09
r_1459_1460_e 1459 1460 836.944
r_1459_1460_i 1459_1460 1460 4256.89
c_1459_1460_i 1459 1459_1460 4.67522e-10
r_2019_2020_e 2019 2020 836.944
r_2019_2020_i 2019_2020 2020 4256.89
c_2019_2020_i 2019 2019_2020 4.67522e-10
r_2579_2580_e 2579 2580 836.944
r_2579_2580_i 2579_2580 2580 4256.89
c_2579_2580_i 2579 2579_2580 4.67522e-10
r_3139_3140_e 3139 3140 836.944
r_3139_3140_i 3139_3140 3140 4256.89
c_3139_3140_i 3139 3139_3140 4.67522e-10
r_3699_3700_e 3699 3700 836.944
r_3699_3700_i 3699_3700 3700 4256.89
c_3699_3700_i 3699 3699_3700 4.67522e-10
r_340_341_e 340 341 13376.4
r_340_341_i 340_341 341 93218.1
c_340_341_i 340 340_341 2.08965e-09
r_900_901_e 900 901 13376.4
r_900_901_i 900_901 901 93218.1
c_900_901_i 900 900_901 2.08965e-09
r_1460_1461_e 1460 1461 836.944
r_1460_1461_i 1460_1461 1461 4256.89
c_1460_1461_i 1460 1460_1461 4.67522e-10
r_2020_2021_e 2020 2021 836.944
r_2020_2021_i 2020_2021 2021 4256.89
c_2020_2021_i 2020 2020_2021 4.67522e-10
r_2580_2581_e 2580 2581 836.944
r_2580_2581_i 2580_2581 2581 4256.89
c_2580_2581_i 2580 2580_2581 4.67522e-10
r_3140_3141_e 3140 3141 13758.3
r_3140_3141_i 3140_3141 3141 95645.6
c_3140_3141_i 3140 3140_3141 9.36084e-12
r_3700_3701_e 3700 3701 13758.3
r_3700_3701_i 3700_3701 3701 95645.6
c_3700_3701_i 3700 3700_3701 9.36084e-12
r_341_342_e 341 342 13376.4
r_341_342_i 341_342 342 93218.1
c_341_342_i 341 341_342 2.08965e-09
r_901_902_e 901 902 13376.4
r_901_902_i 901_902 902 93218.1
c_901_902_i 901 901_902 2.08965e-09
r_1461_1462_e 1461 1462 836.944
r_1461_1462_i 1461_1462 1462 4256.89
c_1461_1462_i 1461 1461_1462 4.67522e-10
r_2021_2022_e 2021 2022 836.944
r_2021_2022_i 2021_2022 2022 4256.89
c_2021_2022_i 2021 2021_2022 4.67522e-10
r_2581_2582_e 2581 2582 836.944
r_2581_2582_i 2581_2582 2582 4256.89
c_2581_2582_i 2581 2581_2582 4.67522e-10
r_3141_3142_e 3141 3142 13758.3
r_3141_3142_i 3141_3142 3142 95645.6
c_3141_3142_i 3141 3141_3142 9.36084e-12
r_3701_3702_e 3701 3702 13758.3
r_3701_3702_i 3701_3702 3702 95645.6
c_3701_3702_i 3701 3701_3702 9.36084e-12
r_342_343_e 342 343 13376.4
r_342_343_i 342_343 343 93218.1
c_342_343_i 342 342_343 2.08965e-09
r_902_903_e 902 903 13376.4
r_902_903_i 902_903 903 93218.1
c_902_903_i 902 902_903 2.08965e-09
r_1462_1463_e 1462 1463 836.944
r_1462_1463_i 1462_1463 1463 4256.89
c_1462_1463_i 1462 1462_1463 4.67522e-10
r_2022_2023_e 2022 2023 836.944
r_2022_2023_i 2022_2023 2023 4256.89
c_2022_2023_i 2022 2022_2023 4.67522e-10
r_2582_2583_e 2582 2583 836.944
r_2582_2583_i 2582_2583 2583 4256.89
c_2582_2583_i 2582 2582_2583 4.67522e-10
r_3142_3143_e 3142 3143 13758.3
r_3142_3143_i 3142_3143 3143 95645.6
c_3142_3143_i 3142 3142_3143 9.36084e-12
r_3702_3703_e 3702 3703 13758.3
r_3702_3703_i 3702_3703 3703 95645.6
c_3702_3703_i 3702 3702_3703 9.36084e-12
r_343_344_e 343 344 13376.4
r_343_344_i 343_344 344 93218.1
c_343_344_i 343 343_344 2.08965e-09
r_903_904_e 903 904 13376.4
r_903_904_i 903_904 904 93218.1
c_903_904_i 903 903_904 2.08965e-09
r_1463_1464_e 1463 1464 836.944
r_1463_1464_i 1463_1464 1464 4256.89
c_1463_1464_i 1463 1463_1464 4.67522e-10
r_2023_2024_e 2023 2024 836.944
r_2023_2024_i 2023_2024 2024 4256.89
c_2023_2024_i 2023 2023_2024 4.67522e-10
r_2583_2584_e 2583 2584 836.944
r_2583_2584_i 2583_2584 2584 4256.89
c_2583_2584_i 2583 2583_2584 4.67522e-10
r_3143_3144_e 3143 3144 13758.3
r_3143_3144_i 3143_3144 3144 95645.6
c_3143_3144_i 3143 3143_3144 9.36084e-12
r_3703_3704_e 3703 3704 13758.3
r_3703_3704_i 3703_3704 3704 95645.6
c_3703_3704_i 3703 3703_3704 9.36084e-12
r_344_345_e 344 345 13376.4
r_344_345_i 344_345 345 93218.1
c_344_345_i 344 344_345 2.08965e-09
r_904_905_e 904 905 13376.4
r_904_905_i 904_905 905 93218.1
c_904_905_i 904 904_905 2.08965e-09
r_1464_1465_e 1464 1465 836.944
r_1464_1465_i 1464_1465 1465 4256.89
c_1464_1465_i 1464 1464_1465 4.67522e-10
r_2024_2025_e 2024 2025 836.944
r_2024_2025_i 2024_2025 2025 4256.89
c_2024_2025_i 2024 2024_2025 4.67522e-10
r_2584_2585_e 2584 2585 836.944
r_2584_2585_i 2584_2585 2585 4256.89
c_2584_2585_i 2584 2584_2585 4.67522e-10
r_3144_3145_e 3144 3145 13758.3
r_3144_3145_i 3144_3145 3145 95645.6
c_3144_3145_i 3144 3144_3145 9.36084e-12
r_3704_3705_e 3704 3705 13758.3
r_3704_3705_i 3704_3705 3705 95645.6
c_3704_3705_i 3704 3704_3705 9.36084e-12
r_345_346_e 345 346 13376.4
r_345_346_i 345_346 346 93218.1
c_345_346_i 345 345_346 2.08965e-09
r_905_906_e 905 906 13376.4
r_905_906_i 905_906 906 93218.1
c_905_906_i 905 905_906 2.08965e-09
r_1465_1466_e 1465 1466 836.944
r_1465_1466_i 1465_1466 1466 4256.89
c_1465_1466_i 1465 1465_1466 4.67522e-10
r_2025_2026_e 2025 2026 836.944
r_2025_2026_i 2025_2026 2026 4256.89
c_2025_2026_i 2025 2025_2026 4.67522e-10
r_2585_2586_e 2585 2586 836.944
r_2585_2586_i 2585_2586 2586 4256.89
c_2585_2586_i 2585 2585_2586 4.67522e-10
r_3145_3146_e 3145 3146 13758.3
r_3145_3146_i 3145_3146 3146 95645.6
c_3145_3146_i 3145 3145_3146 9.36084e-12
r_3705_3706_e 3705 3706 13758.3
r_3705_3706_i 3705_3706 3706 95645.6
c_3705_3706_i 3705 3705_3706 9.36084e-12
r_346_347_e 346 347 13376.4
r_346_347_i 346_347 347 93218.1
c_346_347_i 346 346_347 2.08965e-09
r_906_907_e 906 907 13376.4
r_906_907_i 906_907 907 93218.1
c_906_907_i 906 906_907 2.08965e-09
r_1466_1467_e 1466 1467 836.944
r_1466_1467_i 1466_1467 1467 4256.89
c_1466_1467_i 1466 1466_1467 4.67522e-10
r_2026_2027_e 2026 2027 836.944
r_2026_2027_i 2026_2027 2027 4256.89
c_2026_2027_i 2026 2026_2027 4.67522e-10
r_2586_2587_e 2586 2587 836.944
r_2586_2587_i 2586_2587 2587 4256.89
c_2586_2587_i 2586 2586_2587 4.67522e-10
r_3146_3147_e 3146 3147 13758.3
r_3146_3147_i 3146_3147 3147 95645.6
c_3146_3147_i 3146 3146_3147 9.36084e-12
r_3706_3707_e 3706 3707 13758.3
r_3706_3707_i 3706_3707 3707 95645.6
c_3706_3707_i 3706 3706_3707 9.36084e-12
r_347_348_e 347 348 13376.4
r_347_348_i 347_348 348 93218.1
c_347_348_i 347 347_348 2.08965e-09
r_907_908_e 907 908 396.593
r_907_908_i 907_908 908 1005.01
c_907_908_i 907 907_908 1.65838e-10
r_1467_1468_e 1467 1468 396.593
r_1467_1468_i 1467_1468 1468 1005.01
c_1467_1468_i 1467 1467_1468 1.65838e-10
r_2027_2028_e 2027 2028 836.944
r_2027_2028_i 2027_2028 2028 4256.89
c_2027_2028_i 2027 2027_2028 4.67522e-10
r_2587_2588_e 2587 2588 836.944
r_2587_2588_i 2587_2588 2588 4256.89
c_2587_2588_i 2587 2587_2588 4.67522e-10
r_3147_3148_e 3147 3148 13758.3
r_3147_3148_i 3147_3148 3148 95645.6
c_3147_3148_i 3147 3147_3148 9.36084e-12
r_3707_3708_e 3707 3708 13758.3
r_3707_3708_i 3707_3708 3708 95645.6
c_3707_3708_i 3707 3707_3708 9.36084e-12
r_348_349_e 348 349 13376.4
r_348_349_i 348_349 349 93218.1
c_348_349_i 348 348_349 2.08965e-09
r_908_909_e 908 909 13376.4
r_908_909_i 908_909 909 93218.1
c_908_909_i 908 908_909 2.08965e-09
r_1468_1469_e 1468 1469 836.944
r_1468_1469_i 1468_1469 1469 4256.89
c_1468_1469_i 1468 1468_1469 4.67522e-10
r_2028_2029_e 2028 2029 836.944
r_2028_2029_i 2028_2029 2029 4256.89
c_2028_2029_i 2028 2028_2029 4.67522e-10
r_2588_2589_e 2588 2589 836.944
r_2588_2589_i 2588_2589 2589 4256.89
c_2588_2589_i 2588 2588_2589 4.67522e-10
r_3148_3149_e 3148 3149 13758.3
r_3148_3149_i 3148_3149 3149 95645.6
c_3148_3149_i 3148 3148_3149 9.36084e-12
r_3708_3709_e 3708 3709 13758.3
r_3708_3709_i 3708_3709 3709 95645.6
c_3708_3709_i 3708 3708_3709 9.36084e-12
r_349_350_e 349 350 13376.4
r_349_350_i 349_350 350 93218.1
c_349_350_i 349 349_350 2.08965e-09
r_909_910_e 909 910 13376.4
r_909_910_i 909_910 910 93218.1
c_909_910_i 909 909_910 2.08965e-09
r_1469_1470_e 1469 1470 836.944
r_1469_1470_i 1469_1470 1470 4256.89
c_1469_1470_i 1469 1469_1470 4.67522e-10
r_2029_2030_e 2029 2030 836.944
r_2029_2030_i 2029_2030 2030 4256.89
c_2029_2030_i 2029 2029_2030 4.67522e-10
r_2589_2590_e 2589 2590 836.944
r_2589_2590_i 2589_2590 2590 4256.89
c_2589_2590_i 2589 2589_2590 4.67522e-10
r_3149_3150_e 3149 3150 13758.3
r_3149_3150_i 3149_3150 3150 95645.6
c_3149_3150_i 3149 3149_3150 9.36084e-12
r_3709_3710_e 3709 3710 13758.3
r_3709_3710_i 3709_3710 3710 95645.6
c_3709_3710_i 3709 3709_3710 9.36084e-12
r_350_351_e 350 351 13376.4
r_350_351_i 350_351 351 93218.1
c_350_351_i 350 350_351 2.08965e-09
r_910_911_e 910 911 13376.4
r_910_911_i 910_911 911 93218.1
c_910_911_i 910 910_911 2.08965e-09
r_1470_1471_e 1470 1471 836.944
r_1470_1471_i 1470_1471 1471 4256.89
c_1470_1471_i 1470 1470_1471 4.67522e-10
r_2030_2031_e 2030 2031 836.944
r_2030_2031_i 2030_2031 2031 4256.89
c_2030_2031_i 2030 2030_2031 4.67522e-10
r_2590_2591_e 2590 2591 836.944
r_2590_2591_i 2590_2591 2591 4256.89
c_2590_2591_i 2590 2590_2591 4.67522e-10
r_3150_3151_e 3150 3151 13758.3
r_3150_3151_i 3150_3151 3151 95645.6
c_3150_3151_i 3150 3150_3151 9.36084e-12
r_3710_3711_e 3710 3711 13758.3
r_3710_3711_i 3710_3711 3711 95645.6
c_3710_3711_i 3710 3710_3711 9.36084e-12
r_351_352_e 351 352 13376.4
r_351_352_i 351_352 352 93218.1
c_351_352_i 351 351_352 2.08965e-09
r_911_912_e 911 912 13376.4
r_911_912_i 911_912 912 93218.1
c_911_912_i 911 911_912 2.08965e-09
r_1471_1472_e 1471 1472 836.944
r_1471_1472_i 1471_1472 1472 4256.89
c_1471_1472_i 1471 1471_1472 4.67522e-10
r_2031_2032_e 2031 2032 836.944
r_2031_2032_i 2031_2032 2032 4256.89
c_2031_2032_i 2031 2031_2032 4.67522e-10
r_2591_2592_e 2591 2592 836.944
r_2591_2592_i 2591_2592 2592 4256.89
c_2591_2592_i 2591 2591_2592 4.67522e-10
r_3151_3152_e 3151 3152 13758.3
r_3151_3152_i 3151_3152 3152 95645.6
c_3151_3152_i 3151 3151_3152 9.36084e-12
r_3711_3712_e 3711 3712 13758.3
r_3711_3712_i 3711_3712 3712 95645.6
c_3711_3712_i 3711 3711_3712 9.36084e-12
r_353_354_e 353 354 13376.4
r_353_354_i 353_354 354 93218.1
c_353_354_i 353 353_354 2.08965e-09
r_913_914_e 913 914 13376.4
r_913_914_i 913_914 914 93218.1
c_913_914_i 913 913_914 2.08965e-09
r_1473_1474_e 1473 1474 13376.4
r_1473_1474_i 1473_1474 1474 93218.1
c_1473_1474_i 1473 1473_1474 2.08965e-09
r_2033_2034_e 2033 2034 13376.4
r_2033_2034_i 2033_2034 2034 93218.1
c_2033_2034_i 2033 2033_2034 2.08965e-09
r_2593_2594_e 2593 2594 13376.4
r_2593_2594_i 2593_2594 2594 93218.1
c_2593_2594_i 2593 2593_2594 2.08965e-09
r_3153_3154_e 3153 3154 13376.4
r_3153_3154_i 3153_3154 3154 93218.1
c_3153_3154_i 3153 3153_3154 2.08965e-09
r_3713_3714_e 3713 3714 13376.4
r_3713_3714_i 3713_3714 3714 93218.1
c_3713_3714_i 3713 3713_3714 2.08965e-09
r_354_355_e 354 355 13376.4
r_354_355_i 354_355 355 93218.1
c_354_355_i 354 354_355 2.08965e-09
r_914_915_e 914 915 13376.4
r_914_915_i 914_915 915 93218.1
c_914_915_i 914 914_915 2.08965e-09
r_1474_1475_e 1474 1475 13376.4
r_1474_1475_i 1474_1475 1475 93218.1
c_1474_1475_i 1474 1474_1475 2.08965e-09
r_2034_2035_e 2034 2035 13376.4
r_2034_2035_i 2034_2035 2035 93218.1
c_2034_2035_i 2034 2034_2035 2.08965e-09
r_2594_2595_e 2594 2595 13376.4
r_2594_2595_i 2594_2595 2595 93218.1
c_2594_2595_i 2594 2594_2595 2.08965e-09
r_3154_3155_e 3154 3155 13376.4
r_3154_3155_i 3154_3155 3155 93218.1
c_3154_3155_i 3154 3154_3155 2.08965e-09
r_3714_3715_e 3714 3715 13376.4
r_3714_3715_i 3714_3715 3715 93218.1
c_3714_3715_i 3714 3714_3715 2.08965e-09
r_355_356_e 355 356 13376.4
r_355_356_i 355_356 356 93218.1
c_355_356_i 355 355_356 2.08965e-09
r_915_916_e 915 916 13376.4
r_915_916_i 915_916 916 93218.1
c_915_916_i 915 915_916 2.08965e-09
r_1475_1476_e 1475 1476 836.944
r_1475_1476_i 1475_1476 1476 4256.89
c_1475_1476_i 1475 1475_1476 4.67522e-10
r_2035_2036_e 2035 2036 836.944
r_2035_2036_i 2035_2036 2036 4256.89
c_2035_2036_i 2035 2035_2036 4.67522e-10
r_2595_2596_e 2595 2596 836.944
r_2595_2596_i 2595_2596 2596 4256.89
c_2595_2596_i 2595 2595_2596 4.67522e-10
r_3155_3156_e 3155 3156 836.944
r_3155_3156_i 3155_3156 3156 4256.89
c_3155_3156_i 3155 3155_3156 4.67522e-10
r_3715_3716_e 3715 3716 836.944
r_3715_3716_i 3715_3716 3716 4256.89
c_3715_3716_i 3715 3715_3716 4.67522e-10
r_356_357_e 356 357 13376.4
r_356_357_i 356_357 357 93218.1
c_356_357_i 356 356_357 2.08965e-09
r_916_917_e 916 917 13376.4
r_916_917_i 916_917 917 93218.1
c_916_917_i 916 916_917 2.08965e-09
r_1476_1477_e 1476 1477 836.944
r_1476_1477_i 1476_1477 1477 4256.89
c_1476_1477_i 1476 1476_1477 4.67522e-10
r_2036_2037_e 2036 2037 836.944
r_2036_2037_i 2036_2037 2037 4256.89
c_2036_2037_i 2036 2036_2037 4.67522e-10
r_2596_2597_e 2596 2597 836.944
r_2596_2597_i 2596_2597 2597 4256.89
c_2596_2597_i 2596 2596_2597 4.67522e-10
r_3156_3157_e 3156 3157 13758.3
r_3156_3157_i 3156_3157 3157 95645.6
c_3156_3157_i 3156 3156_3157 9.36084e-12
r_3716_3717_e 3716 3717 13758.3
r_3716_3717_i 3716_3717 3717 95645.6
c_3716_3717_i 3716 3716_3717 9.36084e-12
r_357_358_e 357 358 13376.4
r_357_358_i 357_358 358 93218.1
c_357_358_i 357 357_358 2.08965e-09
r_917_918_e 917 918 13376.4
r_917_918_i 917_918 918 93218.1
c_917_918_i 917 917_918 2.08965e-09
r_1477_1478_e 1477 1478 836.944
r_1477_1478_i 1477_1478 1478 4256.89
c_1477_1478_i 1477 1477_1478 4.67522e-10
r_2037_2038_e 2037 2038 836.944
r_2037_2038_i 2037_2038 2038 4256.89
c_2037_2038_i 2037 2037_2038 4.67522e-10
r_2597_2598_e 2597 2598 836.944
r_2597_2598_i 2597_2598 2598 4256.89
c_2597_2598_i 2597 2597_2598 4.67522e-10
r_3157_3158_e 3157 3158 13758.3
r_3157_3158_i 3157_3158 3158 95645.6
c_3157_3158_i 3157 3157_3158 9.36084e-12
r_3717_3718_e 3717 3718 13758.3
r_3717_3718_i 3717_3718 3718 95645.6
c_3717_3718_i 3717 3717_3718 9.36084e-12
r_358_359_e 358 359 13376.4
r_358_359_i 358_359 359 93218.1
c_358_359_i 358 358_359 2.08965e-09
r_918_919_e 918 919 13376.4
r_918_919_i 918_919 919 93218.1
c_918_919_i 918 918_919 2.08965e-09
r_1478_1479_e 1478 1479 836.944
r_1478_1479_i 1478_1479 1479 4256.89
c_1478_1479_i 1478 1478_1479 4.67522e-10
r_2038_2039_e 2038 2039 836.944
r_2038_2039_i 2038_2039 2039 4256.89
c_2038_2039_i 2038 2038_2039 4.67522e-10
r_2598_2599_e 2598 2599 836.944
r_2598_2599_i 2598_2599 2599 4256.89
c_2598_2599_i 2598 2598_2599 4.67522e-10
r_3158_3159_e 3158 3159 13758.3
r_3158_3159_i 3158_3159 3159 95645.6
c_3158_3159_i 3158 3158_3159 9.36084e-12
r_3718_3719_e 3718 3719 13758.3
r_3718_3719_i 3718_3719 3719 95645.6
c_3718_3719_i 3718 3718_3719 9.36084e-12
r_359_360_e 359 360 13376.4
r_359_360_i 359_360 360 93218.1
c_359_360_i 359 359_360 2.08965e-09
r_919_920_e 919 920 13376.4
r_919_920_i 919_920 920 93218.1
c_919_920_i 919 919_920 2.08965e-09
r_1479_1480_e 1479 1480 836.944
r_1479_1480_i 1479_1480 1480 4256.89
c_1479_1480_i 1479 1479_1480 4.67522e-10
r_2039_2040_e 2039 2040 836.944
r_2039_2040_i 2039_2040 2040 4256.89
c_2039_2040_i 2039 2039_2040 4.67522e-10
r_2599_2600_e 2599 2600 836.944
r_2599_2600_i 2599_2600 2600 4256.89
c_2599_2600_i 2599 2599_2600 4.67522e-10
r_3159_3160_e 3159 3160 13758.3
r_3159_3160_i 3159_3160 3160 95645.6
c_3159_3160_i 3159 3159_3160 9.36084e-12
r_3719_3720_e 3719 3720 13758.3
r_3719_3720_i 3719_3720 3720 95645.6
c_3719_3720_i 3719 3719_3720 9.36084e-12
r_360_361_e 360 361 13376.4
r_360_361_i 360_361 361 93218.1
c_360_361_i 360 360_361 2.08965e-09
r_920_921_e 920 921 13376.4
r_920_921_i 920_921 921 93218.1
c_920_921_i 920 920_921 2.08965e-09
r_1480_1481_e 1480 1481 836.944
r_1480_1481_i 1480_1481 1481 4256.89
c_1480_1481_i 1480 1480_1481 4.67522e-10
r_2040_2041_e 2040 2041 836.944
r_2040_2041_i 2040_2041 2041 4256.89
c_2040_2041_i 2040 2040_2041 4.67522e-10
r_2600_2601_e 2600 2601 836.944
r_2600_2601_i 2600_2601 2601 4256.89
c_2600_2601_i 2600 2600_2601 4.67522e-10
r_3160_3161_e 3160 3161 13758.3
r_3160_3161_i 3160_3161 3161 95645.6
c_3160_3161_i 3160 3160_3161 9.36084e-12
r_3720_3721_e 3720 3721 13758.3
r_3720_3721_i 3720_3721 3721 95645.6
c_3720_3721_i 3720 3720_3721 9.36084e-12
r_361_362_e 361 362 13376.4
r_361_362_i 361_362 362 93218.1
c_361_362_i 361 361_362 2.08965e-09
r_921_922_e 921 922 13376.4
r_921_922_i 921_922 922 93218.1
c_921_922_i 921 921_922 2.08965e-09
r_1481_1482_e 1481 1482 836.944
r_1481_1482_i 1481_1482 1482 4256.89
c_1481_1482_i 1481 1481_1482 4.67522e-10
r_2041_2042_e 2041 2042 836.944
r_2041_2042_i 2041_2042 2042 4256.89
c_2041_2042_i 2041 2041_2042 4.67522e-10
r_2601_2602_e 2601 2602 836.944
r_2601_2602_i 2601_2602 2602 4256.89
c_2601_2602_i 2601 2601_2602 4.67522e-10
r_3161_3162_e 3161 3162 13758.3
r_3161_3162_i 3161_3162 3162 95645.6
c_3161_3162_i 3161 3161_3162 9.36084e-12
r_3721_3722_e 3721 3722 13758.3
r_3721_3722_i 3721_3722 3722 95645.6
c_3721_3722_i 3721 3721_3722 9.36084e-12
r_362_363_e 362 363 13376.4
r_362_363_i 362_363 363 93218.1
c_362_363_i 362 362_363 2.08965e-09
r_922_923_e 922 923 13376.4
r_922_923_i 922_923 923 93218.1
c_922_923_i 922 922_923 2.08965e-09
r_1482_1483_e 1482 1483 836.944
r_1482_1483_i 1482_1483 1483 4256.89
c_1482_1483_i 1482 1482_1483 4.67522e-10
r_2042_2043_e 2042 2043 836.944
r_2042_2043_i 2042_2043 2043 4256.89
c_2042_2043_i 2042 2042_2043 4.67522e-10
r_2602_2603_e 2602 2603 836.944
r_2602_2603_i 2602_2603 2603 4256.89
c_2602_2603_i 2602 2602_2603 4.67522e-10
r_3162_3163_e 3162 3163 13758.3
r_3162_3163_i 3162_3163 3163 95645.6
c_3162_3163_i 3162 3162_3163 9.36084e-12
r_3722_3723_e 3722 3723 13758.3
r_3722_3723_i 3722_3723 3723 95645.6
c_3722_3723_i 3722 3722_3723 9.36084e-12
r_363_364_e 363 364 13376.4
r_363_364_i 363_364 364 93218.1
c_363_364_i 363 363_364 2.08965e-09
r_923_924_e 923 924 396.585
r_923_924_i 923_924 924 1004.98
c_923_924_i 923 923_924 1.65842e-10
r_1483_1484_e 1483 1484 396.585
r_1483_1484_i 1483_1484 1484 1004.98
c_1483_1484_i 1483 1483_1484 1.65842e-10
r_2043_2044_e 2043 2044 836.944
r_2043_2044_i 2043_2044 2044 4256.89
c_2043_2044_i 2043 2043_2044 4.67522e-10
r_2603_2604_e 2603 2604 836.944
r_2603_2604_i 2603_2604 2604 4256.89
c_2603_2604_i 2603 2603_2604 4.67522e-10
r_3163_3164_e 3163 3164 13758.3
r_3163_3164_i 3163_3164 3164 95645.6
c_3163_3164_i 3163 3163_3164 9.36084e-12
r_3723_3724_e 3723 3724 13758.3
r_3723_3724_i 3723_3724 3724 95645.6
c_3723_3724_i 3723 3723_3724 9.36084e-12
r_364_365_e 364 365 13376.4
r_364_365_i 364_365 365 93218.1
c_364_365_i 364 364_365 2.08965e-09
r_924_925_e 924 925 13376.4
r_924_925_i 924_925 925 93218.1
c_924_925_i 924 924_925 2.08965e-09
r_1484_1485_e 1484 1485 836.944
r_1484_1485_i 1484_1485 1485 4256.89
c_1484_1485_i 1484 1484_1485 4.67522e-10
r_2044_2045_e 2044 2045 836.944
r_2044_2045_i 2044_2045 2045 4256.89
c_2044_2045_i 2044 2044_2045 4.67522e-10
r_2604_2605_e 2604 2605 836.944
r_2604_2605_i 2604_2605 2605 4256.89
c_2604_2605_i 2604 2604_2605 4.67522e-10
r_3164_3165_e 3164 3165 13758.3
r_3164_3165_i 3164_3165 3165 95645.6
c_3164_3165_i 3164 3164_3165 9.36084e-12
r_3724_3725_e 3724 3725 13758.3
r_3724_3725_i 3724_3725 3725 95645.6
c_3724_3725_i 3724 3724_3725 9.36084e-12
r_365_366_e 365 366 13376.4
r_365_366_i 365_366 366 93218.1
c_365_366_i 365 365_366 2.08965e-09
r_925_926_e 925 926 13376.4
r_925_926_i 925_926 926 93218.1
c_925_926_i 925 925_926 2.08965e-09
r_1485_1486_e 1485 1486 836.944
r_1485_1486_i 1485_1486 1486 4256.89
c_1485_1486_i 1485 1485_1486 4.67522e-10
r_2045_2046_e 2045 2046 836.944
r_2045_2046_i 2045_2046 2046 4256.89
c_2045_2046_i 2045 2045_2046 4.67522e-10
r_2605_2606_e 2605 2606 836.944
r_2605_2606_i 2605_2606 2606 4256.89
c_2605_2606_i 2605 2605_2606 4.67522e-10
r_3165_3166_e 3165 3166 13758.3
r_3165_3166_i 3165_3166 3166 95645.6
c_3165_3166_i 3165 3165_3166 9.36084e-12
r_3725_3726_e 3725 3726 13758.3
r_3725_3726_i 3725_3726 3726 95645.6
c_3725_3726_i 3725 3725_3726 9.36084e-12
r_366_367_e 366 367 13376.4
r_366_367_i 366_367 367 93218.1
c_366_367_i 366 366_367 2.08965e-09
r_926_927_e 926 927 13376.4
r_926_927_i 926_927 927 93218.1
c_926_927_i 926 926_927 2.08965e-09
r_1486_1487_e 1486 1487 836.944
r_1486_1487_i 1486_1487 1487 4256.89
c_1486_1487_i 1486 1486_1487 4.67522e-10
r_2046_2047_e 2046 2047 836.944
r_2046_2047_i 2046_2047 2047 4256.89
c_2046_2047_i 2046 2046_2047 4.67522e-10
r_2606_2607_e 2606 2607 836.944
r_2606_2607_i 2606_2607 2607 4256.89
c_2606_2607_i 2606 2606_2607 4.67522e-10
r_3166_3167_e 3166 3167 13758.3
r_3166_3167_i 3166_3167 3167 95645.6
c_3166_3167_i 3166 3166_3167 9.36084e-12
r_3726_3727_e 3726 3727 13758.3
r_3726_3727_i 3726_3727 3727 95645.6
c_3726_3727_i 3726 3726_3727 9.36084e-12
r_367_368_e 367 368 13376.4
r_367_368_i 367_368 368 93218.1
c_367_368_i 367 367_368 2.08965e-09
r_927_928_e 927 928 13376.4
r_927_928_i 927_928 928 93218.1
c_927_928_i 927 927_928 2.08965e-09
r_1487_1488_e 1487 1488 836.944
r_1487_1488_i 1487_1488 1488 4256.89
c_1487_1488_i 1487 1487_1488 4.67522e-10
r_2047_2048_e 2047 2048 836.944
r_2047_2048_i 2047_2048 2048 4256.89
c_2047_2048_i 2047 2047_2048 4.67522e-10
r_2607_2608_e 2607 2608 836.944
r_2607_2608_i 2607_2608 2608 4256.89
c_2607_2608_i 2607 2607_2608 4.67522e-10
r_3167_3168_e 3167 3168 13758.3
r_3167_3168_i 3167_3168 3168 95645.6
c_3167_3168_i 3167 3167_3168 9.36084e-12
r_3727_3728_e 3727 3728 13758.3
r_3727_3728_i 3727_3728 3728 95645.6
c_3727_3728_i 3727 3727_3728 9.36084e-12
r_369_370_e 369 370 13376.4
r_369_370_i 369_370 370 93218.1
c_369_370_i 369 369_370 2.08965e-09
r_929_930_e 929 930 13376.4
r_929_930_i 929_930 930 93218.1
c_929_930_i 929 929_930 2.08965e-09
r_1489_1490_e 1489 1490 13376.4
r_1489_1490_i 1489_1490 1490 93218.1
c_1489_1490_i 1489 1489_1490 2.08965e-09
r_2049_2050_e 2049 2050 13376.4
r_2049_2050_i 2049_2050 2050 93218.1
c_2049_2050_i 2049 2049_2050 2.08965e-09
r_2609_2610_e 2609 2610 13376.4
r_2609_2610_i 2609_2610 2610 93218.1
c_2609_2610_i 2609 2609_2610 2.08965e-09
r_3169_3170_e 3169 3170 13376.4
r_3169_3170_i 3169_3170 3170 93218.1
c_3169_3170_i 3169 3169_3170 2.08965e-09
r_3729_3730_e 3729 3730 13376.4
r_3729_3730_i 3729_3730 3730 93218.1
c_3729_3730_i 3729 3729_3730 2.08965e-09
r_370_371_e 370 371 13376.4
r_370_371_i 370_371 371 93218.1
c_370_371_i 370 370_371 2.08965e-09
r_930_931_e 930 931 13376.4
r_930_931_i 930_931 931 93218.1
c_930_931_i 930 930_931 2.08965e-09
r_1490_1491_e 1490 1491 13376.4
r_1490_1491_i 1490_1491 1491 93218.1
c_1490_1491_i 1490 1490_1491 2.08965e-09
r_2050_2051_e 2050 2051 13376.4
r_2050_2051_i 2050_2051 2051 93218.1
c_2050_2051_i 2050 2050_2051 2.08965e-09
r_2610_2611_e 2610 2611 13376.4
r_2610_2611_i 2610_2611 2611 93218.1
c_2610_2611_i 2610 2610_2611 2.08965e-09
r_3170_3171_e 3170 3171 13376.4
r_3170_3171_i 3170_3171 3171 93218.1
c_3170_3171_i 3170 3170_3171 2.08965e-09
r_3730_3731_e 3730 3731 13376.4
r_3730_3731_i 3730_3731 3731 93218.1
c_3730_3731_i 3730 3730_3731 2.08965e-09
r_371_372_e 371 372 13376.4
r_371_372_i 371_372 372 93218.1
c_371_372_i 371 371_372 2.08965e-09
r_931_932_e 931 932 13376.4
r_931_932_i 931_932 932 93218.1
c_931_932_i 931 931_932 2.08965e-09
r_1491_1492_e 1491 1492 836.944
r_1491_1492_i 1491_1492 1492 4256.89
c_1491_1492_i 1491 1491_1492 4.67522e-10
r_2051_2052_e 2051 2052 836.944
r_2051_2052_i 2051_2052 2052 4256.89
c_2051_2052_i 2051 2051_2052 4.67522e-10
r_2611_2612_e 2611 2612 836.944
r_2611_2612_i 2611_2612 2612 4256.89
c_2611_2612_i 2611 2611_2612 4.67522e-10
r_3171_3172_e 3171 3172 836.944
r_3171_3172_i 3171_3172 3172 4256.89
c_3171_3172_i 3171 3171_3172 4.67522e-10
r_3731_3732_e 3731 3732 836.944
r_3731_3732_i 3731_3732 3732 4256.89
c_3731_3732_i 3731 3731_3732 4.67522e-10
r_372_373_e 372 373 13376.4
r_372_373_i 372_373 373 93218.1
c_372_373_i 372 372_373 2.08965e-09
r_932_933_e 932 933 13376.4
r_932_933_i 932_933 933 93218.1
c_932_933_i 932 932_933 2.08965e-09
r_1492_1493_e 1492 1493 836.944
r_1492_1493_i 1492_1493 1493 4256.89
c_1492_1493_i 1492 1492_1493 4.67522e-10
r_2052_2053_e 2052 2053 836.944
r_2052_2053_i 2052_2053 2053 4256.89
c_2052_2053_i 2052 2052_2053 4.67522e-10
r_2612_2613_e 2612 2613 836.944
r_2612_2613_i 2612_2613 2613 4256.89
c_2612_2613_i 2612 2612_2613 4.67522e-10
r_3172_3173_e 3172 3173 13758.3
r_3172_3173_i 3172_3173 3173 95645.6
c_3172_3173_i 3172 3172_3173 9.36084e-12
r_3732_3733_e 3732 3733 13758.3
r_3732_3733_i 3732_3733 3733 95645.6
c_3732_3733_i 3732 3732_3733 9.36084e-12
r_373_374_e 373 374 13376.4
r_373_374_i 373_374 374 93218.1
c_373_374_i 373 373_374 2.08965e-09
r_933_934_e 933 934 13376.4
r_933_934_i 933_934 934 93218.1
c_933_934_i 933 933_934 2.08965e-09
r_1493_1494_e 1493 1494 836.944
r_1493_1494_i 1493_1494 1494 4256.89
c_1493_1494_i 1493 1493_1494 4.67522e-10
r_2053_2054_e 2053 2054 836.944
r_2053_2054_i 2053_2054 2054 4256.89
c_2053_2054_i 2053 2053_2054 4.67522e-10
r_2613_2614_e 2613 2614 836.944
r_2613_2614_i 2613_2614 2614 4256.89
c_2613_2614_i 2613 2613_2614 4.67522e-10
r_3173_3174_e 3173 3174 13758.3
r_3173_3174_i 3173_3174 3174 95645.6
c_3173_3174_i 3173 3173_3174 9.36084e-12
r_3733_3734_e 3733 3734 13758.3
r_3733_3734_i 3733_3734 3734 95645.6
c_3733_3734_i 3733 3733_3734 9.36084e-12
r_374_375_e 374 375 13376.4
r_374_375_i 374_375 375 93218.1
c_374_375_i 374 374_375 2.08965e-09
r_934_935_e 934 935 13376.4
r_934_935_i 934_935 935 93218.1
c_934_935_i 934 934_935 2.08965e-09
r_1494_1495_e 1494 1495 836.944
r_1494_1495_i 1494_1495 1495 4256.89
c_1494_1495_i 1494 1494_1495 4.67522e-10
r_2054_2055_e 2054 2055 836.944
r_2054_2055_i 2054_2055 2055 4256.89
c_2054_2055_i 2054 2054_2055 4.67522e-10
r_2614_2615_e 2614 2615 836.944
r_2614_2615_i 2614_2615 2615 4256.89
c_2614_2615_i 2614 2614_2615 4.67522e-10
r_3174_3175_e 3174 3175 13758.3
r_3174_3175_i 3174_3175 3175 95645.6
c_3174_3175_i 3174 3174_3175 9.36084e-12
r_3734_3735_e 3734 3735 13758.3
r_3734_3735_i 3734_3735 3735 95645.6
c_3734_3735_i 3734 3734_3735 9.36084e-12
r_375_376_e 375 376 13376.4
r_375_376_i 375_376 376 93218.1
c_375_376_i 375 375_376 2.08965e-09
r_935_936_e 935 936 13376.4
r_935_936_i 935_936 936 93218.1
c_935_936_i 935 935_936 2.08965e-09
r_1495_1496_e 1495 1496 836.944
r_1495_1496_i 1495_1496 1496 4256.89
c_1495_1496_i 1495 1495_1496 4.67522e-10
r_2055_2056_e 2055 2056 836.944
r_2055_2056_i 2055_2056 2056 4256.89
c_2055_2056_i 2055 2055_2056 4.67522e-10
r_2615_2616_e 2615 2616 836.944
r_2615_2616_i 2615_2616 2616 4256.89
c_2615_2616_i 2615 2615_2616 4.67522e-10
r_3175_3176_e 3175 3176 13758.3
r_3175_3176_i 3175_3176 3176 95645.6
c_3175_3176_i 3175 3175_3176 9.36084e-12
r_3735_3736_e 3735 3736 13758.3
r_3735_3736_i 3735_3736 3736 95645.6
c_3735_3736_i 3735 3735_3736 9.36084e-12
r_376_377_e 376 377 13376.4
r_376_377_i 376_377 377 93218.1
c_376_377_i 376 376_377 2.08965e-09
r_936_937_e 936 937 13376.4
r_936_937_i 936_937 937 93218.1
c_936_937_i 936 936_937 2.08965e-09
r_1496_1497_e 1496 1497 836.944
r_1496_1497_i 1496_1497 1497 4256.89
c_1496_1497_i 1496 1496_1497 4.67522e-10
r_2056_2057_e 2056 2057 836.944
r_2056_2057_i 2056_2057 2057 4256.89
c_2056_2057_i 2056 2056_2057 4.67522e-10
r_2616_2617_e 2616 2617 836.944
r_2616_2617_i 2616_2617 2617 4256.89
c_2616_2617_i 2616 2616_2617 4.67522e-10
r_3176_3177_e 3176 3177 13758.3
r_3176_3177_i 3176_3177 3177 95645.6
c_3176_3177_i 3176 3176_3177 9.36084e-12
r_3736_3737_e 3736 3737 13758.3
r_3736_3737_i 3736_3737 3737 95645.6
c_3736_3737_i 3736 3736_3737 9.36084e-12
r_377_378_e 377 378 13376.4
r_377_378_i 377_378 378 93218.1
c_377_378_i 377 377_378 2.08965e-09
r_937_938_e 937 938 13376.4
r_937_938_i 937_938 938 93218.1
c_937_938_i 937 937_938 2.08965e-09
r_1497_1498_e 1497 1498 836.944
r_1497_1498_i 1497_1498 1498 4256.89
c_1497_1498_i 1497 1497_1498 4.67522e-10
r_2057_2058_e 2057 2058 836.944
r_2057_2058_i 2057_2058 2058 4256.89
c_2057_2058_i 2057 2057_2058 4.67522e-10
r_2617_2618_e 2617 2618 836.944
r_2617_2618_i 2617_2618 2618 4256.89
c_2617_2618_i 2617 2617_2618 4.67522e-10
r_3177_3178_e 3177 3178 13758.3
r_3177_3178_i 3177_3178 3178 95645.6
c_3177_3178_i 3177 3177_3178 9.36084e-12
r_3737_3738_e 3737 3738 13758.3
r_3737_3738_i 3737_3738 3738 95645.6
c_3737_3738_i 3737 3737_3738 9.36084e-12
r_378_379_e 378 379 13376.4
r_378_379_i 378_379 379 93218.1
c_378_379_i 378 378_379 2.08965e-09
r_938_939_e 938 939 13376.4
r_938_939_i 938_939 939 93218.1
c_938_939_i 938 938_939 2.08965e-09
r_1498_1499_e 1498 1499 836.944
r_1498_1499_i 1498_1499 1499 4256.89
c_1498_1499_i 1498 1498_1499 4.67522e-10
r_2058_2059_e 2058 2059 836.944
r_2058_2059_i 2058_2059 2059 4256.89
c_2058_2059_i 2058 2058_2059 4.67522e-10
r_2618_2619_e 2618 2619 836.944
r_2618_2619_i 2618_2619 2619 4256.89
c_2618_2619_i 2618 2618_2619 4.67522e-10
r_3178_3179_e 3178 3179 13758.3
r_3178_3179_i 3178_3179 3179 95645.6
c_3178_3179_i 3178 3178_3179 9.36084e-12
r_3738_3739_e 3738 3739 13758.3
r_3738_3739_i 3738_3739 3739 95645.6
c_3738_3739_i 3738 3738_3739 9.36084e-12
r_379_380_e 379 380 13376.4
r_379_380_i 379_380 380 93218.1
c_379_380_i 379 379_380 2.08965e-09
r_939_940_e 939 940 396.576
r_939_940_i 939_940 940 1004.96
c_939_940_i 939 939_940 1.65845e-10
r_1499_1500_e 1499 1500 396.576
r_1499_1500_i 1499_1500 1500 1004.96
c_1499_1500_i 1499 1499_1500 1.65845e-10
r_2059_2060_e 2059 2060 836.944
r_2059_2060_i 2059_2060 2060 4256.89
c_2059_2060_i 2059 2059_2060 4.67522e-10
r_2619_2620_e 2619 2620 836.944
r_2619_2620_i 2619_2620 2620 4256.89
c_2619_2620_i 2619 2619_2620 4.67522e-10
r_3179_3180_e 3179 3180 13758.3
r_3179_3180_i 3179_3180 3180 95645.6
c_3179_3180_i 3179 3179_3180 9.36084e-12
r_3739_3740_e 3739 3740 13758.3
r_3739_3740_i 3739_3740 3740 95645.6
c_3739_3740_i 3739 3739_3740 9.36084e-12
r_380_381_e 380 381 13376.4
r_380_381_i 380_381 381 93218.1
c_380_381_i 380 380_381 2.08965e-09
r_940_941_e 940 941 13376.4
r_940_941_i 940_941 941 93218.1
c_940_941_i 940 940_941 2.08965e-09
r_1500_1501_e 1500 1501 836.944
r_1500_1501_i 1500_1501 1501 4256.89
c_1500_1501_i 1500 1500_1501 4.67522e-10
r_2060_2061_e 2060 2061 836.944
r_2060_2061_i 2060_2061 2061 4256.89
c_2060_2061_i 2060 2060_2061 4.67522e-10
r_2620_2621_e 2620 2621 836.944
r_2620_2621_i 2620_2621 2621 4256.89
c_2620_2621_i 2620 2620_2621 4.67522e-10
r_3180_3181_e 3180 3181 13758.3
r_3180_3181_i 3180_3181 3181 95645.6
c_3180_3181_i 3180 3180_3181 9.36084e-12
r_3740_3741_e 3740 3741 13758.3
r_3740_3741_i 3740_3741 3741 95645.6
c_3740_3741_i 3740 3740_3741 9.36084e-12
r_381_382_e 381 382 13376.4
r_381_382_i 381_382 382 93218.1
c_381_382_i 381 381_382 2.08965e-09
r_941_942_e 941 942 13376.4
r_941_942_i 941_942 942 93218.1
c_941_942_i 941 941_942 2.08965e-09
r_1501_1502_e 1501 1502 836.944
r_1501_1502_i 1501_1502 1502 4256.89
c_1501_1502_i 1501 1501_1502 4.67522e-10
r_2061_2062_e 2061 2062 836.944
r_2061_2062_i 2061_2062 2062 4256.89
c_2061_2062_i 2061 2061_2062 4.67522e-10
r_2621_2622_e 2621 2622 836.944
r_2621_2622_i 2621_2622 2622 4256.89
c_2621_2622_i 2621 2621_2622 4.67522e-10
r_3181_3182_e 3181 3182 13758.3
r_3181_3182_i 3181_3182 3182 95645.6
c_3181_3182_i 3181 3181_3182 9.36084e-12
r_3741_3742_e 3741 3742 13758.3
r_3741_3742_i 3741_3742 3742 95645.6
c_3741_3742_i 3741 3741_3742 9.36084e-12
r_382_383_e 382 383 13376.4
r_382_383_i 382_383 383 93218.1
c_382_383_i 382 382_383 2.08965e-09
r_942_943_e 942 943 13376.4
r_942_943_i 942_943 943 93218.1
c_942_943_i 942 942_943 2.08965e-09
r_1502_1503_e 1502 1503 836.944
r_1502_1503_i 1502_1503 1503 4256.89
c_1502_1503_i 1502 1502_1503 4.67522e-10
r_2062_2063_e 2062 2063 836.944
r_2062_2063_i 2062_2063 2063 4256.89
c_2062_2063_i 2062 2062_2063 4.67522e-10
r_2622_2623_e 2622 2623 836.944
r_2622_2623_i 2622_2623 2623 4256.89
c_2622_2623_i 2622 2622_2623 4.67522e-10
r_3182_3183_e 3182 3183 13758.3
r_3182_3183_i 3182_3183 3183 95645.6
c_3182_3183_i 3182 3182_3183 9.36084e-12
r_3742_3743_e 3742 3743 13758.3
r_3742_3743_i 3742_3743 3743 95645.6
c_3742_3743_i 3742 3742_3743 9.36084e-12
r_383_384_e 383 384 13376.4
r_383_384_i 383_384 384 93218.1
c_383_384_i 383 383_384 2.08965e-09
r_943_944_e 943 944 13376.4
r_943_944_i 943_944 944 93218.1
c_943_944_i 943 943_944 2.08965e-09
r_1503_1504_e 1503 1504 836.944
r_1503_1504_i 1503_1504 1504 4256.89
c_1503_1504_i 1503 1503_1504 4.67522e-10
r_2063_2064_e 2063 2064 836.944
r_2063_2064_i 2063_2064 2064 4256.89
c_2063_2064_i 2063 2063_2064 4.67522e-10
r_2623_2624_e 2623 2624 836.944
r_2623_2624_i 2623_2624 2624 4256.89
c_2623_2624_i 2623 2623_2624 4.67522e-10
r_3183_3184_e 3183 3184 13758.3
r_3183_3184_i 3183_3184 3184 95645.6
c_3183_3184_i 3183 3183_3184 9.36084e-12
r_3743_3744_e 3743 3744 13758.3
r_3743_3744_i 3743_3744 3744 95645.6
c_3743_3744_i 3743 3743_3744 9.36084e-12
r_385_386_e 385 386 13376.4
r_385_386_i 385_386 386 93218.1
c_385_386_i 385 385_386 2.08965e-09
r_945_946_e 945 946 13376.4
r_945_946_i 945_946 946 93218.1
c_945_946_i 945 945_946 2.08965e-09
r_1505_1506_e 1505 1506 13376.4
r_1505_1506_i 1505_1506 1506 93218.1
c_1505_1506_i 1505 1505_1506 2.08965e-09
r_2065_2066_e 2065 2066 13376.4
r_2065_2066_i 2065_2066 2066 93218.1
c_2065_2066_i 2065 2065_2066 2.08965e-09
r_2625_2626_e 2625 2626 13376.4
r_2625_2626_i 2625_2626 2626 93218.1
c_2625_2626_i 2625 2625_2626 2.08965e-09
r_3185_3186_e 3185 3186 13376.4
r_3185_3186_i 3185_3186 3186 93218.1
c_3185_3186_i 3185 3185_3186 2.08965e-09
r_3745_3746_e 3745 3746 13376.4
r_3745_3746_i 3745_3746 3746 93218.1
c_3745_3746_i 3745 3745_3746 2.08965e-09
r_386_387_e 386 387 13376.4
r_386_387_i 386_387 387 93218.1
c_386_387_i 386 386_387 2.08965e-09
r_946_947_e 946 947 13376.4
r_946_947_i 946_947 947 93218.1
c_946_947_i 946 946_947 2.08965e-09
r_1506_1507_e 1506 1507 13376.4
r_1506_1507_i 1506_1507 1507 93218.1
c_1506_1507_i 1506 1506_1507 2.08965e-09
r_2066_2067_e 2066 2067 13376.4
r_2066_2067_i 2066_2067 2067 93218.1
c_2066_2067_i 2066 2066_2067 2.08965e-09
r_2626_2627_e 2626 2627 13376.4
r_2626_2627_i 2626_2627 2627 93218.1
c_2626_2627_i 2626 2626_2627 2.08965e-09
r_3186_3187_e 3186 3187 13376.4
r_3186_3187_i 3186_3187 3187 93218.1
c_3186_3187_i 3186 3186_3187 2.08965e-09
r_3746_3747_e 3746 3747 13376.4
r_3746_3747_i 3746_3747 3747 93218.1
c_3746_3747_i 3746 3746_3747 2.08965e-09
r_387_388_e 387 388 13376.4
r_387_388_i 387_388 388 93218.1
c_387_388_i 387 387_388 2.08965e-09
r_947_948_e 947 948 13376.4
r_947_948_i 947_948 948 93218.1
c_947_948_i 947 947_948 2.08965e-09
r_1507_1508_e 1507 1508 836.944
r_1507_1508_i 1507_1508 1508 4256.89
c_1507_1508_i 1507 1507_1508 4.67522e-10
r_2067_2068_e 2067 2068 836.944
r_2067_2068_i 2067_2068 2068 4256.89
c_2067_2068_i 2067 2067_2068 4.67522e-10
r_2627_2628_e 2627 2628 836.944
r_2627_2628_i 2627_2628 2628 4256.89
c_2627_2628_i 2627 2627_2628 4.67522e-10
r_3187_3188_e 3187 3188 836.944
r_3187_3188_i 3187_3188 3188 4256.89
c_3187_3188_i 3187 3187_3188 4.67522e-10
r_3747_3748_e 3747 3748 836.944
r_3747_3748_i 3747_3748 3748 4256.89
c_3747_3748_i 3747 3747_3748 4.67522e-10
r_388_389_e 388 389 13376.4
r_388_389_i 388_389 389 93218.1
c_388_389_i 388 388_389 2.08965e-09
r_948_949_e 948 949 13376.4
r_948_949_i 948_949 949 93218.1
c_948_949_i 948 948_949 2.08965e-09
r_1508_1509_e 1508 1509 836.944
r_1508_1509_i 1508_1509 1509 4256.89
c_1508_1509_i 1508 1508_1509 4.67522e-10
r_2068_2069_e 2068 2069 836.944
r_2068_2069_i 2068_2069 2069 4256.89
c_2068_2069_i 2068 2068_2069 4.67522e-10
r_2628_2629_e 2628 2629 836.944
r_2628_2629_i 2628_2629 2629 4256.89
c_2628_2629_i 2628 2628_2629 4.67522e-10
r_3188_3189_e 3188 3189 13758.3
r_3188_3189_i 3188_3189 3189 95645.6
c_3188_3189_i 3188 3188_3189 9.36084e-12
r_3748_3749_e 3748 3749 13758.3
r_3748_3749_i 3748_3749 3749 95645.6
c_3748_3749_i 3748 3748_3749 9.36084e-12
r_389_390_e 389 390 13376.4
r_389_390_i 389_390 390 93218.1
c_389_390_i 389 389_390 2.08965e-09
r_949_950_e 949 950 13376.4
r_949_950_i 949_950 950 93218.1
c_949_950_i 949 949_950 2.08965e-09
r_1509_1510_e 1509 1510 836.944
r_1509_1510_i 1509_1510 1510 4256.89
c_1509_1510_i 1509 1509_1510 4.67522e-10
r_2069_2070_e 2069 2070 836.944
r_2069_2070_i 2069_2070 2070 4256.89
c_2069_2070_i 2069 2069_2070 4.67522e-10
r_2629_2630_e 2629 2630 836.944
r_2629_2630_i 2629_2630 2630 4256.89
c_2629_2630_i 2629 2629_2630 4.67522e-10
r_3189_3190_e 3189 3190 13758.3
r_3189_3190_i 3189_3190 3190 95645.6
c_3189_3190_i 3189 3189_3190 9.36084e-12
r_3749_3750_e 3749 3750 13758.3
r_3749_3750_i 3749_3750 3750 95645.6
c_3749_3750_i 3749 3749_3750 9.36084e-12
r_390_391_e 390 391 13376.4
r_390_391_i 390_391 391 93218.1
c_390_391_i 390 390_391 2.08965e-09
r_950_951_e 950 951 13376.4
r_950_951_i 950_951 951 93218.1
c_950_951_i 950 950_951 2.08965e-09
r_1510_1511_e 1510 1511 836.944
r_1510_1511_i 1510_1511 1511 4256.89
c_1510_1511_i 1510 1510_1511 4.67522e-10
r_2070_2071_e 2070 2071 836.944
r_2070_2071_i 2070_2071 2071 4256.89
c_2070_2071_i 2070 2070_2071 4.67522e-10
r_2630_2631_e 2630 2631 836.944
r_2630_2631_i 2630_2631 2631 4256.89
c_2630_2631_i 2630 2630_2631 4.67522e-10
r_3190_3191_e 3190 3191 13758.3
r_3190_3191_i 3190_3191 3191 95645.6
c_3190_3191_i 3190 3190_3191 9.36084e-12
r_3750_3751_e 3750 3751 13758.3
r_3750_3751_i 3750_3751 3751 95645.6
c_3750_3751_i 3750 3750_3751 9.36084e-12
r_391_392_e 391 392 13376.4
r_391_392_i 391_392 392 93218.1
c_391_392_i 391 391_392 2.08965e-09
r_951_952_e 951 952 13376.4
r_951_952_i 951_952 952 93218.1
c_951_952_i 951 951_952 2.08965e-09
r_1511_1512_e 1511 1512 836.944
r_1511_1512_i 1511_1512 1512 4256.89
c_1511_1512_i 1511 1511_1512 4.67522e-10
r_2071_2072_e 2071 2072 836.944
r_2071_2072_i 2071_2072 2072 4256.89
c_2071_2072_i 2071 2071_2072 4.67522e-10
r_2631_2632_e 2631 2632 836.944
r_2631_2632_i 2631_2632 2632 4256.89
c_2631_2632_i 2631 2631_2632 4.67522e-10
r_3191_3192_e 3191 3192 13758.3
r_3191_3192_i 3191_3192 3192 95645.6
c_3191_3192_i 3191 3191_3192 9.36084e-12
r_3751_3752_e 3751 3752 13758.3
r_3751_3752_i 3751_3752 3752 95645.6
c_3751_3752_i 3751 3751_3752 9.36084e-12
r_392_393_e 392 393 13376.4
r_392_393_i 392_393 393 93218.1
c_392_393_i 392 392_393 2.08965e-09
r_952_953_e 952 953 13376.4
r_952_953_i 952_953 953 93218.1
c_952_953_i 952 952_953 2.08965e-09
r_1512_1513_e 1512 1513 836.944
r_1512_1513_i 1512_1513 1513 4256.89
c_1512_1513_i 1512 1512_1513 4.67522e-10
r_2072_2073_e 2072 2073 836.944
r_2072_2073_i 2072_2073 2073 4256.89
c_2072_2073_i 2072 2072_2073 4.67522e-10
r_2632_2633_e 2632 2633 836.944
r_2632_2633_i 2632_2633 2633 4256.89
c_2632_2633_i 2632 2632_2633 4.67522e-10
r_3192_3193_e 3192 3193 13758.3
r_3192_3193_i 3192_3193 3193 95645.6
c_3192_3193_i 3192 3192_3193 9.36084e-12
r_3752_3753_e 3752 3753 13758.3
r_3752_3753_i 3752_3753 3753 95645.6
c_3752_3753_i 3752 3752_3753 9.36084e-12
r_393_394_e 393 394 13376.4
r_393_394_i 393_394 394 93218.1
c_393_394_i 393 393_394 2.08965e-09
r_953_954_e 953 954 13376.4
r_953_954_i 953_954 954 93218.1
c_953_954_i 953 953_954 2.08965e-09
r_1513_1514_e 1513 1514 836.944
r_1513_1514_i 1513_1514 1514 4256.89
c_1513_1514_i 1513 1513_1514 4.67522e-10
r_2073_2074_e 2073 2074 836.944
r_2073_2074_i 2073_2074 2074 4256.89
c_2073_2074_i 2073 2073_2074 4.67522e-10
r_2633_2634_e 2633 2634 836.944
r_2633_2634_i 2633_2634 2634 4256.89
c_2633_2634_i 2633 2633_2634 4.67522e-10
r_3193_3194_e 3193 3194 13758.3
r_3193_3194_i 3193_3194 3194 95645.6
c_3193_3194_i 3193 3193_3194 9.36084e-12
r_3753_3754_e 3753 3754 13758.3
r_3753_3754_i 3753_3754 3754 95645.6
c_3753_3754_i 3753 3753_3754 9.36084e-12
r_394_395_e 394 395 13376.4
r_394_395_i 394_395 395 93218.1
c_394_395_i 394 394_395 2.08965e-09
r_954_955_e 954 955 13376.4
r_954_955_i 954_955 955 93218.1
c_954_955_i 954 954_955 2.08965e-09
r_1514_1515_e 1514 1515 836.944
r_1514_1515_i 1514_1515 1515 4256.89
c_1514_1515_i 1514 1514_1515 4.67522e-10
r_2074_2075_e 2074 2075 836.944
r_2074_2075_i 2074_2075 2075 4256.89
c_2074_2075_i 2074 2074_2075 4.67522e-10
r_2634_2635_e 2634 2635 836.944
r_2634_2635_i 2634_2635 2635 4256.89
c_2634_2635_i 2634 2634_2635 4.67522e-10
r_3194_3195_e 3194 3195 13758.3
r_3194_3195_i 3194_3195 3195 95645.6
c_3194_3195_i 3194 3194_3195 9.36084e-12
r_3754_3755_e 3754 3755 13758.3
r_3754_3755_i 3754_3755 3755 95645.6
c_3754_3755_i 3754 3754_3755 9.36084e-12
r_395_396_e 395 396 13376.4
r_395_396_i 395_396 396 93218.1
c_395_396_i 395 395_396 2.08965e-09
r_955_956_e 955 956 396.568
r_955_956_i 955_956 956 1004.94
c_955_956_i 955 955_956 1.65849e-10
r_1515_1516_e 1515 1516 396.568
r_1515_1516_i 1515_1516 1516 1004.94
c_1515_1516_i 1515 1515_1516 1.65849e-10
r_2075_2076_e 2075 2076 836.944
r_2075_2076_i 2075_2076 2076 4256.89
c_2075_2076_i 2075 2075_2076 4.67522e-10
r_2635_2636_e 2635 2636 836.944
r_2635_2636_i 2635_2636 2636 4256.89
c_2635_2636_i 2635 2635_2636 4.67522e-10
r_3195_3196_e 3195 3196 13758.3
r_3195_3196_i 3195_3196 3196 95645.6
c_3195_3196_i 3195 3195_3196 9.36084e-12
r_3755_3756_e 3755 3756 13758.3
r_3755_3756_i 3755_3756 3756 95645.6
c_3755_3756_i 3755 3755_3756 9.36084e-12
r_396_397_e 396 397 13376.4
r_396_397_i 396_397 397 93218.1
c_396_397_i 396 396_397 2.08965e-09
r_956_957_e 956 957 13376.4
r_956_957_i 956_957 957 93218.1
c_956_957_i 956 956_957 2.08965e-09
r_1516_1517_e 1516 1517 836.944
r_1516_1517_i 1516_1517 1517 4256.89
c_1516_1517_i 1516 1516_1517 4.67522e-10
r_2076_2077_e 2076 2077 836.944
r_2076_2077_i 2076_2077 2077 4256.89
c_2076_2077_i 2076 2076_2077 4.67522e-10
r_2636_2637_e 2636 2637 836.944
r_2636_2637_i 2636_2637 2637 4256.89
c_2636_2637_i 2636 2636_2637 4.67522e-10
r_3196_3197_e 3196 3197 13758.3
r_3196_3197_i 3196_3197 3197 95645.6
c_3196_3197_i 3196 3196_3197 9.36084e-12
r_3756_3757_e 3756 3757 13758.3
r_3756_3757_i 3756_3757 3757 95645.6
c_3756_3757_i 3756 3756_3757 9.36084e-12
r_397_398_e 397 398 13376.4
r_397_398_i 397_398 398 93218.1
c_397_398_i 397 397_398 2.08965e-09
r_957_958_e 957 958 13376.4
r_957_958_i 957_958 958 93218.1
c_957_958_i 957 957_958 2.08965e-09
r_1517_1518_e 1517 1518 836.944
r_1517_1518_i 1517_1518 1518 4256.89
c_1517_1518_i 1517 1517_1518 4.67522e-10
r_2077_2078_e 2077 2078 836.944
r_2077_2078_i 2077_2078 2078 4256.89
c_2077_2078_i 2077 2077_2078 4.67522e-10
r_2637_2638_e 2637 2638 836.944
r_2637_2638_i 2637_2638 2638 4256.89
c_2637_2638_i 2637 2637_2638 4.67522e-10
r_3197_3198_e 3197 3198 13758.3
r_3197_3198_i 3197_3198 3198 95645.6
c_3197_3198_i 3197 3197_3198 9.36084e-12
r_3757_3758_e 3757 3758 13758.3
r_3757_3758_i 3757_3758 3758 95645.6
c_3757_3758_i 3757 3757_3758 9.36084e-12
r_398_399_e 398 399 13376.4
r_398_399_i 398_399 399 93218.1
c_398_399_i 398 398_399 2.08965e-09
r_958_959_e 958 959 13376.4
r_958_959_i 958_959 959 93218.1
c_958_959_i 958 958_959 2.08965e-09
r_1518_1519_e 1518 1519 836.944
r_1518_1519_i 1518_1519 1519 4256.89
c_1518_1519_i 1518 1518_1519 4.67522e-10
r_2078_2079_e 2078 2079 836.944
r_2078_2079_i 2078_2079 2079 4256.89
c_2078_2079_i 2078 2078_2079 4.67522e-10
r_2638_2639_e 2638 2639 836.944
r_2638_2639_i 2638_2639 2639 4256.89
c_2638_2639_i 2638 2638_2639 4.67522e-10
r_3198_3199_e 3198 3199 13758.3
r_3198_3199_i 3198_3199 3199 95645.6
c_3198_3199_i 3198 3198_3199 9.36084e-12
r_3758_3759_e 3758 3759 13758.3
r_3758_3759_i 3758_3759 3759 95645.6
c_3758_3759_i 3758 3758_3759 9.36084e-12
r_399_400_e 399 400 13376.4
r_399_400_i 399_400 400 93218.1
c_399_400_i 399 399_400 2.08965e-09
r_959_960_e 959 960 13376.4
r_959_960_i 959_960 960 93218.1
c_959_960_i 959 959_960 2.08965e-09
r_1519_1520_e 1519 1520 836.944
r_1519_1520_i 1519_1520 1520 4256.89
c_1519_1520_i 1519 1519_1520 4.67522e-10
r_2079_2080_e 2079 2080 836.944
r_2079_2080_i 2079_2080 2080 4256.89
c_2079_2080_i 2079 2079_2080 4.67522e-10
r_2639_2640_e 2639 2640 836.944
r_2639_2640_i 2639_2640 2640 4256.89
c_2639_2640_i 2639 2639_2640 4.67522e-10
r_3199_3200_e 3199 3200 13758.3
r_3199_3200_i 3199_3200 3200 95645.6
c_3199_3200_i 3199 3199_3200 9.36084e-12
r_3759_3760_e 3759 3760 13758.3
r_3759_3760_i 3759_3760 3760 95645.6
c_3759_3760_i 3759 3759_3760 9.36084e-12
r_401_402_e 401 402 13376.4
r_401_402_i 401_402 402 93218.1
c_401_402_i 401 401_402 2.08965e-09
r_961_962_e 961 962 13376.4
r_961_962_i 961_962 962 93218.1
c_961_962_i 961 961_962 2.08965e-09
r_1521_1522_e 1521 1522 13376.4
r_1521_1522_i 1521_1522 1522 93218.1
c_1521_1522_i 1521 1521_1522 2.08965e-09
r_2081_2082_e 2081 2082 13376.4
r_2081_2082_i 2081_2082 2082 93218.1
c_2081_2082_i 2081 2081_2082 2.08965e-09
r_2641_2642_e 2641 2642 13376.4
r_2641_2642_i 2641_2642 2642 93218.1
c_2641_2642_i 2641 2641_2642 2.08965e-09
r_3201_3202_e 3201 3202 13376.4
r_3201_3202_i 3201_3202 3202 93218.1
c_3201_3202_i 3201 3201_3202 2.08965e-09
r_3761_3762_e 3761 3762 13376.4
r_3761_3762_i 3761_3762 3762 93218.1
c_3761_3762_i 3761 3761_3762 2.08965e-09
r_402_403_e 402 403 13376.4
r_402_403_i 402_403 403 93218.1
c_402_403_i 402 402_403 2.08965e-09
r_962_963_e 962 963 13376.4
r_962_963_i 962_963 963 93218.1
c_962_963_i 962 962_963 2.08965e-09
r_1522_1523_e 1522 1523 13376.4
r_1522_1523_i 1522_1523 1523 93218.1
c_1522_1523_i 1522 1522_1523 2.08965e-09
r_2082_2083_e 2082 2083 13376.4
r_2082_2083_i 2082_2083 2083 93218.1
c_2082_2083_i 2082 2082_2083 2.08965e-09
r_2642_2643_e 2642 2643 13376.4
r_2642_2643_i 2642_2643 2643 93218.1
c_2642_2643_i 2642 2642_2643 2.08965e-09
r_3202_3203_e 3202 3203 13376.4
r_3202_3203_i 3202_3203 3203 93218.1
c_3202_3203_i 3202 3202_3203 2.08965e-09
r_3762_3763_e 3762 3763 13376.4
r_3762_3763_i 3762_3763 3763 93218.1
c_3762_3763_i 3762 3762_3763 2.08965e-09
r_403_404_e 403 404 13376.4
r_403_404_i 403_404 404 93218.1
c_403_404_i 403 403_404 2.08965e-09
r_963_964_e 963 964 13376.4
r_963_964_i 963_964 964 93218.1
c_963_964_i 963 963_964 2.08965e-09
r_1523_1524_e 1523 1524 836.944
r_1523_1524_i 1523_1524 1524 4256.89
c_1523_1524_i 1523 1523_1524 4.67522e-10
r_2083_2084_e 2083 2084 836.944
r_2083_2084_i 2083_2084 2084 4256.89
c_2083_2084_i 2083 2083_2084 4.67522e-10
r_2643_2644_e 2643 2644 836.944
r_2643_2644_i 2643_2644 2644 4256.89
c_2643_2644_i 2643 2643_2644 4.67522e-10
r_3203_3204_e 3203 3204 836.944
r_3203_3204_i 3203_3204 3204 4256.89
c_3203_3204_i 3203 3203_3204 4.67522e-10
r_3763_3764_e 3763 3764 836.944
r_3763_3764_i 3763_3764 3764 4256.89
c_3763_3764_i 3763 3763_3764 4.67522e-10
r_404_405_e 404 405 13376.4
r_404_405_i 404_405 405 93218.1
c_404_405_i 404 404_405 2.08965e-09
r_964_965_e 964 965 13376.4
r_964_965_i 964_965 965 93218.1
c_964_965_i 964 964_965 2.08965e-09
r_1524_1525_e 1524 1525 836.944
r_1524_1525_i 1524_1525 1525 4256.89
c_1524_1525_i 1524 1524_1525 4.67522e-10
r_2084_2085_e 2084 2085 836.944
r_2084_2085_i 2084_2085 2085 4256.89
c_2084_2085_i 2084 2084_2085 4.67522e-10
r_2644_2645_e 2644 2645 836.944
r_2644_2645_i 2644_2645 2645 4256.89
c_2644_2645_i 2644 2644_2645 4.67522e-10
r_3204_3205_e 3204 3205 13758.3
r_3204_3205_i 3204_3205 3205 95645.6
c_3204_3205_i 3204 3204_3205 9.36084e-12
r_3764_3765_e 3764 3765 13758.3
r_3764_3765_i 3764_3765 3765 95645.6
c_3764_3765_i 3764 3764_3765 9.36084e-12
r_405_406_e 405 406 13376.4
r_405_406_i 405_406 406 93218.1
c_405_406_i 405 405_406 2.08965e-09
r_965_966_e 965 966 13376.4
r_965_966_i 965_966 966 93218.1
c_965_966_i 965 965_966 2.08965e-09
r_1525_1526_e 1525 1526 836.944
r_1525_1526_i 1525_1526 1526 4256.89
c_1525_1526_i 1525 1525_1526 4.67522e-10
r_2085_2086_e 2085 2086 836.944
r_2085_2086_i 2085_2086 2086 4256.89
c_2085_2086_i 2085 2085_2086 4.67522e-10
r_2645_2646_e 2645 2646 836.944
r_2645_2646_i 2645_2646 2646 4256.89
c_2645_2646_i 2645 2645_2646 4.67522e-10
r_3205_3206_e 3205 3206 13758.3
r_3205_3206_i 3205_3206 3206 95645.6
c_3205_3206_i 3205 3205_3206 9.36084e-12
r_3765_3766_e 3765 3766 13758.3
r_3765_3766_i 3765_3766 3766 95645.6
c_3765_3766_i 3765 3765_3766 9.36084e-12
r_406_407_e 406 407 13376.4
r_406_407_i 406_407 407 93218.1
c_406_407_i 406 406_407 2.08965e-09
r_966_967_e 966 967 13376.4
r_966_967_i 966_967 967 93218.1
c_966_967_i 966 966_967 2.08965e-09
r_1526_1527_e 1526 1527 836.944
r_1526_1527_i 1526_1527 1527 4256.89
c_1526_1527_i 1526 1526_1527 4.67522e-10
r_2086_2087_e 2086 2087 836.944
r_2086_2087_i 2086_2087 2087 4256.89
c_2086_2087_i 2086 2086_2087 4.67522e-10
r_2646_2647_e 2646 2647 836.944
r_2646_2647_i 2646_2647 2647 4256.89
c_2646_2647_i 2646 2646_2647 4.67522e-10
r_3206_3207_e 3206 3207 13758.3
r_3206_3207_i 3206_3207 3207 95645.6
c_3206_3207_i 3206 3206_3207 9.36084e-12
r_3766_3767_e 3766 3767 13758.3
r_3766_3767_i 3766_3767 3767 95645.6
c_3766_3767_i 3766 3766_3767 9.36084e-12
r_407_408_e 407 408 13376.4
r_407_408_i 407_408 408 93218.1
c_407_408_i 407 407_408 2.08965e-09
r_967_968_e 967 968 13376.4
r_967_968_i 967_968 968 93218.1
c_967_968_i 967 967_968 2.08965e-09
r_1527_1528_e 1527 1528 836.944
r_1527_1528_i 1527_1528 1528 4256.89
c_1527_1528_i 1527 1527_1528 4.67522e-10
r_2087_2088_e 2087 2088 836.944
r_2087_2088_i 2087_2088 2088 4256.89
c_2087_2088_i 2087 2087_2088 4.67522e-10
r_2647_2648_e 2647 2648 836.944
r_2647_2648_i 2647_2648 2648 4256.89
c_2647_2648_i 2647 2647_2648 4.67522e-10
r_3207_3208_e 3207 3208 13758.3
r_3207_3208_i 3207_3208 3208 95645.6
c_3207_3208_i 3207 3207_3208 9.36084e-12
r_3767_3768_e 3767 3768 13758.3
r_3767_3768_i 3767_3768 3768 95645.6
c_3767_3768_i 3767 3767_3768 9.36084e-12
r_408_409_e 408 409 13376.4
r_408_409_i 408_409 409 93218.1
c_408_409_i 408 408_409 2.08965e-09
r_968_969_e 968 969 13376.4
r_968_969_i 968_969 969 93218.1
c_968_969_i 968 968_969 2.08965e-09
r_1528_1529_e 1528 1529 836.944
r_1528_1529_i 1528_1529 1529 4256.89
c_1528_1529_i 1528 1528_1529 4.67522e-10
r_2088_2089_e 2088 2089 836.944
r_2088_2089_i 2088_2089 2089 4256.89
c_2088_2089_i 2088 2088_2089 4.67522e-10
r_2648_2649_e 2648 2649 836.944
r_2648_2649_i 2648_2649 2649 4256.89
c_2648_2649_i 2648 2648_2649 4.67522e-10
r_3208_3209_e 3208 3209 13758.3
r_3208_3209_i 3208_3209 3209 95645.6
c_3208_3209_i 3208 3208_3209 9.36084e-12
r_3768_3769_e 3768 3769 13758.3
r_3768_3769_i 3768_3769 3769 95645.6
c_3768_3769_i 3768 3768_3769 9.36084e-12
r_409_410_e 409 410 13376.4
r_409_410_i 409_410 410 93218.1
c_409_410_i 409 409_410 2.08965e-09
r_969_970_e 969 970 13376.4
r_969_970_i 969_970 970 93218.1
c_969_970_i 969 969_970 2.08965e-09
r_1529_1530_e 1529 1530 836.944
r_1529_1530_i 1529_1530 1530 4256.89
c_1529_1530_i 1529 1529_1530 4.67522e-10
r_2089_2090_e 2089 2090 836.944
r_2089_2090_i 2089_2090 2090 4256.89
c_2089_2090_i 2089 2089_2090 4.67522e-10
r_2649_2650_e 2649 2650 836.944
r_2649_2650_i 2649_2650 2650 4256.89
c_2649_2650_i 2649 2649_2650 4.67522e-10
r_3209_3210_e 3209 3210 13758.3
r_3209_3210_i 3209_3210 3210 95645.6
c_3209_3210_i 3209 3209_3210 9.36084e-12
r_3769_3770_e 3769 3770 13758.3
r_3769_3770_i 3769_3770 3770 95645.6
c_3769_3770_i 3769 3769_3770 9.36084e-12
r_410_411_e 410 411 13376.4
r_410_411_i 410_411 411 93218.1
c_410_411_i 410 410_411 2.08965e-09
r_970_971_e 970 971 13376.4
r_970_971_i 970_971 971 93218.1
c_970_971_i 970 970_971 2.08965e-09
r_1530_1531_e 1530 1531 836.944
r_1530_1531_i 1530_1531 1531 4256.89
c_1530_1531_i 1530 1530_1531 4.67522e-10
r_2090_2091_e 2090 2091 836.944
r_2090_2091_i 2090_2091 2091 4256.89
c_2090_2091_i 2090 2090_2091 4.67522e-10
r_2650_2651_e 2650 2651 836.944
r_2650_2651_i 2650_2651 2651 4256.89
c_2650_2651_i 2650 2650_2651 4.67522e-10
r_3210_3211_e 3210 3211 13758.3
r_3210_3211_i 3210_3211 3211 95645.6
c_3210_3211_i 3210 3210_3211 9.36084e-12
r_3770_3771_e 3770 3771 13758.3
r_3770_3771_i 3770_3771 3771 95645.6
c_3770_3771_i 3770 3770_3771 9.36084e-12
r_411_412_e 411 412 13376.4
r_411_412_i 411_412 412 93218.1
c_411_412_i 411 411_412 2.08965e-09
r_971_972_e 971 972 396.56
r_971_972_i 971_972 972 1004.92
c_971_972_i 971 971_972 1.65852e-10
r_1531_1532_e 1531 1532 396.56
r_1531_1532_i 1531_1532 1532 1004.92
c_1531_1532_i 1531 1531_1532 1.65852e-10
r_2091_2092_e 2091 2092 836.944
r_2091_2092_i 2091_2092 2092 4256.89
c_2091_2092_i 2091 2091_2092 4.67522e-10
r_2651_2652_e 2651 2652 836.944
r_2651_2652_i 2651_2652 2652 4256.89
c_2651_2652_i 2651 2651_2652 4.67522e-10
r_3211_3212_e 3211 3212 13758.3
r_3211_3212_i 3211_3212 3212 95645.6
c_3211_3212_i 3211 3211_3212 9.36084e-12
r_3771_3772_e 3771 3772 13758.3
r_3771_3772_i 3771_3772 3772 95645.6
c_3771_3772_i 3771 3771_3772 9.36084e-12
r_412_413_e 412 413 13376.4
r_412_413_i 412_413 413 93218.1
c_412_413_i 412 412_413 2.08965e-09
r_972_973_e 972 973 13376.4
r_972_973_i 972_973 973 93218.1
c_972_973_i 972 972_973 2.08965e-09
r_1532_1533_e 1532 1533 836.944
r_1532_1533_i 1532_1533 1533 4256.89
c_1532_1533_i 1532 1532_1533 4.67522e-10
r_2092_2093_e 2092 2093 836.944
r_2092_2093_i 2092_2093 2093 4256.89
c_2092_2093_i 2092 2092_2093 4.67522e-10
r_2652_2653_e 2652 2653 836.944
r_2652_2653_i 2652_2653 2653 4256.89
c_2652_2653_i 2652 2652_2653 4.67522e-10
r_3212_3213_e 3212 3213 13758.3
r_3212_3213_i 3212_3213 3213 95645.6
c_3212_3213_i 3212 3212_3213 9.36084e-12
r_3772_3773_e 3772 3773 13758.3
r_3772_3773_i 3772_3773 3773 95645.6
c_3772_3773_i 3772 3772_3773 9.36084e-12
r_413_414_e 413 414 13376.4
r_413_414_i 413_414 414 93218.1
c_413_414_i 413 413_414 2.08965e-09
r_973_974_e 973 974 13376.4
r_973_974_i 973_974 974 93218.1
c_973_974_i 973 973_974 2.08965e-09
r_1533_1534_e 1533 1534 836.944
r_1533_1534_i 1533_1534 1534 4256.89
c_1533_1534_i 1533 1533_1534 4.67522e-10
r_2093_2094_e 2093 2094 836.944
r_2093_2094_i 2093_2094 2094 4256.89
c_2093_2094_i 2093 2093_2094 4.67522e-10
r_2653_2654_e 2653 2654 836.944
r_2653_2654_i 2653_2654 2654 4256.89
c_2653_2654_i 2653 2653_2654 4.67522e-10
r_3213_3214_e 3213 3214 13758.3
r_3213_3214_i 3213_3214 3214 95645.6
c_3213_3214_i 3213 3213_3214 9.36084e-12
r_3773_3774_e 3773 3774 13758.3
r_3773_3774_i 3773_3774 3774 95645.6
c_3773_3774_i 3773 3773_3774 9.36084e-12
r_414_415_e 414 415 13376.4
r_414_415_i 414_415 415 93218.1
c_414_415_i 414 414_415 2.08965e-09
r_974_975_e 974 975 13376.4
r_974_975_i 974_975 975 93218.1
c_974_975_i 974 974_975 2.08965e-09
r_1534_1535_e 1534 1535 836.944
r_1534_1535_i 1534_1535 1535 4256.89
c_1534_1535_i 1534 1534_1535 4.67522e-10
r_2094_2095_e 2094 2095 836.944
r_2094_2095_i 2094_2095 2095 4256.89
c_2094_2095_i 2094 2094_2095 4.67522e-10
r_2654_2655_e 2654 2655 836.944
r_2654_2655_i 2654_2655 2655 4256.89
c_2654_2655_i 2654 2654_2655 4.67522e-10
r_3214_3215_e 3214 3215 13758.3
r_3214_3215_i 3214_3215 3215 95645.6
c_3214_3215_i 3214 3214_3215 9.36084e-12
r_3774_3775_e 3774 3775 13758.3
r_3774_3775_i 3774_3775 3775 95645.6
c_3774_3775_i 3774 3774_3775 9.36084e-12
r_415_416_e 415 416 13376.4
r_415_416_i 415_416 416 93218.1
c_415_416_i 415 415_416 2.08965e-09
r_975_976_e 975 976 13376.4
r_975_976_i 975_976 976 93218.1
c_975_976_i 975 975_976 2.08965e-09
r_1535_1536_e 1535 1536 836.944
r_1535_1536_i 1535_1536 1536 4256.89
c_1535_1536_i 1535 1535_1536 4.67522e-10
r_2095_2096_e 2095 2096 836.944
r_2095_2096_i 2095_2096 2096 4256.89
c_2095_2096_i 2095 2095_2096 4.67522e-10
r_2655_2656_e 2655 2656 836.944
r_2655_2656_i 2655_2656 2656 4256.89
c_2655_2656_i 2655 2655_2656 4.67522e-10
r_3215_3216_e 3215 3216 13758.3
r_3215_3216_i 3215_3216 3216 95645.6
c_3215_3216_i 3215 3215_3216 9.36084e-12
r_3775_3776_e 3775 3776 13758.3
r_3775_3776_i 3775_3776 3776 95645.6
c_3775_3776_i 3775 3775_3776 9.36084e-12
r_417_418_e 417 418 13376.4
r_417_418_i 417_418 418 93218.1
c_417_418_i 417 417_418 2.08965e-09
r_977_978_e 977 978 13376.4
r_977_978_i 977_978 978 93218.1
c_977_978_i 977 977_978 2.08965e-09
r_1537_1538_e 1537 1538 13376.4
r_1537_1538_i 1537_1538 1538 93218.1
c_1537_1538_i 1537 1537_1538 2.08965e-09
r_2097_2098_e 2097 2098 13376.4
r_2097_2098_i 2097_2098 2098 93218.1
c_2097_2098_i 2097 2097_2098 2.08965e-09
r_2657_2658_e 2657 2658 13376.4
r_2657_2658_i 2657_2658 2658 93218.1
c_2657_2658_i 2657 2657_2658 2.08965e-09
r_3217_3218_e 3217 3218 13376.4
r_3217_3218_i 3217_3218 3218 93218.1
c_3217_3218_i 3217 3217_3218 2.08965e-09
r_3777_3778_e 3777 3778 13376.4
r_3777_3778_i 3777_3778 3778 93218.1
c_3777_3778_i 3777 3777_3778 2.08965e-09
r_418_419_e 418 419 13376.4
r_418_419_i 418_419 419 93218.1
c_418_419_i 418 418_419 2.08965e-09
r_978_979_e 978 979 13376.4
r_978_979_i 978_979 979 93218.1
c_978_979_i 978 978_979 2.08965e-09
r_1538_1539_e 1538 1539 13376.4
r_1538_1539_i 1538_1539 1539 93218.1
c_1538_1539_i 1538 1538_1539 2.08965e-09
r_2098_2099_e 2098 2099 13376.4
r_2098_2099_i 2098_2099 2099 93218.1
c_2098_2099_i 2098 2098_2099 2.08965e-09
r_2658_2659_e 2658 2659 13376.4
r_2658_2659_i 2658_2659 2659 93218.1
c_2658_2659_i 2658 2658_2659 2.08965e-09
r_3218_3219_e 3218 3219 13376.4
r_3218_3219_i 3218_3219 3219 93218.1
c_3218_3219_i 3218 3218_3219 2.08965e-09
r_3778_3779_e 3778 3779 13376.4
r_3778_3779_i 3778_3779 3779 93218.1
c_3778_3779_i 3778 3778_3779 2.08965e-09
r_419_420_e 419 420 13376.4
r_419_420_i 419_420 420 93218.1
c_419_420_i 419 419_420 2.08965e-09
r_979_980_e 979 980 13376.4
r_979_980_i 979_980 980 93218.1
c_979_980_i 979 979_980 2.08965e-09
r_1539_1540_e 1539 1540 836.944
r_1539_1540_i 1539_1540 1540 4256.89
c_1539_1540_i 1539 1539_1540 4.67522e-10
r_2099_2100_e 2099 2100 836.944
r_2099_2100_i 2099_2100 2100 4256.89
c_2099_2100_i 2099 2099_2100 4.67522e-10
r_2659_2660_e 2659 2660 836.944
r_2659_2660_i 2659_2660 2660 4256.89
c_2659_2660_i 2659 2659_2660 4.67522e-10
r_3219_3220_e 3219 3220 836.944
r_3219_3220_i 3219_3220 3220 4256.89
c_3219_3220_i 3219 3219_3220 4.67522e-10
r_3779_3780_e 3779 3780 836.944
r_3779_3780_i 3779_3780 3780 4256.89
c_3779_3780_i 3779 3779_3780 4.67522e-10
r_420_421_e 420 421 13376.4
r_420_421_i 420_421 421 93218.1
c_420_421_i 420 420_421 2.08965e-09
r_980_981_e 980 981 13376.4
r_980_981_i 980_981 981 93218.1
c_980_981_i 980 980_981 2.08965e-09
r_1540_1541_e 1540 1541 836.944
r_1540_1541_i 1540_1541 1541 4256.89
c_1540_1541_i 1540 1540_1541 4.67522e-10
r_2100_2101_e 2100 2101 836.944
r_2100_2101_i 2100_2101 2101 4256.89
c_2100_2101_i 2100 2100_2101 4.67522e-10
r_2660_2661_e 2660 2661 836.944
r_2660_2661_i 2660_2661 2661 4256.89
c_2660_2661_i 2660 2660_2661 4.67522e-10
r_3220_3221_e 3220 3221 13758.3
r_3220_3221_i 3220_3221 3221 95645.6
c_3220_3221_i 3220 3220_3221 9.36084e-12
r_3780_3781_e 3780 3781 13758.3
r_3780_3781_i 3780_3781 3781 95645.6
c_3780_3781_i 3780 3780_3781 9.36084e-12
r_421_422_e 421 422 13376.4
r_421_422_i 421_422 422 93218.1
c_421_422_i 421 421_422 2.08965e-09
r_981_982_e 981 982 13376.4
r_981_982_i 981_982 982 93218.1
c_981_982_i 981 981_982 2.08965e-09
r_1541_1542_e 1541 1542 836.944
r_1541_1542_i 1541_1542 1542 4256.89
c_1541_1542_i 1541 1541_1542 4.67522e-10
r_2101_2102_e 2101 2102 836.944
r_2101_2102_i 2101_2102 2102 4256.89
c_2101_2102_i 2101 2101_2102 4.67522e-10
r_2661_2662_e 2661 2662 836.944
r_2661_2662_i 2661_2662 2662 4256.89
c_2661_2662_i 2661 2661_2662 4.67522e-10
r_3221_3222_e 3221 3222 13758.3
r_3221_3222_i 3221_3222 3222 95645.6
c_3221_3222_i 3221 3221_3222 9.36084e-12
r_3781_3782_e 3781 3782 13758.3
r_3781_3782_i 3781_3782 3782 95645.6
c_3781_3782_i 3781 3781_3782 9.36084e-12
r_422_423_e 422 423 13376.4
r_422_423_i 422_423 423 93218.1
c_422_423_i 422 422_423 2.08965e-09
r_982_983_e 982 983 13376.4
r_982_983_i 982_983 983 93218.1
c_982_983_i 982 982_983 2.08965e-09
r_1542_1543_e 1542 1543 836.944
r_1542_1543_i 1542_1543 1543 4256.89
c_1542_1543_i 1542 1542_1543 4.67522e-10
r_2102_2103_e 2102 2103 836.944
r_2102_2103_i 2102_2103 2103 4256.89
c_2102_2103_i 2102 2102_2103 4.67522e-10
r_2662_2663_e 2662 2663 836.944
r_2662_2663_i 2662_2663 2663 4256.89
c_2662_2663_i 2662 2662_2663 4.67522e-10
r_3222_3223_e 3222 3223 13758.3
r_3222_3223_i 3222_3223 3223 95645.6
c_3222_3223_i 3222 3222_3223 9.36084e-12
r_3782_3783_e 3782 3783 13758.3
r_3782_3783_i 3782_3783 3783 95645.6
c_3782_3783_i 3782 3782_3783 9.36084e-12
r_423_424_e 423 424 13376.4
r_423_424_i 423_424 424 93218.1
c_423_424_i 423 423_424 2.08965e-09
r_983_984_e 983 984 13376.4
r_983_984_i 983_984 984 93218.1
c_983_984_i 983 983_984 2.08965e-09
r_1543_1544_e 1543 1544 836.944
r_1543_1544_i 1543_1544 1544 4256.89
c_1543_1544_i 1543 1543_1544 4.67522e-10
r_2103_2104_e 2103 2104 836.944
r_2103_2104_i 2103_2104 2104 4256.89
c_2103_2104_i 2103 2103_2104 4.67522e-10
r_2663_2664_e 2663 2664 836.944
r_2663_2664_i 2663_2664 2664 4256.89
c_2663_2664_i 2663 2663_2664 4.67522e-10
r_3223_3224_e 3223 3224 13758.3
r_3223_3224_i 3223_3224 3224 95645.6
c_3223_3224_i 3223 3223_3224 9.36084e-12
r_3783_3784_e 3783 3784 13758.3
r_3783_3784_i 3783_3784 3784 95645.6
c_3783_3784_i 3783 3783_3784 9.36084e-12
r_424_425_e 424 425 13376.4
r_424_425_i 424_425 425 93218.1
c_424_425_i 424 424_425 2.08965e-09
r_984_985_e 984 985 13376.4
r_984_985_i 984_985 985 93218.1
c_984_985_i 984 984_985 2.08965e-09
r_1544_1545_e 1544 1545 836.944
r_1544_1545_i 1544_1545 1545 4256.89
c_1544_1545_i 1544 1544_1545 4.67522e-10
r_2104_2105_e 2104 2105 836.944
r_2104_2105_i 2104_2105 2105 4256.89
c_2104_2105_i 2104 2104_2105 4.67522e-10
r_2664_2665_e 2664 2665 836.944
r_2664_2665_i 2664_2665 2665 4256.89
c_2664_2665_i 2664 2664_2665 4.67522e-10
r_3224_3225_e 3224 3225 13758.3
r_3224_3225_i 3224_3225 3225 95645.6
c_3224_3225_i 3224 3224_3225 9.36084e-12
r_3784_3785_e 3784 3785 13758.3
r_3784_3785_i 3784_3785 3785 95645.6
c_3784_3785_i 3784 3784_3785 9.36084e-12
r_425_426_e 425 426 13376.4
r_425_426_i 425_426 426 93218.1
c_425_426_i 425 425_426 2.08965e-09
r_985_986_e 985 986 13376.4
r_985_986_i 985_986 986 93218.1
c_985_986_i 985 985_986 2.08965e-09
r_1545_1546_e 1545 1546 836.944
r_1545_1546_i 1545_1546 1546 4256.89
c_1545_1546_i 1545 1545_1546 4.67522e-10
r_2105_2106_e 2105 2106 836.944
r_2105_2106_i 2105_2106 2106 4256.89
c_2105_2106_i 2105 2105_2106 4.67522e-10
r_2665_2666_e 2665 2666 836.944
r_2665_2666_i 2665_2666 2666 4256.89
c_2665_2666_i 2665 2665_2666 4.67522e-10
r_3225_3226_e 3225 3226 13758.3
r_3225_3226_i 3225_3226 3226 95645.6
c_3225_3226_i 3225 3225_3226 9.36084e-12
r_3785_3786_e 3785 3786 13758.3
r_3785_3786_i 3785_3786 3786 95645.6
c_3785_3786_i 3785 3785_3786 9.36084e-12
r_426_427_e 426 427 13376.4
r_426_427_i 426_427 427 93218.1
c_426_427_i 426 426_427 2.08965e-09
r_986_987_e 986 987 13376.4
r_986_987_i 986_987 987 93218.1
c_986_987_i 986 986_987 2.08965e-09
r_1546_1547_e 1546 1547 836.944
r_1546_1547_i 1546_1547 1547 4256.89
c_1546_1547_i 1546 1546_1547 4.67522e-10
r_2106_2107_e 2106 2107 836.944
r_2106_2107_i 2106_2107 2107 4256.89
c_2106_2107_i 2106 2106_2107 4.67522e-10
r_2666_2667_e 2666 2667 836.944
r_2666_2667_i 2666_2667 2667 4256.89
c_2666_2667_i 2666 2666_2667 4.67522e-10
r_3226_3227_e 3226 3227 13758.3
r_3226_3227_i 3226_3227 3227 95645.6
c_3226_3227_i 3226 3226_3227 9.36084e-12
r_3786_3787_e 3786 3787 13758.3
r_3786_3787_i 3786_3787 3787 95645.6
c_3786_3787_i 3786 3786_3787 9.36084e-12
r_427_428_e 427 428 13376.4
r_427_428_i 427_428 428 93218.1
c_427_428_i 427 427_428 2.08965e-09
r_987_988_e 987 988 396.551
r_987_988_i 987_988 988 1004.9
c_987_988_i 987 987_988 1.65856e-10
r_1547_1548_e 1547 1548 396.551
r_1547_1548_i 1547_1548 1548 1004.9
c_1547_1548_i 1547 1547_1548 1.65856e-10
r_2107_2108_e 2107 2108 836.944
r_2107_2108_i 2107_2108 2108 4256.89
c_2107_2108_i 2107 2107_2108 4.67522e-10
r_2667_2668_e 2667 2668 836.944
r_2667_2668_i 2667_2668 2668 4256.89
c_2667_2668_i 2667 2667_2668 4.67522e-10
r_3227_3228_e 3227 3228 13758.3
r_3227_3228_i 3227_3228 3228 95645.6
c_3227_3228_i 3227 3227_3228 9.36084e-12
r_3787_3788_e 3787 3788 13758.3
r_3787_3788_i 3787_3788 3788 95645.6
c_3787_3788_i 3787 3787_3788 9.36084e-12
r_428_429_e 428 429 13376.4
r_428_429_i 428_429 429 93218.1
c_428_429_i 428 428_429 2.08965e-09
r_988_989_e 988 989 13376.4
r_988_989_i 988_989 989 93218.1
c_988_989_i 988 988_989 2.08965e-09
r_1548_1549_e 1548 1549 836.944
r_1548_1549_i 1548_1549 1549 4256.89
c_1548_1549_i 1548 1548_1549 4.67522e-10
r_2108_2109_e 2108 2109 836.944
r_2108_2109_i 2108_2109 2109 4256.89
c_2108_2109_i 2108 2108_2109 4.67522e-10
r_2668_2669_e 2668 2669 836.944
r_2668_2669_i 2668_2669 2669 4256.89
c_2668_2669_i 2668 2668_2669 4.67522e-10
r_3228_3229_e 3228 3229 13758.3
r_3228_3229_i 3228_3229 3229 95645.6
c_3228_3229_i 3228 3228_3229 9.36084e-12
r_3788_3789_e 3788 3789 13758.3
r_3788_3789_i 3788_3789 3789 95645.6
c_3788_3789_i 3788 3788_3789 9.36084e-12
r_429_430_e 429 430 13376.4
r_429_430_i 429_430 430 93218.1
c_429_430_i 429 429_430 2.08965e-09
r_989_990_e 989 990 13376.4
r_989_990_i 989_990 990 93218.1
c_989_990_i 989 989_990 2.08965e-09
r_1549_1550_e 1549 1550 836.944
r_1549_1550_i 1549_1550 1550 4256.89
c_1549_1550_i 1549 1549_1550 4.67522e-10
r_2109_2110_e 2109 2110 836.944
r_2109_2110_i 2109_2110 2110 4256.89
c_2109_2110_i 2109 2109_2110 4.67522e-10
r_2669_2670_e 2669 2670 836.944
r_2669_2670_i 2669_2670 2670 4256.89
c_2669_2670_i 2669 2669_2670 4.67522e-10
r_3229_3230_e 3229 3230 13758.3
r_3229_3230_i 3229_3230 3230 95645.6
c_3229_3230_i 3229 3229_3230 9.36084e-12
r_3789_3790_e 3789 3790 13758.3
r_3789_3790_i 3789_3790 3790 95645.6
c_3789_3790_i 3789 3789_3790 9.36084e-12
r_430_431_e 430 431 13376.4
r_430_431_i 430_431 431 93218.1
c_430_431_i 430 430_431 2.08965e-09
r_990_991_e 990 991 13376.4
r_990_991_i 990_991 991 93218.1
c_990_991_i 990 990_991 2.08965e-09
r_1550_1551_e 1550 1551 836.944
r_1550_1551_i 1550_1551 1551 4256.89
c_1550_1551_i 1550 1550_1551 4.67522e-10
r_2110_2111_e 2110 2111 836.944
r_2110_2111_i 2110_2111 2111 4256.89
c_2110_2111_i 2110 2110_2111 4.67522e-10
r_2670_2671_e 2670 2671 836.944
r_2670_2671_i 2670_2671 2671 4256.89
c_2670_2671_i 2670 2670_2671 4.67522e-10
r_3230_3231_e 3230 3231 13758.3
r_3230_3231_i 3230_3231 3231 95645.6
c_3230_3231_i 3230 3230_3231 9.36084e-12
r_3790_3791_e 3790 3791 13758.3
r_3790_3791_i 3790_3791 3791 95645.6
c_3790_3791_i 3790 3790_3791 9.36084e-12
r_431_432_e 431 432 13376.4
r_431_432_i 431_432 432 93218.1
c_431_432_i 431 431_432 2.08965e-09
r_991_992_e 991 992 13376.4
r_991_992_i 991_992 992 93218.1
c_991_992_i 991 991_992 2.08965e-09
r_1551_1552_e 1551 1552 836.944
r_1551_1552_i 1551_1552 1552 4256.89
c_1551_1552_i 1551 1551_1552 4.67522e-10
r_2111_2112_e 2111 2112 836.944
r_2111_2112_i 2111_2112 2112 4256.89
c_2111_2112_i 2111 2111_2112 4.67522e-10
r_2671_2672_e 2671 2672 836.944
r_2671_2672_i 2671_2672 2672 4256.89
c_2671_2672_i 2671 2671_2672 4.67522e-10
r_3231_3232_e 3231 3232 13758.3
r_3231_3232_i 3231_3232 3232 95645.6
c_3231_3232_i 3231 3231_3232 9.36084e-12
r_3791_3792_e 3791 3792 13758.3
r_3791_3792_i 3791_3792 3792 95645.6
c_3791_3792_i 3791 3791_3792 9.36084e-12
r_433_434_e 433 434 13376.4
r_433_434_i 433_434 434 93218.1
c_433_434_i 433 433_434 2.08965e-09
r_993_994_e 993 994 13376.4
r_993_994_i 993_994 994 93218.1
c_993_994_i 993 993_994 2.08965e-09
r_1553_1554_e 1553 1554 13376.4
r_1553_1554_i 1553_1554 1554 93218.1
c_1553_1554_i 1553 1553_1554 2.08965e-09
r_2113_2114_e 2113 2114 13376.4
r_2113_2114_i 2113_2114 2114 93218.1
c_2113_2114_i 2113 2113_2114 2.08965e-09
r_2673_2674_e 2673 2674 13376.4
r_2673_2674_i 2673_2674 2674 93218.1
c_2673_2674_i 2673 2673_2674 2.08965e-09
r_3233_3234_e 3233 3234 13376.4
r_3233_3234_i 3233_3234 3234 93218.1
c_3233_3234_i 3233 3233_3234 2.08965e-09
r_3793_3794_e 3793 3794 13376.4
r_3793_3794_i 3793_3794 3794 93218.1
c_3793_3794_i 3793 3793_3794 2.08965e-09
r_434_435_e 434 435 13376.4
r_434_435_i 434_435 435 93218.1
c_434_435_i 434 434_435 2.08965e-09
r_994_995_e 994 995 13376.4
r_994_995_i 994_995 995 93218.1
c_994_995_i 994 994_995 2.08965e-09
r_1554_1555_e 1554 1555 13376.4
r_1554_1555_i 1554_1555 1555 93218.1
c_1554_1555_i 1554 1554_1555 2.08965e-09
r_2114_2115_e 2114 2115 13376.4
r_2114_2115_i 2114_2115 2115 93218.1
c_2114_2115_i 2114 2114_2115 2.08965e-09
r_2674_2675_e 2674 2675 13376.4
r_2674_2675_i 2674_2675 2675 93218.1
c_2674_2675_i 2674 2674_2675 2.08965e-09
r_3234_3235_e 3234 3235 13376.4
r_3234_3235_i 3234_3235 3235 93218.1
c_3234_3235_i 3234 3234_3235 2.08965e-09
r_3794_3795_e 3794 3795 13376.4
r_3794_3795_i 3794_3795 3795 93218.1
c_3794_3795_i 3794 3794_3795 2.08965e-09
r_435_436_e 435 436 13376.4
r_435_436_i 435_436 436 93218.1
c_435_436_i 435 435_436 2.08965e-09
r_995_996_e 995 996 13376.4
r_995_996_i 995_996 996 93218.1
c_995_996_i 995 995_996 2.08965e-09
r_1555_1556_e 1555 1556 836.944
r_1555_1556_i 1555_1556 1556 4256.89
c_1555_1556_i 1555 1555_1556 4.67522e-10
r_2115_2116_e 2115 2116 836.944
r_2115_2116_i 2115_2116 2116 4256.89
c_2115_2116_i 2115 2115_2116 4.67522e-10
r_2675_2676_e 2675 2676 836.944
r_2675_2676_i 2675_2676 2676 4256.89
c_2675_2676_i 2675 2675_2676 4.67522e-10
r_3235_3236_e 3235 3236 836.944
r_3235_3236_i 3235_3236 3236 4256.89
c_3235_3236_i 3235 3235_3236 4.67522e-10
r_3795_3796_e 3795 3796 836.944
r_3795_3796_i 3795_3796 3796 4256.89
c_3795_3796_i 3795 3795_3796 4.67522e-10
r_436_437_e 436 437 13376.4
r_436_437_i 436_437 437 93218.1
c_436_437_i 436 436_437 2.08965e-09
r_996_997_e 996 997 13376.4
r_996_997_i 996_997 997 93218.1
c_996_997_i 996 996_997 2.08965e-09
r_1556_1557_e 1556 1557 836.944
r_1556_1557_i 1556_1557 1557 4256.89
c_1556_1557_i 1556 1556_1557 4.67522e-10
r_2116_2117_e 2116 2117 836.944
r_2116_2117_i 2116_2117 2117 4256.89
c_2116_2117_i 2116 2116_2117 4.67522e-10
r_2676_2677_e 2676 2677 836.944
r_2676_2677_i 2676_2677 2677 4256.89
c_2676_2677_i 2676 2676_2677 4.67522e-10
r_3236_3237_e 3236 3237 13758.3
r_3236_3237_i 3236_3237 3237 95645.6
c_3236_3237_i 3236 3236_3237 9.36084e-12
r_3796_3797_e 3796 3797 13758.3
r_3796_3797_i 3796_3797 3797 95645.6
c_3796_3797_i 3796 3796_3797 9.36084e-12
r_437_438_e 437 438 13376.4
r_437_438_i 437_438 438 93218.1
c_437_438_i 437 437_438 2.08965e-09
r_997_998_e 997 998 13376.4
r_997_998_i 997_998 998 93218.1
c_997_998_i 997 997_998 2.08965e-09
r_1557_1558_e 1557 1558 836.944
r_1557_1558_i 1557_1558 1558 4256.89
c_1557_1558_i 1557 1557_1558 4.67522e-10
r_2117_2118_e 2117 2118 836.944
r_2117_2118_i 2117_2118 2118 4256.89
c_2117_2118_i 2117 2117_2118 4.67522e-10
r_2677_2678_e 2677 2678 836.944
r_2677_2678_i 2677_2678 2678 4256.89
c_2677_2678_i 2677 2677_2678 4.67522e-10
r_3237_3238_e 3237 3238 13758.3
r_3237_3238_i 3237_3238 3238 95645.6
c_3237_3238_i 3237 3237_3238 9.36084e-12
r_3797_3798_e 3797 3798 13758.3
r_3797_3798_i 3797_3798 3798 95645.6
c_3797_3798_i 3797 3797_3798 9.36084e-12
r_438_439_e 438 439 13376.4
r_438_439_i 438_439 439 93218.1
c_438_439_i 438 438_439 2.08965e-09
r_998_999_e 998 999 13376.4
r_998_999_i 998_999 999 93218.1
c_998_999_i 998 998_999 2.08965e-09
r_1558_1559_e 1558 1559 836.944
r_1558_1559_i 1558_1559 1559 4256.89
c_1558_1559_i 1558 1558_1559 4.67522e-10
r_2118_2119_e 2118 2119 836.944
r_2118_2119_i 2118_2119 2119 4256.89
c_2118_2119_i 2118 2118_2119 4.67522e-10
r_2678_2679_e 2678 2679 836.944
r_2678_2679_i 2678_2679 2679 4256.89
c_2678_2679_i 2678 2678_2679 4.67522e-10
r_3238_3239_e 3238 3239 13758.3
r_3238_3239_i 3238_3239 3239 95645.6
c_3238_3239_i 3238 3238_3239 9.36084e-12
r_3798_3799_e 3798 3799 13758.3
r_3798_3799_i 3798_3799 3799 95645.6
c_3798_3799_i 3798 3798_3799 9.36084e-12
r_439_440_e 439 440 13376.4
r_439_440_i 439_440 440 93218.1
c_439_440_i 439 439_440 2.08965e-09
r_999_1000_e 999 1000 13376.4
r_999_1000_i 999_1000 1000 93218.1
c_999_1000_i 999 999_1000 2.08965e-09
r_1559_1560_e 1559 1560 836.944
r_1559_1560_i 1559_1560 1560 4256.89
c_1559_1560_i 1559 1559_1560 4.67522e-10
r_2119_2120_e 2119 2120 836.944
r_2119_2120_i 2119_2120 2120 4256.89
c_2119_2120_i 2119 2119_2120 4.67522e-10
r_2679_2680_e 2679 2680 836.944
r_2679_2680_i 2679_2680 2680 4256.89
c_2679_2680_i 2679 2679_2680 4.67522e-10
r_3239_3240_e 3239 3240 13758.3
r_3239_3240_i 3239_3240 3240 95645.6
c_3239_3240_i 3239 3239_3240 9.36084e-12
r_3799_3800_e 3799 3800 13758.3
r_3799_3800_i 3799_3800 3800 95645.6
c_3799_3800_i 3799 3799_3800 9.36084e-12
r_440_441_e 440 441 13376.4
r_440_441_i 440_441 441 93218.1
c_440_441_i 440 440_441 2.08965e-09
r_1000_1001_e 1000 1001 13376.4
r_1000_1001_i 1000_1001 1001 93218.1
c_1000_1001_i 1000 1000_1001 2.08965e-09
r_1560_1561_e 1560 1561 836.944
r_1560_1561_i 1560_1561 1561 4256.89
c_1560_1561_i 1560 1560_1561 4.67522e-10
r_2120_2121_e 2120 2121 836.944
r_2120_2121_i 2120_2121 2121 4256.89
c_2120_2121_i 2120 2120_2121 4.67522e-10
r_2680_2681_e 2680 2681 836.944
r_2680_2681_i 2680_2681 2681 4256.89
c_2680_2681_i 2680 2680_2681 4.67522e-10
r_3240_3241_e 3240 3241 13758.3
r_3240_3241_i 3240_3241 3241 95645.6
c_3240_3241_i 3240 3240_3241 9.36084e-12
r_3800_3801_e 3800 3801 13758.3
r_3800_3801_i 3800_3801 3801 95645.6
c_3800_3801_i 3800 3800_3801 9.36084e-12
r_441_442_e 441 442 13376.4
r_441_442_i 441_442 442 93218.1
c_441_442_i 441 441_442 2.08965e-09
r_1001_1002_e 1001 1002 13376.4
r_1001_1002_i 1001_1002 1002 93218.1
c_1001_1002_i 1001 1001_1002 2.08965e-09
r_1561_1562_e 1561 1562 836.944
r_1561_1562_i 1561_1562 1562 4256.89
c_1561_1562_i 1561 1561_1562 4.67522e-10
r_2121_2122_e 2121 2122 836.944
r_2121_2122_i 2121_2122 2122 4256.89
c_2121_2122_i 2121 2121_2122 4.67522e-10
r_2681_2682_e 2681 2682 836.944
r_2681_2682_i 2681_2682 2682 4256.89
c_2681_2682_i 2681 2681_2682 4.67522e-10
r_3241_3242_e 3241 3242 13758.3
r_3241_3242_i 3241_3242 3242 95645.6
c_3241_3242_i 3241 3241_3242 9.36084e-12
r_3801_3802_e 3801 3802 13758.3
r_3801_3802_i 3801_3802 3802 95645.6
c_3801_3802_i 3801 3801_3802 9.36084e-12
r_442_443_e 442 443 13376.4
r_442_443_i 442_443 443 93218.1
c_442_443_i 442 442_443 2.08965e-09
r_1002_1003_e 1002 1003 13376.4
r_1002_1003_i 1002_1003 1003 93218.1
c_1002_1003_i 1002 1002_1003 2.08965e-09
r_1562_1563_e 1562 1563 836.944
r_1562_1563_i 1562_1563 1563 4256.89
c_1562_1563_i 1562 1562_1563 4.67522e-10
r_2122_2123_e 2122 2123 836.944
r_2122_2123_i 2122_2123 2123 4256.89
c_2122_2123_i 2122 2122_2123 4.67522e-10
r_2682_2683_e 2682 2683 836.944
r_2682_2683_i 2682_2683 2683 4256.89
c_2682_2683_i 2682 2682_2683 4.67522e-10
r_3242_3243_e 3242 3243 13758.3
r_3242_3243_i 3242_3243 3243 95645.6
c_3242_3243_i 3242 3242_3243 9.36084e-12
r_3802_3803_e 3802 3803 13758.3
r_3802_3803_i 3802_3803 3803 95645.6
c_3802_3803_i 3802 3802_3803 9.36084e-12
r_443_444_e 443 444 13376.4
r_443_444_i 443_444 444 93218.1
c_443_444_i 443 443_444 2.08965e-09
r_1003_1004_e 1003 1004 396.543
r_1003_1004_i 1003_1004 1004 1004.88
c_1003_1004_i 1003 1003_1004 1.65859e-10
r_1563_1564_e 1563 1564 396.543
r_1563_1564_i 1563_1564 1564 1004.88
c_1563_1564_i 1563 1563_1564 1.65859e-10
r_2123_2124_e 2123 2124 836.944
r_2123_2124_i 2123_2124 2124 4256.89
c_2123_2124_i 2123 2123_2124 4.67522e-10
r_2683_2684_e 2683 2684 836.944
r_2683_2684_i 2683_2684 2684 4256.89
c_2683_2684_i 2683 2683_2684 4.67522e-10
r_3243_3244_e 3243 3244 13758.3
r_3243_3244_i 3243_3244 3244 95645.6
c_3243_3244_i 3243 3243_3244 9.36084e-12
r_3803_3804_e 3803 3804 13758.3
r_3803_3804_i 3803_3804 3804 95645.6
c_3803_3804_i 3803 3803_3804 9.36084e-12
r_444_445_e 444 445 13376.4
r_444_445_i 444_445 445 93218.1
c_444_445_i 444 444_445 2.08965e-09
r_1004_1005_e 1004 1005 13376.4
r_1004_1005_i 1004_1005 1005 93218.1
c_1004_1005_i 1004 1004_1005 2.08965e-09
r_1564_1565_e 1564 1565 836.944
r_1564_1565_i 1564_1565 1565 4256.89
c_1564_1565_i 1564 1564_1565 4.67522e-10
r_2124_2125_e 2124 2125 836.944
r_2124_2125_i 2124_2125 2125 4256.89
c_2124_2125_i 2124 2124_2125 4.67522e-10
r_2684_2685_e 2684 2685 836.944
r_2684_2685_i 2684_2685 2685 4256.89
c_2684_2685_i 2684 2684_2685 4.67522e-10
r_3244_3245_e 3244 3245 13758.3
r_3244_3245_i 3244_3245 3245 95645.6
c_3244_3245_i 3244 3244_3245 9.36084e-12
r_3804_3805_e 3804 3805 13758.3
r_3804_3805_i 3804_3805 3805 95645.6
c_3804_3805_i 3804 3804_3805 9.36084e-12
r_445_446_e 445 446 13376.4
r_445_446_i 445_446 446 93218.1
c_445_446_i 445 445_446 2.08965e-09
r_1005_1006_e 1005 1006 13376.4
r_1005_1006_i 1005_1006 1006 93218.1
c_1005_1006_i 1005 1005_1006 2.08965e-09
r_1565_1566_e 1565 1566 836.944
r_1565_1566_i 1565_1566 1566 4256.89
c_1565_1566_i 1565 1565_1566 4.67522e-10
r_2125_2126_e 2125 2126 836.944
r_2125_2126_i 2125_2126 2126 4256.89
c_2125_2126_i 2125 2125_2126 4.67522e-10
r_2685_2686_e 2685 2686 836.944
r_2685_2686_i 2685_2686 2686 4256.89
c_2685_2686_i 2685 2685_2686 4.67522e-10
r_3245_3246_e 3245 3246 13758.3
r_3245_3246_i 3245_3246 3246 95645.6
c_3245_3246_i 3245 3245_3246 9.36084e-12
r_3805_3806_e 3805 3806 13758.3
r_3805_3806_i 3805_3806 3806 95645.6
c_3805_3806_i 3805 3805_3806 9.36084e-12
r_446_447_e 446 447 13376.4
r_446_447_i 446_447 447 93218.1
c_446_447_i 446 446_447 2.08965e-09
r_1006_1007_e 1006 1007 13376.4
r_1006_1007_i 1006_1007 1007 93218.1
c_1006_1007_i 1006 1006_1007 2.08965e-09
r_1566_1567_e 1566 1567 836.944
r_1566_1567_i 1566_1567 1567 4256.89
c_1566_1567_i 1566 1566_1567 4.67522e-10
r_2126_2127_e 2126 2127 836.944
r_2126_2127_i 2126_2127 2127 4256.89
c_2126_2127_i 2126 2126_2127 4.67522e-10
r_2686_2687_e 2686 2687 836.944
r_2686_2687_i 2686_2687 2687 4256.89
c_2686_2687_i 2686 2686_2687 4.67522e-10
r_3246_3247_e 3246 3247 13758.3
r_3246_3247_i 3246_3247 3247 95645.6
c_3246_3247_i 3246 3246_3247 9.36084e-12
r_3806_3807_e 3806 3807 13758.3
r_3806_3807_i 3806_3807 3807 95645.6
c_3806_3807_i 3806 3806_3807 9.36084e-12
r_447_448_e 447 448 13376.4
r_447_448_i 447_448 448 93218.1
c_447_448_i 447 447_448 2.08965e-09
r_1007_1008_e 1007 1008 13376.4
r_1007_1008_i 1007_1008 1008 93218.1
c_1007_1008_i 1007 1007_1008 2.08965e-09
r_1567_1568_e 1567 1568 836.944
r_1567_1568_i 1567_1568 1568 4256.89
c_1567_1568_i 1567 1567_1568 4.67522e-10
r_2127_2128_e 2127 2128 836.944
r_2127_2128_i 2127_2128 2128 4256.89
c_2127_2128_i 2127 2127_2128 4.67522e-10
r_2687_2688_e 2687 2688 836.944
r_2687_2688_i 2687_2688 2688 4256.89
c_2687_2688_i 2687 2687_2688 4.67522e-10
r_3247_3248_e 3247 3248 13758.3
r_3247_3248_i 3247_3248 3248 95645.6
c_3247_3248_i 3247 3247_3248 9.36084e-12
r_3807_3808_e 3807 3808 13758.3
r_3807_3808_i 3807_3808 3808 95645.6
c_3807_3808_i 3807 3807_3808 9.36084e-12
r_449_450_e 449 450 13376.4
r_449_450_i 449_450 450 93218.1
c_449_450_i 449 449_450 2.08965e-09
r_1009_1010_e 1009 1010 13376.4
r_1009_1010_i 1009_1010 1010 93218.1
c_1009_1010_i 1009 1009_1010 2.08965e-09
r_1569_1570_e 1569 1570 13376.4
r_1569_1570_i 1569_1570 1570 93218.1
c_1569_1570_i 1569 1569_1570 2.08965e-09
r_2129_2130_e 2129 2130 13376.4
r_2129_2130_i 2129_2130 2130 93218.1
c_2129_2130_i 2129 2129_2130 2.08965e-09
r_2689_2690_e 2689 2690 13376.4
r_2689_2690_i 2689_2690 2690 93218.1
c_2689_2690_i 2689 2689_2690 2.08965e-09
r_3249_3250_e 3249 3250 13376.4
r_3249_3250_i 3249_3250 3250 93218.1
c_3249_3250_i 3249 3249_3250 2.08965e-09
r_3809_3810_e 3809 3810 13376.4
r_3809_3810_i 3809_3810 3810 93218.1
c_3809_3810_i 3809 3809_3810 2.08965e-09
r_450_451_e 450 451 13376.4
r_450_451_i 450_451 451 93218.1
c_450_451_i 450 450_451 2.08965e-09
r_1010_1011_e 1010 1011 13376.4
r_1010_1011_i 1010_1011 1011 93218.1
c_1010_1011_i 1010 1010_1011 2.08965e-09
r_1570_1571_e 1570 1571 13376.4
r_1570_1571_i 1570_1571 1571 93218.1
c_1570_1571_i 1570 1570_1571 2.08965e-09
r_2130_2131_e 2130 2131 13376.4
r_2130_2131_i 2130_2131 2131 93218.1
c_2130_2131_i 2130 2130_2131 2.08965e-09
r_2690_2691_e 2690 2691 13376.4
r_2690_2691_i 2690_2691 2691 93218.1
c_2690_2691_i 2690 2690_2691 2.08965e-09
r_3250_3251_e 3250 3251 13376.4
r_3250_3251_i 3250_3251 3251 93218.1
c_3250_3251_i 3250 3250_3251 2.08965e-09
r_3810_3811_e 3810 3811 13376.4
r_3810_3811_i 3810_3811 3811 93218.1
c_3810_3811_i 3810 3810_3811 2.08965e-09
r_451_452_e 451 452 13376.4
r_451_452_i 451_452 452 93218.1
c_451_452_i 451 451_452 2.08965e-09
r_1011_1012_e 1011 1012 13376.4
r_1011_1012_i 1011_1012 1012 93218.1
c_1011_1012_i 1011 1011_1012 2.08965e-09
r_1571_1572_e 1571 1572 836.944
r_1571_1572_i 1571_1572 1572 4256.89
c_1571_1572_i 1571 1571_1572 4.67522e-10
r_2131_2132_e 2131 2132 836.944
r_2131_2132_i 2131_2132 2132 4256.89
c_2131_2132_i 2131 2131_2132 4.67522e-10
r_2691_2692_e 2691 2692 836.944
r_2691_2692_i 2691_2692 2692 4256.89
c_2691_2692_i 2691 2691_2692 4.67522e-10
r_3251_3252_e 3251 3252 836.944
r_3251_3252_i 3251_3252 3252 4256.89
c_3251_3252_i 3251 3251_3252 4.67522e-10
r_3811_3812_e 3811 3812 836.944
r_3811_3812_i 3811_3812 3812 4256.89
c_3811_3812_i 3811 3811_3812 4.67522e-10
r_452_453_e 452 453 13376.4
r_452_453_i 452_453 453 93218.1
c_452_453_i 452 452_453 2.08965e-09
r_1012_1013_e 1012 1013 13376.4
r_1012_1013_i 1012_1013 1013 93218.1
c_1012_1013_i 1012 1012_1013 2.08965e-09
r_1572_1573_e 1572 1573 836.944
r_1572_1573_i 1572_1573 1573 4256.89
c_1572_1573_i 1572 1572_1573 4.67522e-10
r_2132_2133_e 2132 2133 836.944
r_2132_2133_i 2132_2133 2133 4256.89
c_2132_2133_i 2132 2132_2133 4.67522e-10
r_2692_2693_e 2692 2693 836.944
r_2692_2693_i 2692_2693 2693 4256.89
c_2692_2693_i 2692 2692_2693 4.67522e-10
r_3252_3253_e 3252 3253 13758.3
r_3252_3253_i 3252_3253 3253 95645.6
c_3252_3253_i 3252 3252_3253 9.36084e-12
r_3812_3813_e 3812 3813 13758.3
r_3812_3813_i 3812_3813 3813 95645.6
c_3812_3813_i 3812 3812_3813 9.36084e-12
r_453_454_e 453 454 13376.4
r_453_454_i 453_454 454 93218.1
c_453_454_i 453 453_454 2.08965e-09
r_1013_1014_e 1013 1014 13376.4
r_1013_1014_i 1013_1014 1014 93218.1
c_1013_1014_i 1013 1013_1014 2.08965e-09
r_1573_1574_e 1573 1574 836.944
r_1573_1574_i 1573_1574 1574 4256.89
c_1573_1574_i 1573 1573_1574 4.67522e-10
r_2133_2134_e 2133 2134 836.944
r_2133_2134_i 2133_2134 2134 4256.89
c_2133_2134_i 2133 2133_2134 4.67522e-10
r_2693_2694_e 2693 2694 836.944
r_2693_2694_i 2693_2694 2694 4256.89
c_2693_2694_i 2693 2693_2694 4.67522e-10
r_3253_3254_e 3253 3254 13758.3
r_3253_3254_i 3253_3254 3254 95645.6
c_3253_3254_i 3253 3253_3254 9.36084e-12
r_3813_3814_e 3813 3814 13758.3
r_3813_3814_i 3813_3814 3814 95645.6
c_3813_3814_i 3813 3813_3814 9.36084e-12
r_454_455_e 454 455 13376.4
r_454_455_i 454_455 455 93218.1
c_454_455_i 454 454_455 2.08965e-09
r_1014_1015_e 1014 1015 13376.4
r_1014_1015_i 1014_1015 1015 93218.1
c_1014_1015_i 1014 1014_1015 2.08965e-09
r_1574_1575_e 1574 1575 836.944
r_1574_1575_i 1574_1575 1575 4256.89
c_1574_1575_i 1574 1574_1575 4.67522e-10
r_2134_2135_e 2134 2135 836.944
r_2134_2135_i 2134_2135 2135 4256.89
c_2134_2135_i 2134 2134_2135 4.67522e-10
r_2694_2695_e 2694 2695 836.944
r_2694_2695_i 2694_2695 2695 4256.89
c_2694_2695_i 2694 2694_2695 4.67522e-10
r_3254_3255_e 3254 3255 13758.3
r_3254_3255_i 3254_3255 3255 95645.6
c_3254_3255_i 3254 3254_3255 9.36084e-12
r_3814_3815_e 3814 3815 13758.3
r_3814_3815_i 3814_3815 3815 95645.6
c_3814_3815_i 3814 3814_3815 9.36084e-12
r_455_456_e 455 456 13376.4
r_455_456_i 455_456 456 93218.1
c_455_456_i 455 455_456 2.08965e-09
r_1015_1016_e 1015 1016 13376.4
r_1015_1016_i 1015_1016 1016 93218.1
c_1015_1016_i 1015 1015_1016 2.08965e-09
r_1575_1576_e 1575 1576 836.944
r_1575_1576_i 1575_1576 1576 4256.89
c_1575_1576_i 1575 1575_1576 4.67522e-10
r_2135_2136_e 2135 2136 836.944
r_2135_2136_i 2135_2136 2136 4256.89
c_2135_2136_i 2135 2135_2136 4.67522e-10
r_2695_2696_e 2695 2696 836.944
r_2695_2696_i 2695_2696 2696 4256.89
c_2695_2696_i 2695 2695_2696 4.67522e-10
r_3255_3256_e 3255 3256 13758.3
r_3255_3256_i 3255_3256 3256 95645.6
c_3255_3256_i 3255 3255_3256 9.36084e-12
r_3815_3816_e 3815 3816 13758.3
r_3815_3816_i 3815_3816 3816 95645.6
c_3815_3816_i 3815 3815_3816 9.36084e-12
r_456_457_e 456 457 13376.4
r_456_457_i 456_457 457 93218.1
c_456_457_i 456 456_457 2.08965e-09
r_1016_1017_e 1016 1017 13376.4
r_1016_1017_i 1016_1017 1017 93218.1
c_1016_1017_i 1016 1016_1017 2.08965e-09
r_1576_1577_e 1576 1577 836.944
r_1576_1577_i 1576_1577 1577 4256.89
c_1576_1577_i 1576 1576_1577 4.67522e-10
r_2136_2137_e 2136 2137 836.944
r_2136_2137_i 2136_2137 2137 4256.89
c_2136_2137_i 2136 2136_2137 4.67522e-10
r_2696_2697_e 2696 2697 836.944
r_2696_2697_i 2696_2697 2697 4256.89
c_2696_2697_i 2696 2696_2697 4.67522e-10
r_3256_3257_e 3256 3257 13758.3
r_3256_3257_i 3256_3257 3257 95645.6
c_3256_3257_i 3256 3256_3257 9.36084e-12
r_3816_3817_e 3816 3817 13758.3
r_3816_3817_i 3816_3817 3817 95645.6
c_3816_3817_i 3816 3816_3817 9.36084e-12
r_457_458_e 457 458 13376.4
r_457_458_i 457_458 458 93218.1
c_457_458_i 457 457_458 2.08965e-09
r_1017_1018_e 1017 1018 13376.4
r_1017_1018_i 1017_1018 1018 93218.1
c_1017_1018_i 1017 1017_1018 2.08965e-09
r_1577_1578_e 1577 1578 836.944
r_1577_1578_i 1577_1578 1578 4256.89
c_1577_1578_i 1577 1577_1578 4.67522e-10
r_2137_2138_e 2137 2138 836.944
r_2137_2138_i 2137_2138 2138 4256.89
c_2137_2138_i 2137 2137_2138 4.67522e-10
r_2697_2698_e 2697 2698 836.944
r_2697_2698_i 2697_2698 2698 4256.89
c_2697_2698_i 2697 2697_2698 4.67522e-10
r_3257_3258_e 3257 3258 13758.3
r_3257_3258_i 3257_3258 3258 95645.6
c_3257_3258_i 3257 3257_3258 9.36084e-12
r_3817_3818_e 3817 3818 13758.3
r_3817_3818_i 3817_3818 3818 95645.6
c_3817_3818_i 3817 3817_3818 9.36084e-12
r_458_459_e 458 459 13376.4
r_458_459_i 458_459 459 93218.1
c_458_459_i 458 458_459 2.08965e-09
r_1018_1019_e 1018 1019 13376.4
r_1018_1019_i 1018_1019 1019 93218.1
c_1018_1019_i 1018 1018_1019 2.08965e-09
r_1578_1579_e 1578 1579 836.944
r_1578_1579_i 1578_1579 1579 4256.89
c_1578_1579_i 1578 1578_1579 4.67522e-10
r_2138_2139_e 2138 2139 836.944
r_2138_2139_i 2138_2139 2139 4256.89
c_2138_2139_i 2138 2138_2139 4.67522e-10
r_2698_2699_e 2698 2699 836.944
r_2698_2699_i 2698_2699 2699 4256.89
c_2698_2699_i 2698 2698_2699 4.67522e-10
r_3258_3259_e 3258 3259 13758.3
r_3258_3259_i 3258_3259 3259 95645.6
c_3258_3259_i 3258 3258_3259 9.36084e-12
r_3818_3819_e 3818 3819 13758.3
r_3818_3819_i 3818_3819 3819 95645.6
c_3818_3819_i 3818 3818_3819 9.36084e-12
r_459_460_e 459 460 13376.4
r_459_460_i 459_460 460 93218.1
c_459_460_i 459 459_460 2.08965e-09
r_1019_1020_e 1019 1020 396.535
r_1019_1020_i 1019_1020 1020 1004.86
c_1019_1020_i 1019 1019_1020 1.65863e-10
r_1579_1580_e 1579 1580 396.535
r_1579_1580_i 1579_1580 1580 1004.86
c_1579_1580_i 1579 1579_1580 1.65863e-10
r_2139_2140_e 2139 2140 836.944
r_2139_2140_i 2139_2140 2140 4256.89
c_2139_2140_i 2139 2139_2140 4.67522e-10
r_2699_2700_e 2699 2700 836.944
r_2699_2700_i 2699_2700 2700 4256.89
c_2699_2700_i 2699 2699_2700 4.67522e-10
r_3259_3260_e 3259 3260 13758.3
r_3259_3260_i 3259_3260 3260 95645.6
c_3259_3260_i 3259 3259_3260 9.36084e-12
r_3819_3820_e 3819 3820 13758.3
r_3819_3820_i 3819_3820 3820 95645.6
c_3819_3820_i 3819 3819_3820 9.36084e-12
r_460_461_e 460 461 13376.4
r_460_461_i 460_461 461 93218.1
c_460_461_i 460 460_461 2.08965e-09
r_1020_1021_e 1020 1021 13376.4
r_1020_1021_i 1020_1021 1021 93218.1
c_1020_1021_i 1020 1020_1021 2.08965e-09
r_1580_1581_e 1580 1581 836.944
r_1580_1581_i 1580_1581 1581 4256.89
c_1580_1581_i 1580 1580_1581 4.67522e-10
r_2140_2141_e 2140 2141 836.944
r_2140_2141_i 2140_2141 2141 4256.89
c_2140_2141_i 2140 2140_2141 4.67522e-10
r_2700_2701_e 2700 2701 836.944
r_2700_2701_i 2700_2701 2701 4256.89
c_2700_2701_i 2700 2700_2701 4.67522e-10
r_3260_3261_e 3260 3261 13758.3
r_3260_3261_i 3260_3261 3261 95645.6
c_3260_3261_i 3260 3260_3261 9.36084e-12
r_3820_3821_e 3820 3821 13758.3
r_3820_3821_i 3820_3821 3821 95645.6
c_3820_3821_i 3820 3820_3821 9.36084e-12
r_461_462_e 461 462 13376.4
r_461_462_i 461_462 462 93218.1
c_461_462_i 461 461_462 2.08965e-09
r_1021_1022_e 1021 1022 13376.4
r_1021_1022_i 1021_1022 1022 93218.1
c_1021_1022_i 1021 1021_1022 2.08965e-09
r_1581_1582_e 1581 1582 836.944
r_1581_1582_i 1581_1582 1582 4256.89
c_1581_1582_i 1581 1581_1582 4.67522e-10
r_2141_2142_e 2141 2142 836.944
r_2141_2142_i 2141_2142 2142 4256.89
c_2141_2142_i 2141 2141_2142 4.67522e-10
r_2701_2702_e 2701 2702 836.944
r_2701_2702_i 2701_2702 2702 4256.89
c_2701_2702_i 2701 2701_2702 4.67522e-10
r_3261_3262_e 3261 3262 13758.3
r_3261_3262_i 3261_3262 3262 95645.6
c_3261_3262_i 3261 3261_3262 9.36084e-12
r_3821_3822_e 3821 3822 13758.3
r_3821_3822_i 3821_3822 3822 95645.6
c_3821_3822_i 3821 3821_3822 9.36084e-12
r_462_463_e 462 463 13376.4
r_462_463_i 462_463 463 93218.1
c_462_463_i 462 462_463 2.08965e-09
r_1022_1023_e 1022 1023 13376.4
r_1022_1023_i 1022_1023 1023 93218.1
c_1022_1023_i 1022 1022_1023 2.08965e-09
r_1582_1583_e 1582 1583 836.944
r_1582_1583_i 1582_1583 1583 4256.89
c_1582_1583_i 1582 1582_1583 4.67522e-10
r_2142_2143_e 2142 2143 836.944
r_2142_2143_i 2142_2143 2143 4256.89
c_2142_2143_i 2142 2142_2143 4.67522e-10
r_2702_2703_e 2702 2703 836.944
r_2702_2703_i 2702_2703 2703 4256.89
c_2702_2703_i 2702 2702_2703 4.67522e-10
r_3262_3263_e 3262 3263 13758.3
r_3262_3263_i 3262_3263 3263 95645.6
c_3262_3263_i 3262 3262_3263 9.36084e-12
r_3822_3823_e 3822 3823 13758.3
r_3822_3823_i 3822_3823 3823 95645.6
c_3822_3823_i 3822 3822_3823 9.36084e-12
r_463_464_e 463 464 13376.4
r_463_464_i 463_464 464 93218.1
c_463_464_i 463 463_464 2.08965e-09
r_1023_1024_e 1023 1024 13376.4
r_1023_1024_i 1023_1024 1024 93218.1
c_1023_1024_i 1023 1023_1024 2.08965e-09
r_1583_1584_e 1583 1584 836.944
r_1583_1584_i 1583_1584 1584 4256.89
c_1583_1584_i 1583 1583_1584 4.67522e-10
r_2143_2144_e 2143 2144 836.944
r_2143_2144_i 2143_2144 2144 4256.89
c_2143_2144_i 2143 2143_2144 4.67522e-10
r_2703_2704_e 2703 2704 836.944
r_2703_2704_i 2703_2704 2704 4256.89
c_2703_2704_i 2703 2703_2704 4.67522e-10
r_3263_3264_e 3263 3264 13758.3
r_3263_3264_i 3263_3264 3264 95645.6
c_3263_3264_i 3263 3263_3264 9.36084e-12
r_3823_3824_e 3823 3824 13758.3
r_3823_3824_i 3823_3824 3824 95645.6
c_3823_3824_i 3823 3823_3824 9.36084e-12
r_465_466_e 465 466 13376.4
r_465_466_i 465_466 466 93218.1
c_465_466_i 465 465_466 2.08965e-09
r_1025_1026_e 1025 1026 13376.4
r_1025_1026_i 1025_1026 1026 93218.1
c_1025_1026_i 1025 1025_1026 2.08965e-09
r_1585_1586_e 1585 1586 13376.4
r_1585_1586_i 1585_1586 1586 93218.1
c_1585_1586_i 1585 1585_1586 2.08965e-09
r_2145_2146_e 2145 2146 13376.4
r_2145_2146_i 2145_2146 2146 93218.1
c_2145_2146_i 2145 2145_2146 2.08965e-09
r_2705_2706_e 2705 2706 13376.4
r_2705_2706_i 2705_2706 2706 93218.1
c_2705_2706_i 2705 2705_2706 2.08965e-09
r_3265_3266_e 3265 3266 13376.4
r_3265_3266_i 3265_3266 3266 93218.1
c_3265_3266_i 3265 3265_3266 2.08965e-09
r_3825_3826_e 3825 3826 13376.4
r_3825_3826_i 3825_3826 3826 93218.1
c_3825_3826_i 3825 3825_3826 2.08965e-09
r_466_467_e 466 467 13376.4
r_466_467_i 466_467 467 93218.1
c_466_467_i 466 466_467 2.08965e-09
r_1026_1027_e 1026 1027 13376.4
r_1026_1027_i 1026_1027 1027 93218.1
c_1026_1027_i 1026 1026_1027 2.08965e-09
r_1586_1587_e 1586 1587 13376.4
r_1586_1587_i 1586_1587 1587 93218.1
c_1586_1587_i 1586 1586_1587 2.08965e-09
r_2146_2147_e 2146 2147 13376.4
r_2146_2147_i 2146_2147 2147 93218.1
c_2146_2147_i 2146 2146_2147 2.08965e-09
r_2706_2707_e 2706 2707 13376.4
r_2706_2707_i 2706_2707 2707 93218.1
c_2706_2707_i 2706 2706_2707 2.08965e-09
r_3266_3267_e 3266 3267 13376.4
r_3266_3267_i 3266_3267 3267 93218.1
c_3266_3267_i 3266 3266_3267 2.08965e-09
r_3826_3827_e 3826 3827 13376.4
r_3826_3827_i 3826_3827 3827 93218.1
c_3826_3827_i 3826 3826_3827 2.08965e-09
r_467_468_e 467 468 13376.4
r_467_468_i 467_468 468 93218.1
c_467_468_i 467 467_468 2.08965e-09
r_1027_1028_e 1027 1028 13376.4
r_1027_1028_i 1027_1028 1028 93218.1
c_1027_1028_i 1027 1027_1028 2.08965e-09
r_1587_1588_e 1587 1588 836.944
r_1587_1588_i 1587_1588 1588 4256.89
c_1587_1588_i 1587 1587_1588 4.67522e-10
r_2147_2148_e 2147 2148 836.944
r_2147_2148_i 2147_2148 2148 4256.89
c_2147_2148_i 2147 2147_2148 4.67522e-10
r_2707_2708_e 2707 2708 836.944
r_2707_2708_i 2707_2708 2708 4256.89
c_2707_2708_i 2707 2707_2708 4.67522e-10
r_3267_3268_e 3267 3268 836.944
r_3267_3268_i 3267_3268 3268 4256.89
c_3267_3268_i 3267 3267_3268 4.67522e-10
r_3827_3828_e 3827 3828 836.944
r_3827_3828_i 3827_3828 3828 4256.89
c_3827_3828_i 3827 3827_3828 4.67522e-10
r_468_469_e 468 469 13376.4
r_468_469_i 468_469 469 93218.1
c_468_469_i 468 468_469 2.08965e-09
r_1028_1029_e 1028 1029 13376.4
r_1028_1029_i 1028_1029 1029 93218.1
c_1028_1029_i 1028 1028_1029 2.08965e-09
r_1588_1589_e 1588 1589 836.944
r_1588_1589_i 1588_1589 1589 4256.89
c_1588_1589_i 1588 1588_1589 4.67522e-10
r_2148_2149_e 2148 2149 836.944
r_2148_2149_i 2148_2149 2149 4256.89
c_2148_2149_i 2148 2148_2149 4.67522e-10
r_2708_2709_e 2708 2709 836.944
r_2708_2709_i 2708_2709 2709 4256.89
c_2708_2709_i 2708 2708_2709 4.67522e-10
r_3268_3269_e 3268 3269 13758.3
r_3268_3269_i 3268_3269 3269 95645.6
c_3268_3269_i 3268 3268_3269 9.36084e-12
r_3828_3829_e 3828 3829 13758.3
r_3828_3829_i 3828_3829 3829 95645.6
c_3828_3829_i 3828 3828_3829 9.36084e-12
r_469_470_e 469 470 13376.4
r_469_470_i 469_470 470 93218.1
c_469_470_i 469 469_470 2.08965e-09
r_1029_1030_e 1029 1030 13376.4
r_1029_1030_i 1029_1030 1030 93218.1
c_1029_1030_i 1029 1029_1030 2.08965e-09
r_1589_1590_e 1589 1590 836.944
r_1589_1590_i 1589_1590 1590 4256.89
c_1589_1590_i 1589 1589_1590 4.67522e-10
r_2149_2150_e 2149 2150 836.944
r_2149_2150_i 2149_2150 2150 4256.89
c_2149_2150_i 2149 2149_2150 4.67522e-10
r_2709_2710_e 2709 2710 836.944
r_2709_2710_i 2709_2710 2710 4256.89
c_2709_2710_i 2709 2709_2710 4.67522e-10
r_3269_3270_e 3269 3270 13758.3
r_3269_3270_i 3269_3270 3270 95645.6
c_3269_3270_i 3269 3269_3270 9.36084e-12
r_3829_3830_e 3829 3830 13758.3
r_3829_3830_i 3829_3830 3830 95645.6
c_3829_3830_i 3829 3829_3830 9.36084e-12
r_470_471_e 470 471 13376.4
r_470_471_i 470_471 471 93218.1
c_470_471_i 470 470_471 2.08965e-09
r_1030_1031_e 1030 1031 13376.4
r_1030_1031_i 1030_1031 1031 93218.1
c_1030_1031_i 1030 1030_1031 2.08965e-09
r_1590_1591_e 1590 1591 836.944
r_1590_1591_i 1590_1591 1591 4256.89
c_1590_1591_i 1590 1590_1591 4.67522e-10
r_2150_2151_e 2150 2151 836.944
r_2150_2151_i 2150_2151 2151 4256.89
c_2150_2151_i 2150 2150_2151 4.67522e-10
r_2710_2711_e 2710 2711 836.944
r_2710_2711_i 2710_2711 2711 4256.89
c_2710_2711_i 2710 2710_2711 4.67522e-10
r_3270_3271_e 3270 3271 13758.3
r_3270_3271_i 3270_3271 3271 95645.6
c_3270_3271_i 3270 3270_3271 9.36084e-12
r_3830_3831_e 3830 3831 13758.3
r_3830_3831_i 3830_3831 3831 95645.6
c_3830_3831_i 3830 3830_3831 9.36084e-12
r_471_472_e 471 472 13376.4
r_471_472_i 471_472 472 93218.1
c_471_472_i 471 471_472 2.08965e-09
r_1031_1032_e 1031 1032 13376.4
r_1031_1032_i 1031_1032 1032 93218.1
c_1031_1032_i 1031 1031_1032 2.08965e-09
r_1591_1592_e 1591 1592 836.944
r_1591_1592_i 1591_1592 1592 4256.89
c_1591_1592_i 1591 1591_1592 4.67522e-10
r_2151_2152_e 2151 2152 836.944
r_2151_2152_i 2151_2152 2152 4256.89
c_2151_2152_i 2151 2151_2152 4.67522e-10
r_2711_2712_e 2711 2712 836.944
r_2711_2712_i 2711_2712 2712 4256.89
c_2711_2712_i 2711 2711_2712 4.67522e-10
r_3271_3272_e 3271 3272 13758.3
r_3271_3272_i 3271_3272 3272 95645.6
c_3271_3272_i 3271 3271_3272 9.36084e-12
r_3831_3832_e 3831 3832 13758.3
r_3831_3832_i 3831_3832 3832 95645.6
c_3831_3832_i 3831 3831_3832 9.36084e-12
r_472_473_e 472 473 13376.4
r_472_473_i 472_473 473 93218.1
c_472_473_i 472 472_473 2.08965e-09
r_1032_1033_e 1032 1033 13376.4
r_1032_1033_i 1032_1033 1033 93218.1
c_1032_1033_i 1032 1032_1033 2.08965e-09
r_1592_1593_e 1592 1593 836.944
r_1592_1593_i 1592_1593 1593 4256.89
c_1592_1593_i 1592 1592_1593 4.67522e-10
r_2152_2153_e 2152 2153 836.944
r_2152_2153_i 2152_2153 2153 4256.89
c_2152_2153_i 2152 2152_2153 4.67522e-10
r_2712_2713_e 2712 2713 836.944
r_2712_2713_i 2712_2713 2713 4256.89
c_2712_2713_i 2712 2712_2713 4.67522e-10
r_3272_3273_e 3272 3273 13758.3
r_3272_3273_i 3272_3273 3273 95645.6
c_3272_3273_i 3272 3272_3273 9.36084e-12
r_3832_3833_e 3832 3833 13758.3
r_3832_3833_i 3832_3833 3833 95645.6
c_3832_3833_i 3832 3832_3833 9.36084e-12
r_473_474_e 473 474 13376.4
r_473_474_i 473_474 474 93218.1
c_473_474_i 473 473_474 2.08965e-09
r_1033_1034_e 1033 1034 13376.4
r_1033_1034_i 1033_1034 1034 93218.1
c_1033_1034_i 1033 1033_1034 2.08965e-09
r_1593_1594_e 1593 1594 836.944
r_1593_1594_i 1593_1594 1594 4256.89
c_1593_1594_i 1593 1593_1594 4.67522e-10
r_2153_2154_e 2153 2154 836.944
r_2153_2154_i 2153_2154 2154 4256.89
c_2153_2154_i 2153 2153_2154 4.67522e-10
r_2713_2714_e 2713 2714 836.944
r_2713_2714_i 2713_2714 2714 4256.89
c_2713_2714_i 2713 2713_2714 4.67522e-10
r_3273_3274_e 3273 3274 13758.3
r_3273_3274_i 3273_3274 3274 95645.6
c_3273_3274_i 3273 3273_3274 9.36084e-12
r_3833_3834_e 3833 3834 13758.3
r_3833_3834_i 3833_3834 3834 95645.6
c_3833_3834_i 3833 3833_3834 9.36084e-12
r_474_475_e 474 475 13376.4
r_474_475_i 474_475 475 93218.1
c_474_475_i 474 474_475 2.08965e-09
r_1034_1035_e 1034 1035 13376.4
r_1034_1035_i 1034_1035 1035 93218.1
c_1034_1035_i 1034 1034_1035 2.08965e-09
r_1594_1595_e 1594 1595 836.944
r_1594_1595_i 1594_1595 1595 4256.89
c_1594_1595_i 1594 1594_1595 4.67522e-10
r_2154_2155_e 2154 2155 836.944
r_2154_2155_i 2154_2155 2155 4256.89
c_2154_2155_i 2154 2154_2155 4.67522e-10
r_2714_2715_e 2714 2715 836.944
r_2714_2715_i 2714_2715 2715 4256.89
c_2714_2715_i 2714 2714_2715 4.67522e-10
r_3274_3275_e 3274 3275 13758.3
r_3274_3275_i 3274_3275 3275 95645.6
c_3274_3275_i 3274 3274_3275 9.36084e-12
r_3834_3835_e 3834 3835 13758.3
r_3834_3835_i 3834_3835 3835 95645.6
c_3834_3835_i 3834 3834_3835 9.36084e-12
r_475_476_e 475 476 13376.4
r_475_476_i 475_476 476 93218.1
c_475_476_i 475 475_476 2.08965e-09
r_1035_1036_e 1035 1036 396.526
r_1035_1036_i 1035_1036 1036 1004.84
c_1035_1036_i 1035 1035_1036 1.65866e-10
r_1595_1596_e 1595 1596 396.526
r_1595_1596_i 1595_1596 1596 1004.84
c_1595_1596_i 1595 1595_1596 1.65866e-10
r_2155_2156_e 2155 2156 836.944
r_2155_2156_i 2155_2156 2156 4256.89
c_2155_2156_i 2155 2155_2156 4.67522e-10
r_2715_2716_e 2715 2716 836.944
r_2715_2716_i 2715_2716 2716 4256.89
c_2715_2716_i 2715 2715_2716 4.67522e-10
r_3275_3276_e 3275 3276 13758.3
r_3275_3276_i 3275_3276 3276 95645.6
c_3275_3276_i 3275 3275_3276 9.36084e-12
r_3835_3836_e 3835 3836 13758.3
r_3835_3836_i 3835_3836 3836 95645.6
c_3835_3836_i 3835 3835_3836 9.36084e-12
r_476_477_e 476 477 13376.4
r_476_477_i 476_477 477 93218.1
c_476_477_i 476 476_477 2.08965e-09
r_1036_1037_e 1036 1037 13376.4
r_1036_1037_i 1036_1037 1037 93218.1
c_1036_1037_i 1036 1036_1037 2.08965e-09
r_1596_1597_e 1596 1597 836.944
r_1596_1597_i 1596_1597 1597 4256.89
c_1596_1597_i 1596 1596_1597 4.67522e-10
r_2156_2157_e 2156 2157 836.944
r_2156_2157_i 2156_2157 2157 4256.89
c_2156_2157_i 2156 2156_2157 4.67522e-10
r_2716_2717_e 2716 2717 836.944
r_2716_2717_i 2716_2717 2717 4256.89
c_2716_2717_i 2716 2716_2717 4.67522e-10
r_3276_3277_e 3276 3277 13758.3
r_3276_3277_i 3276_3277 3277 95645.6
c_3276_3277_i 3276 3276_3277 9.36084e-12
r_3836_3837_e 3836 3837 13758.3
r_3836_3837_i 3836_3837 3837 95645.6
c_3836_3837_i 3836 3836_3837 9.36084e-12
r_477_478_e 477 478 13376.4
r_477_478_i 477_478 478 93218.1
c_477_478_i 477 477_478 2.08965e-09
r_1037_1038_e 1037 1038 13376.4
r_1037_1038_i 1037_1038 1038 93218.1
c_1037_1038_i 1037 1037_1038 2.08965e-09
r_1597_1598_e 1597 1598 836.944
r_1597_1598_i 1597_1598 1598 4256.89
c_1597_1598_i 1597 1597_1598 4.67522e-10
r_2157_2158_e 2157 2158 836.944
r_2157_2158_i 2157_2158 2158 4256.89
c_2157_2158_i 2157 2157_2158 4.67522e-10
r_2717_2718_e 2717 2718 836.944
r_2717_2718_i 2717_2718 2718 4256.89
c_2717_2718_i 2717 2717_2718 4.67522e-10
r_3277_3278_e 3277 3278 13758.3
r_3277_3278_i 3277_3278 3278 95645.6
c_3277_3278_i 3277 3277_3278 9.36084e-12
r_3837_3838_e 3837 3838 13758.3
r_3837_3838_i 3837_3838 3838 95645.6
c_3837_3838_i 3837 3837_3838 9.36084e-12
r_478_479_e 478 479 13376.4
r_478_479_i 478_479 479 93218.1
c_478_479_i 478 478_479 2.08965e-09
r_1038_1039_e 1038 1039 13376.4
r_1038_1039_i 1038_1039 1039 93218.1
c_1038_1039_i 1038 1038_1039 2.08965e-09
r_1598_1599_e 1598 1599 836.944
r_1598_1599_i 1598_1599 1599 4256.89
c_1598_1599_i 1598 1598_1599 4.67522e-10
r_2158_2159_e 2158 2159 836.944
r_2158_2159_i 2158_2159 2159 4256.89
c_2158_2159_i 2158 2158_2159 4.67522e-10
r_2718_2719_e 2718 2719 836.944
r_2718_2719_i 2718_2719 2719 4256.89
c_2718_2719_i 2718 2718_2719 4.67522e-10
r_3278_3279_e 3278 3279 13758.3
r_3278_3279_i 3278_3279 3279 95645.6
c_3278_3279_i 3278 3278_3279 9.36084e-12
r_3838_3839_e 3838 3839 13758.3
r_3838_3839_i 3838_3839 3839 95645.6
c_3838_3839_i 3838 3838_3839 9.36084e-12
r_479_480_e 479 480 13376.4
r_479_480_i 479_480 480 93218.1
c_479_480_i 479 479_480 2.08965e-09
r_1039_1040_e 1039 1040 13376.4
r_1039_1040_i 1039_1040 1040 93218.1
c_1039_1040_i 1039 1039_1040 2.08965e-09
r_1599_1600_e 1599 1600 836.944
r_1599_1600_i 1599_1600 1600 4256.89
c_1599_1600_i 1599 1599_1600 4.67522e-10
r_2159_2160_e 2159 2160 836.944
r_2159_2160_i 2159_2160 2160 4256.89
c_2159_2160_i 2159 2159_2160 4.67522e-10
r_2719_2720_e 2719 2720 836.944
r_2719_2720_i 2719_2720 2720 4256.89
c_2719_2720_i 2719 2719_2720 4.67522e-10
r_3279_3280_e 3279 3280 13758.3
r_3279_3280_i 3279_3280 3280 95645.6
c_3279_3280_i 3279 3279_3280 9.36084e-12
r_3839_3840_e 3839 3840 13758.3
r_3839_3840_i 3839_3840 3840 95645.6
c_3839_3840_i 3839 3839_3840 9.36084e-12
r_481_482_e 481 482 13376.4
r_481_482_i 481_482 482 93218.1
c_481_482_i 481 481_482 2.08965e-09
r_1041_1042_e 1041 1042 13376.4
r_1041_1042_i 1041_1042 1042 93218.1
c_1041_1042_i 1041 1041_1042 2.08965e-09
r_1601_1602_e 1601 1602 13376.4
r_1601_1602_i 1601_1602 1602 93218.1
c_1601_1602_i 1601 1601_1602 2.08965e-09
r_2161_2162_e 2161 2162 13376.4
r_2161_2162_i 2161_2162 2162 93218.1
c_2161_2162_i 2161 2161_2162 2.08965e-09
r_2721_2722_e 2721 2722 13376.4
r_2721_2722_i 2721_2722 2722 93218.1
c_2721_2722_i 2721 2721_2722 2.08965e-09
r_3281_3282_e 3281 3282 13376.4
r_3281_3282_i 3281_3282 3282 93218.1
c_3281_3282_i 3281 3281_3282 2.08965e-09
r_3841_3842_e 3841 3842 13376.4
r_3841_3842_i 3841_3842 3842 93218.1
c_3841_3842_i 3841 3841_3842 2.08965e-09
r_482_483_e 482 483 13376.4
r_482_483_i 482_483 483 93218.1
c_482_483_i 482 482_483 2.08965e-09
r_1042_1043_e 1042 1043 13376.4
r_1042_1043_i 1042_1043 1043 93218.1
c_1042_1043_i 1042 1042_1043 2.08965e-09
r_1602_1603_e 1602 1603 13376.4
r_1602_1603_i 1602_1603 1603 93218.1
c_1602_1603_i 1602 1602_1603 2.08965e-09
r_2162_2163_e 2162 2163 13376.4
r_2162_2163_i 2162_2163 2163 93218.1
c_2162_2163_i 2162 2162_2163 2.08965e-09
r_2722_2723_e 2722 2723 13376.4
r_2722_2723_i 2722_2723 2723 93218.1
c_2722_2723_i 2722 2722_2723 2.08965e-09
r_3282_3283_e 3282 3283 13376.4
r_3282_3283_i 3282_3283 3283 93218.1
c_3282_3283_i 3282 3282_3283 2.08965e-09
r_3842_3843_e 3842 3843 13376.4
r_3842_3843_i 3842_3843 3843 93218.1
c_3842_3843_i 3842 3842_3843 2.08965e-09
r_483_484_e 483 484 13376.4
r_483_484_i 483_484 484 93218.1
c_483_484_i 483 483_484 2.08965e-09
r_1043_1044_e 1043 1044 13376.4
r_1043_1044_i 1043_1044 1044 93218.1
c_1043_1044_i 1043 1043_1044 2.08965e-09
r_1603_1604_e 1603 1604 836.944
r_1603_1604_i 1603_1604 1604 4256.89
c_1603_1604_i 1603 1603_1604 4.67522e-10
r_2163_2164_e 2163 2164 836.944
r_2163_2164_i 2163_2164 2164 4256.89
c_2163_2164_i 2163 2163_2164 4.67522e-10
r_2723_2724_e 2723 2724 836.944
r_2723_2724_i 2723_2724 2724 4256.89
c_2723_2724_i 2723 2723_2724 4.67522e-10
r_3283_3284_e 3283 3284 836.944
r_3283_3284_i 3283_3284 3284 4256.89
c_3283_3284_i 3283 3283_3284 4.67522e-10
r_3843_3844_e 3843 3844 836.944
r_3843_3844_i 3843_3844 3844 4256.89
c_3843_3844_i 3843 3843_3844 4.67522e-10
r_484_485_e 484 485 13376.4
r_484_485_i 484_485 485 93218.1
c_484_485_i 484 484_485 2.08965e-09
r_1044_1045_e 1044 1045 13376.4
r_1044_1045_i 1044_1045 1045 93218.1
c_1044_1045_i 1044 1044_1045 2.08965e-09
r_1604_1605_e 1604 1605 836.944
r_1604_1605_i 1604_1605 1605 4256.89
c_1604_1605_i 1604 1604_1605 4.67522e-10
r_2164_2165_e 2164 2165 836.944
r_2164_2165_i 2164_2165 2165 4256.89
c_2164_2165_i 2164 2164_2165 4.67522e-10
r_2724_2725_e 2724 2725 836.944
r_2724_2725_i 2724_2725 2725 4256.89
c_2724_2725_i 2724 2724_2725 4.67522e-10
r_3284_3285_e 3284 3285 13758.3
r_3284_3285_i 3284_3285 3285 95645.6
c_3284_3285_i 3284 3284_3285 9.36084e-12
r_3844_3845_e 3844 3845 13758.3
r_3844_3845_i 3844_3845 3845 95645.6
c_3844_3845_i 3844 3844_3845 9.36084e-12
r_485_486_e 485 486 13376.4
r_485_486_i 485_486 486 93218.1
c_485_486_i 485 485_486 2.08965e-09
r_1045_1046_e 1045 1046 13376.4
r_1045_1046_i 1045_1046 1046 93218.1
c_1045_1046_i 1045 1045_1046 2.08965e-09
r_1605_1606_e 1605 1606 836.944
r_1605_1606_i 1605_1606 1606 4256.89
c_1605_1606_i 1605 1605_1606 4.67522e-10
r_2165_2166_e 2165 2166 836.944
r_2165_2166_i 2165_2166 2166 4256.89
c_2165_2166_i 2165 2165_2166 4.67522e-10
r_2725_2726_e 2725 2726 836.944
r_2725_2726_i 2725_2726 2726 4256.89
c_2725_2726_i 2725 2725_2726 4.67522e-10
r_3285_3286_e 3285 3286 13758.3
r_3285_3286_i 3285_3286 3286 95645.6
c_3285_3286_i 3285 3285_3286 9.36084e-12
r_3845_3846_e 3845 3846 13758.3
r_3845_3846_i 3845_3846 3846 95645.6
c_3845_3846_i 3845 3845_3846 9.36084e-12
r_486_487_e 486 487 13376.4
r_486_487_i 486_487 487 93218.1
c_486_487_i 486 486_487 2.08965e-09
r_1046_1047_e 1046 1047 13376.4
r_1046_1047_i 1046_1047 1047 93218.1
c_1046_1047_i 1046 1046_1047 2.08965e-09
r_1606_1607_e 1606 1607 836.944
r_1606_1607_i 1606_1607 1607 4256.89
c_1606_1607_i 1606 1606_1607 4.67522e-10
r_2166_2167_e 2166 2167 836.944
r_2166_2167_i 2166_2167 2167 4256.89
c_2166_2167_i 2166 2166_2167 4.67522e-10
r_2726_2727_e 2726 2727 836.944
r_2726_2727_i 2726_2727 2727 4256.89
c_2726_2727_i 2726 2726_2727 4.67522e-10
r_3286_3287_e 3286 3287 13758.3
r_3286_3287_i 3286_3287 3287 95645.6
c_3286_3287_i 3286 3286_3287 9.36084e-12
r_3846_3847_e 3846 3847 13758.3
r_3846_3847_i 3846_3847 3847 95645.6
c_3846_3847_i 3846 3846_3847 9.36084e-12
r_487_488_e 487 488 13376.4
r_487_488_i 487_488 488 93218.1
c_487_488_i 487 487_488 2.08965e-09
r_1047_1048_e 1047 1048 13376.4
r_1047_1048_i 1047_1048 1048 93218.1
c_1047_1048_i 1047 1047_1048 2.08965e-09
r_1607_1608_e 1607 1608 836.944
r_1607_1608_i 1607_1608 1608 4256.89
c_1607_1608_i 1607 1607_1608 4.67522e-10
r_2167_2168_e 2167 2168 836.944
r_2167_2168_i 2167_2168 2168 4256.89
c_2167_2168_i 2167 2167_2168 4.67522e-10
r_2727_2728_e 2727 2728 836.944
r_2727_2728_i 2727_2728 2728 4256.89
c_2727_2728_i 2727 2727_2728 4.67522e-10
r_3287_3288_e 3287 3288 13758.3
r_3287_3288_i 3287_3288 3288 95645.6
c_3287_3288_i 3287 3287_3288 9.36084e-12
r_3847_3848_e 3847 3848 13758.3
r_3847_3848_i 3847_3848 3848 95645.6
c_3847_3848_i 3847 3847_3848 9.36084e-12
r_488_489_e 488 489 13376.4
r_488_489_i 488_489 489 93218.1
c_488_489_i 488 488_489 2.08965e-09
r_1048_1049_e 1048 1049 13376.4
r_1048_1049_i 1048_1049 1049 93218.1
c_1048_1049_i 1048 1048_1049 2.08965e-09
r_1608_1609_e 1608 1609 836.944
r_1608_1609_i 1608_1609 1609 4256.89
c_1608_1609_i 1608 1608_1609 4.67522e-10
r_2168_2169_e 2168 2169 836.944
r_2168_2169_i 2168_2169 2169 4256.89
c_2168_2169_i 2168 2168_2169 4.67522e-10
r_2728_2729_e 2728 2729 836.944
r_2728_2729_i 2728_2729 2729 4256.89
c_2728_2729_i 2728 2728_2729 4.67522e-10
r_3288_3289_e 3288 3289 13758.3
r_3288_3289_i 3288_3289 3289 95645.6
c_3288_3289_i 3288 3288_3289 9.36084e-12
r_3848_3849_e 3848 3849 13758.3
r_3848_3849_i 3848_3849 3849 95645.6
c_3848_3849_i 3848 3848_3849 9.36084e-12
r_489_490_e 489 490 13376.4
r_489_490_i 489_490 490 93218.1
c_489_490_i 489 489_490 2.08965e-09
r_1049_1050_e 1049 1050 13376.4
r_1049_1050_i 1049_1050 1050 93218.1
c_1049_1050_i 1049 1049_1050 2.08965e-09
r_1609_1610_e 1609 1610 836.944
r_1609_1610_i 1609_1610 1610 4256.89
c_1609_1610_i 1609 1609_1610 4.67522e-10
r_2169_2170_e 2169 2170 836.944
r_2169_2170_i 2169_2170 2170 4256.89
c_2169_2170_i 2169 2169_2170 4.67522e-10
r_2729_2730_e 2729 2730 836.944
r_2729_2730_i 2729_2730 2730 4256.89
c_2729_2730_i 2729 2729_2730 4.67522e-10
r_3289_3290_e 3289 3290 13758.3
r_3289_3290_i 3289_3290 3290 95645.6
c_3289_3290_i 3289 3289_3290 9.36084e-12
r_3849_3850_e 3849 3850 13758.3
r_3849_3850_i 3849_3850 3850 95645.6
c_3849_3850_i 3849 3849_3850 9.36084e-12
r_490_491_e 490 491 13376.4
r_490_491_i 490_491 491 93218.1
c_490_491_i 490 490_491 2.08965e-09
r_1050_1051_e 1050 1051 13376.4
r_1050_1051_i 1050_1051 1051 93218.1
c_1050_1051_i 1050 1050_1051 2.08965e-09
r_1610_1611_e 1610 1611 836.944
r_1610_1611_i 1610_1611 1611 4256.89
c_1610_1611_i 1610 1610_1611 4.67522e-10
r_2170_2171_e 2170 2171 836.944
r_2170_2171_i 2170_2171 2171 4256.89
c_2170_2171_i 2170 2170_2171 4.67522e-10
r_2730_2731_e 2730 2731 836.944
r_2730_2731_i 2730_2731 2731 4256.89
c_2730_2731_i 2730 2730_2731 4.67522e-10
r_3290_3291_e 3290 3291 13758.3
r_3290_3291_i 3290_3291 3291 95645.6
c_3290_3291_i 3290 3290_3291 9.36084e-12
r_3850_3851_e 3850 3851 13758.3
r_3850_3851_i 3850_3851 3851 95645.6
c_3850_3851_i 3850 3850_3851 9.36084e-12
r_491_492_e 491 492 13376.4
r_491_492_i 491_492 492 93218.1
c_491_492_i 491 491_492 2.08965e-09
r_1051_1052_e 1051 1052 396.518
r_1051_1052_i 1051_1052 1052 1004.81
c_1051_1052_i 1051 1051_1052 1.65869e-10
r_1611_1612_e 1611 1612 396.518
r_1611_1612_i 1611_1612 1612 1004.81
c_1611_1612_i 1611 1611_1612 1.65869e-10
r_2171_2172_e 2171 2172 836.944
r_2171_2172_i 2171_2172 2172 4256.89
c_2171_2172_i 2171 2171_2172 4.67522e-10
r_2731_2732_e 2731 2732 836.944
r_2731_2732_i 2731_2732 2732 4256.89
c_2731_2732_i 2731 2731_2732 4.67522e-10
r_3291_3292_e 3291 3292 13758.3
r_3291_3292_i 3291_3292 3292 95645.6
c_3291_3292_i 3291 3291_3292 9.36084e-12
r_3851_3852_e 3851 3852 13758.3
r_3851_3852_i 3851_3852 3852 95645.6
c_3851_3852_i 3851 3851_3852 9.36084e-12
r_492_493_e 492 493 13376.4
r_492_493_i 492_493 493 93218.1
c_492_493_i 492 492_493 2.08965e-09
r_1052_1053_e 1052 1053 13376.4
r_1052_1053_i 1052_1053 1053 93218.1
c_1052_1053_i 1052 1052_1053 2.08965e-09
r_1612_1613_e 1612 1613 836.944
r_1612_1613_i 1612_1613 1613 4256.89
c_1612_1613_i 1612 1612_1613 4.67522e-10
r_2172_2173_e 2172 2173 836.944
r_2172_2173_i 2172_2173 2173 4256.89
c_2172_2173_i 2172 2172_2173 4.67522e-10
r_2732_2733_e 2732 2733 836.944
r_2732_2733_i 2732_2733 2733 4256.89
c_2732_2733_i 2732 2732_2733 4.67522e-10
r_3292_3293_e 3292 3293 13758.3
r_3292_3293_i 3292_3293 3293 95645.6
c_3292_3293_i 3292 3292_3293 9.36084e-12
r_3852_3853_e 3852 3853 13758.3
r_3852_3853_i 3852_3853 3853 95645.6
c_3852_3853_i 3852 3852_3853 9.36084e-12
r_493_494_e 493 494 13376.4
r_493_494_i 493_494 494 93218.1
c_493_494_i 493 493_494 2.08965e-09
r_1053_1054_e 1053 1054 13376.4
r_1053_1054_i 1053_1054 1054 93218.1
c_1053_1054_i 1053 1053_1054 2.08965e-09
r_1613_1614_e 1613 1614 836.944
r_1613_1614_i 1613_1614 1614 4256.89
c_1613_1614_i 1613 1613_1614 4.67522e-10
r_2173_2174_e 2173 2174 836.944
r_2173_2174_i 2173_2174 2174 4256.89
c_2173_2174_i 2173 2173_2174 4.67522e-10
r_2733_2734_e 2733 2734 836.944
r_2733_2734_i 2733_2734 2734 4256.89
c_2733_2734_i 2733 2733_2734 4.67522e-10
r_3293_3294_e 3293 3294 13758.3
r_3293_3294_i 3293_3294 3294 95645.6
c_3293_3294_i 3293 3293_3294 9.36084e-12
r_3853_3854_e 3853 3854 13758.3
r_3853_3854_i 3853_3854 3854 95645.6
c_3853_3854_i 3853 3853_3854 9.36084e-12
r_494_495_e 494 495 13376.4
r_494_495_i 494_495 495 93218.1
c_494_495_i 494 494_495 2.08965e-09
r_1054_1055_e 1054 1055 13376.4
r_1054_1055_i 1054_1055 1055 93218.1
c_1054_1055_i 1054 1054_1055 2.08965e-09
r_1614_1615_e 1614 1615 836.944
r_1614_1615_i 1614_1615 1615 4256.89
c_1614_1615_i 1614 1614_1615 4.67522e-10
r_2174_2175_e 2174 2175 836.944
r_2174_2175_i 2174_2175 2175 4256.89
c_2174_2175_i 2174 2174_2175 4.67522e-10
r_2734_2735_e 2734 2735 836.944
r_2734_2735_i 2734_2735 2735 4256.89
c_2734_2735_i 2734 2734_2735 4.67522e-10
r_3294_3295_e 3294 3295 13758.3
r_3294_3295_i 3294_3295 3295 95645.6
c_3294_3295_i 3294 3294_3295 9.36084e-12
r_3854_3855_e 3854 3855 13758.3
r_3854_3855_i 3854_3855 3855 95645.6
c_3854_3855_i 3854 3854_3855 9.36084e-12
r_495_496_e 495 496 13376.4
r_495_496_i 495_496 496 93218.1
c_495_496_i 495 495_496 2.08965e-09
r_1055_1056_e 1055 1056 13376.4
r_1055_1056_i 1055_1056 1056 93218.1
c_1055_1056_i 1055 1055_1056 2.08965e-09
r_1615_1616_e 1615 1616 836.944
r_1615_1616_i 1615_1616 1616 4256.89
c_1615_1616_i 1615 1615_1616 4.67522e-10
r_2175_2176_e 2175 2176 836.944
r_2175_2176_i 2175_2176 2176 4256.89
c_2175_2176_i 2175 2175_2176 4.67522e-10
r_2735_2736_e 2735 2736 836.944
r_2735_2736_i 2735_2736 2736 4256.89
c_2735_2736_i 2735 2735_2736 4.67522e-10
r_3295_3296_e 3295 3296 13758.3
r_3295_3296_i 3295_3296 3296 95645.6
c_3295_3296_i 3295 3295_3296 9.36084e-12
r_3855_3856_e 3855 3856 13758.3
r_3855_3856_i 3855_3856 3856 95645.6
c_3855_3856_i 3855 3855_3856 9.36084e-12
r_497_498_e 497 498 13376.4
r_497_498_i 497_498 498 93218.1
c_497_498_i 497 497_498 2.08965e-09
r_1057_1058_e 1057 1058 13376.4
r_1057_1058_i 1057_1058 1058 93218.1
c_1057_1058_i 1057 1057_1058 2.08965e-09
r_1617_1618_e 1617 1618 13376.4
r_1617_1618_i 1617_1618 1618 93218.1
c_1617_1618_i 1617 1617_1618 2.08965e-09
r_2177_2178_e 2177 2178 13376.4
r_2177_2178_i 2177_2178 2178 93218.1
c_2177_2178_i 2177 2177_2178 2.08965e-09
r_2737_2738_e 2737 2738 13376.4
r_2737_2738_i 2737_2738 2738 93218.1
c_2737_2738_i 2737 2737_2738 2.08965e-09
r_3297_3298_e 3297 3298 13376.4
r_3297_3298_i 3297_3298 3298 93218.1
c_3297_3298_i 3297 3297_3298 2.08965e-09
r_3857_3858_e 3857 3858 13376.4
r_3857_3858_i 3857_3858 3858 93218.1
c_3857_3858_i 3857 3857_3858 2.08965e-09
r_498_499_e 498 499 13376.4
r_498_499_i 498_499 499 93218.1
c_498_499_i 498 498_499 2.08965e-09
r_1058_1059_e 1058 1059 13376.4
r_1058_1059_i 1058_1059 1059 93218.1
c_1058_1059_i 1058 1058_1059 2.08965e-09
r_1618_1619_e 1618 1619 13376.4
r_1618_1619_i 1618_1619 1619 93218.1
c_1618_1619_i 1618 1618_1619 2.08965e-09
r_2178_2179_e 2178 2179 13376.4
r_2178_2179_i 2178_2179 2179 93218.1
c_2178_2179_i 2178 2178_2179 2.08965e-09
r_2738_2739_e 2738 2739 13376.4
r_2738_2739_i 2738_2739 2739 93218.1
c_2738_2739_i 2738 2738_2739 2.08965e-09
r_3298_3299_e 3298 3299 13376.4
r_3298_3299_i 3298_3299 3299 93218.1
c_3298_3299_i 3298 3298_3299 2.08965e-09
r_3858_3859_e 3858 3859 13376.4
r_3858_3859_i 3858_3859 3859 93218.1
c_3858_3859_i 3858 3858_3859 2.08965e-09
r_499_500_e 499 500 13376.4
r_499_500_i 499_500 500 93218.1
c_499_500_i 499 499_500 2.08965e-09
r_1059_1060_e 1059 1060 13376.4
r_1059_1060_i 1059_1060 1060 93218.1
c_1059_1060_i 1059 1059_1060 2.08965e-09
r_1619_1620_e 1619 1620 836.944
r_1619_1620_i 1619_1620 1620 4256.89
c_1619_1620_i 1619 1619_1620 4.67522e-10
r_2179_2180_e 2179 2180 836.944
r_2179_2180_i 2179_2180 2180 4256.89
c_2179_2180_i 2179 2179_2180 4.67522e-10
r_2739_2740_e 2739 2740 836.944
r_2739_2740_i 2739_2740 2740 4256.89
c_2739_2740_i 2739 2739_2740 4.67522e-10
r_3299_3300_e 3299 3300 836.944
r_3299_3300_i 3299_3300 3300 4256.89
c_3299_3300_i 3299 3299_3300 4.67522e-10
r_3859_3860_e 3859 3860 836.944
r_3859_3860_i 3859_3860 3860 4256.89
c_3859_3860_i 3859 3859_3860 4.67522e-10
r_500_501_e 500 501 13376.4
r_500_501_i 500_501 501 93218.1
c_500_501_i 500 500_501 2.08965e-09
r_1060_1061_e 1060 1061 13376.4
r_1060_1061_i 1060_1061 1061 93218.1
c_1060_1061_i 1060 1060_1061 2.08965e-09
r_1620_1621_e 1620 1621 836.944
r_1620_1621_i 1620_1621 1621 4256.89
c_1620_1621_i 1620 1620_1621 4.67522e-10
r_2180_2181_e 2180 2181 836.944
r_2180_2181_i 2180_2181 2181 4256.89
c_2180_2181_i 2180 2180_2181 4.67522e-10
r_2740_2741_e 2740 2741 836.944
r_2740_2741_i 2740_2741 2741 4256.89
c_2740_2741_i 2740 2740_2741 4.67522e-10
r_3300_3301_e 3300 3301 13758.3
r_3300_3301_i 3300_3301 3301 95645.6
c_3300_3301_i 3300 3300_3301 9.36084e-12
r_3860_3861_e 3860 3861 13758.3
r_3860_3861_i 3860_3861 3861 95645.6
c_3860_3861_i 3860 3860_3861 9.36084e-12
r_501_502_e 501 502 13376.4
r_501_502_i 501_502 502 93218.1
c_501_502_i 501 501_502 2.08965e-09
r_1061_1062_e 1061 1062 13376.4
r_1061_1062_i 1061_1062 1062 93218.1
c_1061_1062_i 1061 1061_1062 2.08965e-09
r_1621_1622_e 1621 1622 836.944
r_1621_1622_i 1621_1622 1622 4256.89
c_1621_1622_i 1621 1621_1622 4.67522e-10
r_2181_2182_e 2181 2182 836.944
r_2181_2182_i 2181_2182 2182 4256.89
c_2181_2182_i 2181 2181_2182 4.67522e-10
r_2741_2742_e 2741 2742 836.944
r_2741_2742_i 2741_2742 2742 4256.89
c_2741_2742_i 2741 2741_2742 4.67522e-10
r_3301_3302_e 3301 3302 13758.3
r_3301_3302_i 3301_3302 3302 95645.6
c_3301_3302_i 3301 3301_3302 9.36084e-12
r_3861_3862_e 3861 3862 13758.3
r_3861_3862_i 3861_3862 3862 95645.6
c_3861_3862_i 3861 3861_3862 9.36084e-12
r_502_503_e 502 503 13376.4
r_502_503_i 502_503 503 93218.1
c_502_503_i 502 502_503 2.08965e-09
r_1062_1063_e 1062 1063 13376.4
r_1062_1063_i 1062_1063 1063 93218.1
c_1062_1063_i 1062 1062_1063 2.08965e-09
r_1622_1623_e 1622 1623 836.944
r_1622_1623_i 1622_1623 1623 4256.89
c_1622_1623_i 1622 1622_1623 4.67522e-10
r_2182_2183_e 2182 2183 836.944
r_2182_2183_i 2182_2183 2183 4256.89
c_2182_2183_i 2182 2182_2183 4.67522e-10
r_2742_2743_e 2742 2743 836.944
r_2742_2743_i 2742_2743 2743 4256.89
c_2742_2743_i 2742 2742_2743 4.67522e-10
r_3302_3303_e 3302 3303 13758.3
r_3302_3303_i 3302_3303 3303 95645.6
c_3302_3303_i 3302 3302_3303 9.36084e-12
r_3862_3863_e 3862 3863 13758.3
r_3862_3863_i 3862_3863 3863 95645.6
c_3862_3863_i 3862 3862_3863 9.36084e-12
r_503_504_e 503 504 13376.4
r_503_504_i 503_504 504 93218.1
c_503_504_i 503 503_504 2.08965e-09
r_1063_1064_e 1063 1064 13376.4
r_1063_1064_i 1063_1064 1064 93218.1
c_1063_1064_i 1063 1063_1064 2.08965e-09
r_1623_1624_e 1623 1624 836.944
r_1623_1624_i 1623_1624 1624 4256.89
c_1623_1624_i 1623 1623_1624 4.67522e-10
r_2183_2184_e 2183 2184 836.944
r_2183_2184_i 2183_2184 2184 4256.89
c_2183_2184_i 2183 2183_2184 4.67522e-10
r_2743_2744_e 2743 2744 836.944
r_2743_2744_i 2743_2744 2744 4256.89
c_2743_2744_i 2743 2743_2744 4.67522e-10
r_3303_3304_e 3303 3304 13758.3
r_3303_3304_i 3303_3304 3304 95645.6
c_3303_3304_i 3303 3303_3304 9.36084e-12
r_3863_3864_e 3863 3864 13758.3
r_3863_3864_i 3863_3864 3864 95645.6
c_3863_3864_i 3863 3863_3864 9.36084e-12
r_504_505_e 504 505 13376.4
r_504_505_i 504_505 505 93218.1
c_504_505_i 504 504_505 2.08965e-09
r_1064_1065_e 1064 1065 13376.4
r_1064_1065_i 1064_1065 1065 93218.1
c_1064_1065_i 1064 1064_1065 2.08965e-09
r_1624_1625_e 1624 1625 836.944
r_1624_1625_i 1624_1625 1625 4256.89
c_1624_1625_i 1624 1624_1625 4.67522e-10
r_2184_2185_e 2184 2185 836.944
r_2184_2185_i 2184_2185 2185 4256.89
c_2184_2185_i 2184 2184_2185 4.67522e-10
r_2744_2745_e 2744 2745 836.944
r_2744_2745_i 2744_2745 2745 4256.89
c_2744_2745_i 2744 2744_2745 4.67522e-10
r_3304_3305_e 3304 3305 13758.3
r_3304_3305_i 3304_3305 3305 95645.6
c_3304_3305_i 3304 3304_3305 9.36084e-12
r_3864_3865_e 3864 3865 13758.3
r_3864_3865_i 3864_3865 3865 95645.6
c_3864_3865_i 3864 3864_3865 9.36084e-12
r_505_506_e 505 506 13376.4
r_505_506_i 505_506 506 93218.1
c_505_506_i 505 505_506 2.08965e-09
r_1065_1066_e 1065 1066 13376.4
r_1065_1066_i 1065_1066 1066 93218.1
c_1065_1066_i 1065 1065_1066 2.08965e-09
r_1625_1626_e 1625 1626 836.944
r_1625_1626_i 1625_1626 1626 4256.89
c_1625_1626_i 1625 1625_1626 4.67522e-10
r_2185_2186_e 2185 2186 836.944
r_2185_2186_i 2185_2186 2186 4256.89
c_2185_2186_i 2185 2185_2186 4.67522e-10
r_2745_2746_e 2745 2746 836.944
r_2745_2746_i 2745_2746 2746 4256.89
c_2745_2746_i 2745 2745_2746 4.67522e-10
r_3305_3306_e 3305 3306 13758.3
r_3305_3306_i 3305_3306 3306 95645.6
c_3305_3306_i 3305 3305_3306 9.36084e-12
r_3865_3866_e 3865 3866 13758.3
r_3865_3866_i 3865_3866 3866 95645.6
c_3865_3866_i 3865 3865_3866 9.36084e-12
r_506_507_e 506 507 13376.4
r_506_507_i 506_507 507 93218.1
c_506_507_i 506 506_507 2.08965e-09
r_1066_1067_e 1066 1067 13376.4
r_1066_1067_i 1066_1067 1067 93218.1
c_1066_1067_i 1066 1066_1067 2.08965e-09
r_1626_1627_e 1626 1627 836.944
r_1626_1627_i 1626_1627 1627 4256.89
c_1626_1627_i 1626 1626_1627 4.67522e-10
r_2186_2187_e 2186 2187 836.944
r_2186_2187_i 2186_2187 2187 4256.89
c_2186_2187_i 2186 2186_2187 4.67522e-10
r_2746_2747_e 2746 2747 836.944
r_2746_2747_i 2746_2747 2747 4256.89
c_2746_2747_i 2746 2746_2747 4.67522e-10
r_3306_3307_e 3306 3307 13758.3
r_3306_3307_i 3306_3307 3307 95645.6
c_3306_3307_i 3306 3306_3307 9.36084e-12
r_3866_3867_e 3866 3867 13758.3
r_3866_3867_i 3866_3867 3867 95645.6
c_3866_3867_i 3866 3866_3867 9.36084e-12
r_507_508_e 507 508 13376.4
r_507_508_i 507_508 508 93218.1
c_507_508_i 507 507_508 2.08965e-09
r_1067_1068_e 1067 1068 396.51
r_1067_1068_i 1067_1068 1068 1004.79
c_1067_1068_i 1067 1067_1068 1.65873e-10
r_1627_1628_e 1627 1628 396.51
r_1627_1628_i 1627_1628 1628 1004.79
c_1627_1628_i 1627 1627_1628 1.65873e-10
r_2187_2188_e 2187 2188 836.944
r_2187_2188_i 2187_2188 2188 4256.89
c_2187_2188_i 2187 2187_2188 4.67522e-10
r_2747_2748_e 2747 2748 836.944
r_2747_2748_i 2747_2748 2748 4256.89
c_2747_2748_i 2747 2747_2748 4.67522e-10
r_3307_3308_e 3307 3308 13758.3
r_3307_3308_i 3307_3308 3308 95645.6
c_3307_3308_i 3307 3307_3308 9.36084e-12
r_3867_3868_e 3867 3868 13758.3
r_3867_3868_i 3867_3868 3868 95645.6
c_3867_3868_i 3867 3867_3868 9.36084e-12
r_508_509_e 508 509 13376.4
r_508_509_i 508_509 509 93218.1
c_508_509_i 508 508_509 2.08965e-09
r_1068_1069_e 1068 1069 13376.4
r_1068_1069_i 1068_1069 1069 93218.1
c_1068_1069_i 1068 1068_1069 2.08965e-09
r_1628_1629_e 1628 1629 836.944
r_1628_1629_i 1628_1629 1629 4256.89
c_1628_1629_i 1628 1628_1629 4.67522e-10
r_2188_2189_e 2188 2189 836.944
r_2188_2189_i 2188_2189 2189 4256.89
c_2188_2189_i 2188 2188_2189 4.67522e-10
r_2748_2749_e 2748 2749 836.944
r_2748_2749_i 2748_2749 2749 4256.89
c_2748_2749_i 2748 2748_2749 4.67522e-10
r_3308_3309_e 3308 3309 13758.3
r_3308_3309_i 3308_3309 3309 95645.6
c_3308_3309_i 3308 3308_3309 9.36084e-12
r_3868_3869_e 3868 3869 13758.3
r_3868_3869_i 3868_3869 3869 95645.6
c_3868_3869_i 3868 3868_3869 9.36084e-12
r_509_510_e 509 510 13376.4
r_509_510_i 509_510 510 93218.1
c_509_510_i 509 509_510 2.08965e-09
r_1069_1070_e 1069 1070 13376.4
r_1069_1070_i 1069_1070 1070 93218.1
c_1069_1070_i 1069 1069_1070 2.08965e-09
r_1629_1630_e 1629 1630 836.944
r_1629_1630_i 1629_1630 1630 4256.89
c_1629_1630_i 1629 1629_1630 4.67522e-10
r_2189_2190_e 2189 2190 836.944
r_2189_2190_i 2189_2190 2190 4256.89
c_2189_2190_i 2189 2189_2190 4.67522e-10
r_2749_2750_e 2749 2750 836.944
r_2749_2750_i 2749_2750 2750 4256.89
c_2749_2750_i 2749 2749_2750 4.67522e-10
r_3309_3310_e 3309 3310 13758.3
r_3309_3310_i 3309_3310 3310 95645.6
c_3309_3310_i 3309 3309_3310 9.36084e-12
r_3869_3870_e 3869 3870 13758.3
r_3869_3870_i 3869_3870 3870 95645.6
c_3869_3870_i 3869 3869_3870 9.36084e-12
r_510_511_e 510 511 13376.4
r_510_511_i 510_511 511 93218.1
c_510_511_i 510 510_511 2.08965e-09
r_1070_1071_e 1070 1071 13376.4
r_1070_1071_i 1070_1071 1071 93218.1
c_1070_1071_i 1070 1070_1071 2.08965e-09
r_1630_1631_e 1630 1631 836.944
r_1630_1631_i 1630_1631 1631 4256.89
c_1630_1631_i 1630 1630_1631 4.67522e-10
r_2190_2191_e 2190 2191 836.944
r_2190_2191_i 2190_2191 2191 4256.89
c_2190_2191_i 2190 2190_2191 4.67522e-10
r_2750_2751_e 2750 2751 836.944
r_2750_2751_i 2750_2751 2751 4256.89
c_2750_2751_i 2750 2750_2751 4.67522e-10
r_3310_3311_e 3310 3311 13758.3
r_3310_3311_i 3310_3311 3311 95645.6
c_3310_3311_i 3310 3310_3311 9.36084e-12
r_3870_3871_e 3870 3871 13758.3
r_3870_3871_i 3870_3871 3871 95645.6
c_3870_3871_i 3870 3870_3871 9.36084e-12
r_511_512_e 511 512 13376.4
r_511_512_i 511_512 512 93218.1
c_511_512_i 511 511_512 2.08965e-09
r_1071_1072_e 1071 1072 13376.4
r_1071_1072_i 1071_1072 1072 93218.1
c_1071_1072_i 1071 1071_1072 2.08965e-09
r_1631_1632_e 1631 1632 836.944
r_1631_1632_i 1631_1632 1632 4256.89
c_1631_1632_i 1631 1631_1632 4.67522e-10
r_2191_2192_e 2191 2192 836.944
r_2191_2192_i 2191_2192 2192 4256.89
c_2191_2192_i 2191 2191_2192 4.67522e-10
r_2751_2752_e 2751 2752 836.944
r_2751_2752_i 2751_2752 2752 4256.89
c_2751_2752_i 2751 2751_2752 4.67522e-10
r_3311_3312_e 3311 3312 13758.3
r_3311_3312_i 3311_3312 3312 95645.6
c_3311_3312_i 3311 3311_3312 9.36084e-12
r_3871_3872_e 3871 3872 13758.3
r_3871_3872_i 3871_3872 3872 95645.6
c_3871_3872_i 3871 3871_3872 9.36084e-12
r_513_514_e 513 514 13376.4
r_513_514_i 513_514 514 93218.1
c_513_514_i 513 513_514 2.08965e-09
r_1073_1074_e 1073 1074 13376.4
r_1073_1074_i 1073_1074 1074 93218.1
c_1073_1074_i 1073 1073_1074 2.08965e-09
r_1633_1634_e 1633 1634 13376.4
r_1633_1634_i 1633_1634 1634 93218.1
c_1633_1634_i 1633 1633_1634 2.08965e-09
r_2193_2194_e 2193 2194 13376.4
r_2193_2194_i 2193_2194 2194 93218.1
c_2193_2194_i 2193 2193_2194 2.08965e-09
r_2753_2754_e 2753 2754 13376.4
r_2753_2754_i 2753_2754 2754 93218.1
c_2753_2754_i 2753 2753_2754 2.08965e-09
r_3313_3314_e 3313 3314 13376.4
r_3313_3314_i 3313_3314 3314 93218.1
c_3313_3314_i 3313 3313_3314 2.08965e-09
r_3873_3874_e 3873 3874 13376.4
r_3873_3874_i 3873_3874 3874 93218.1
c_3873_3874_i 3873 3873_3874 2.08965e-09
r_514_515_e 514 515 13376.4
r_514_515_i 514_515 515 93218.1
c_514_515_i 514 514_515 2.08965e-09
r_1074_1075_e 1074 1075 13376.4
r_1074_1075_i 1074_1075 1075 93218.1
c_1074_1075_i 1074 1074_1075 2.08965e-09
r_1634_1635_e 1634 1635 13376.4
r_1634_1635_i 1634_1635 1635 93218.1
c_1634_1635_i 1634 1634_1635 2.08965e-09
r_2194_2195_e 2194 2195 13376.4
r_2194_2195_i 2194_2195 2195 93218.1
c_2194_2195_i 2194 2194_2195 2.08965e-09
r_2754_2755_e 2754 2755 13376.4
r_2754_2755_i 2754_2755 2755 93218.1
c_2754_2755_i 2754 2754_2755 2.08965e-09
r_3314_3315_e 3314 3315 13376.4
r_3314_3315_i 3314_3315 3315 93218.1
c_3314_3315_i 3314 3314_3315 2.08965e-09
r_3874_3875_e 3874 3875 13376.4
r_3874_3875_i 3874_3875 3875 93218.1
c_3874_3875_i 3874 3874_3875 2.08965e-09
r_515_516_e 515 516 13376.4
r_515_516_i 515_516 516 93218.1
c_515_516_i 515 515_516 2.08965e-09
r_1075_1076_e 1075 1076 13376.4
r_1075_1076_i 1075_1076 1076 93218.1
c_1075_1076_i 1075 1075_1076 2.08965e-09
r_1635_1636_e 1635 1636 836.944
r_1635_1636_i 1635_1636 1636 4256.89
c_1635_1636_i 1635 1635_1636 4.67522e-10
r_2195_2196_e 2195 2196 836.944
r_2195_2196_i 2195_2196 2196 4256.89
c_2195_2196_i 2195 2195_2196 4.67522e-10
r_2755_2756_e 2755 2756 836.944
r_2755_2756_i 2755_2756 2756 4256.89
c_2755_2756_i 2755 2755_2756 4.67522e-10
r_3315_3316_e 3315 3316 836.944
r_3315_3316_i 3315_3316 3316 4256.89
c_3315_3316_i 3315 3315_3316 4.67522e-10
r_3875_3876_e 3875 3876 836.944
r_3875_3876_i 3875_3876 3876 4256.89
c_3875_3876_i 3875 3875_3876 4.67522e-10
r_516_517_e 516 517 13376.4
r_516_517_i 516_517 517 93218.1
c_516_517_i 516 516_517 2.08965e-09
r_1076_1077_e 1076 1077 13376.4
r_1076_1077_i 1076_1077 1077 93218.1
c_1076_1077_i 1076 1076_1077 2.08965e-09
r_1636_1637_e 1636 1637 836.944
r_1636_1637_i 1636_1637 1637 4256.89
c_1636_1637_i 1636 1636_1637 4.67522e-10
r_2196_2197_e 2196 2197 836.944
r_2196_2197_i 2196_2197 2197 4256.89
c_2196_2197_i 2196 2196_2197 4.67522e-10
r_2756_2757_e 2756 2757 836.944
r_2756_2757_i 2756_2757 2757 4256.89
c_2756_2757_i 2756 2756_2757 4.67522e-10
r_3316_3317_e 3316 3317 13758.3
r_3316_3317_i 3316_3317 3317 95645.6
c_3316_3317_i 3316 3316_3317 9.36084e-12
r_3876_3877_e 3876 3877 13758.3
r_3876_3877_i 3876_3877 3877 95645.6
c_3876_3877_i 3876 3876_3877 9.36084e-12
r_517_518_e 517 518 13376.4
r_517_518_i 517_518 518 93218.1
c_517_518_i 517 517_518 2.08965e-09
r_1077_1078_e 1077 1078 13376.4
r_1077_1078_i 1077_1078 1078 93218.1
c_1077_1078_i 1077 1077_1078 2.08965e-09
r_1637_1638_e 1637 1638 836.944
r_1637_1638_i 1637_1638 1638 4256.89
c_1637_1638_i 1637 1637_1638 4.67522e-10
r_2197_2198_e 2197 2198 836.944
r_2197_2198_i 2197_2198 2198 4256.89
c_2197_2198_i 2197 2197_2198 4.67522e-10
r_2757_2758_e 2757 2758 836.944
r_2757_2758_i 2757_2758 2758 4256.89
c_2757_2758_i 2757 2757_2758 4.67522e-10
r_3317_3318_e 3317 3318 13758.3
r_3317_3318_i 3317_3318 3318 95645.6
c_3317_3318_i 3317 3317_3318 9.36084e-12
r_3877_3878_e 3877 3878 13758.3
r_3877_3878_i 3877_3878 3878 95645.6
c_3877_3878_i 3877 3877_3878 9.36084e-12
r_518_519_e 518 519 13376.4
r_518_519_i 518_519 519 93218.1
c_518_519_i 518 518_519 2.08965e-09
r_1078_1079_e 1078 1079 13376.4
r_1078_1079_i 1078_1079 1079 93218.1
c_1078_1079_i 1078 1078_1079 2.08965e-09
r_1638_1639_e 1638 1639 836.944
r_1638_1639_i 1638_1639 1639 4256.89
c_1638_1639_i 1638 1638_1639 4.67522e-10
r_2198_2199_e 2198 2199 836.944
r_2198_2199_i 2198_2199 2199 4256.89
c_2198_2199_i 2198 2198_2199 4.67522e-10
r_2758_2759_e 2758 2759 836.944
r_2758_2759_i 2758_2759 2759 4256.89
c_2758_2759_i 2758 2758_2759 4.67522e-10
r_3318_3319_e 3318 3319 13758.3
r_3318_3319_i 3318_3319 3319 95645.6
c_3318_3319_i 3318 3318_3319 9.36084e-12
r_3878_3879_e 3878 3879 13758.3
r_3878_3879_i 3878_3879 3879 95645.6
c_3878_3879_i 3878 3878_3879 9.36084e-12
r_519_520_e 519 520 13376.4
r_519_520_i 519_520 520 93218.1
c_519_520_i 519 519_520 2.08965e-09
r_1079_1080_e 1079 1080 13376.4
r_1079_1080_i 1079_1080 1080 93218.1
c_1079_1080_i 1079 1079_1080 2.08965e-09
r_1639_1640_e 1639 1640 836.944
r_1639_1640_i 1639_1640 1640 4256.89
c_1639_1640_i 1639 1639_1640 4.67522e-10
r_2199_2200_e 2199 2200 836.944
r_2199_2200_i 2199_2200 2200 4256.89
c_2199_2200_i 2199 2199_2200 4.67522e-10
r_2759_2760_e 2759 2760 836.944
r_2759_2760_i 2759_2760 2760 4256.89
c_2759_2760_i 2759 2759_2760 4.67522e-10
r_3319_3320_e 3319 3320 13758.3
r_3319_3320_i 3319_3320 3320 95645.6
c_3319_3320_i 3319 3319_3320 9.36084e-12
r_3879_3880_e 3879 3880 13758.3
r_3879_3880_i 3879_3880 3880 95645.6
c_3879_3880_i 3879 3879_3880 9.36084e-12
r_520_521_e 520 521 13376.4
r_520_521_i 520_521 521 93218.1
c_520_521_i 520 520_521 2.08965e-09
r_1080_1081_e 1080 1081 13376.4
r_1080_1081_i 1080_1081 1081 93218.1
c_1080_1081_i 1080 1080_1081 2.08965e-09
r_1640_1641_e 1640 1641 836.944
r_1640_1641_i 1640_1641 1641 4256.89
c_1640_1641_i 1640 1640_1641 4.67522e-10
r_2200_2201_e 2200 2201 836.944
r_2200_2201_i 2200_2201 2201 4256.89
c_2200_2201_i 2200 2200_2201 4.67522e-10
r_2760_2761_e 2760 2761 836.944
r_2760_2761_i 2760_2761 2761 4256.89
c_2760_2761_i 2760 2760_2761 4.67522e-10
r_3320_3321_e 3320 3321 13758.3
r_3320_3321_i 3320_3321 3321 95645.6
c_3320_3321_i 3320 3320_3321 9.36084e-12
r_3880_3881_e 3880 3881 13758.3
r_3880_3881_i 3880_3881 3881 95645.6
c_3880_3881_i 3880 3880_3881 9.36084e-12
r_521_522_e 521 522 13376.4
r_521_522_i 521_522 522 93218.1
c_521_522_i 521 521_522 2.08965e-09
r_1081_1082_e 1081 1082 13376.4
r_1081_1082_i 1081_1082 1082 93218.1
c_1081_1082_i 1081 1081_1082 2.08965e-09
r_1641_1642_e 1641 1642 836.944
r_1641_1642_i 1641_1642 1642 4256.89
c_1641_1642_i 1641 1641_1642 4.67522e-10
r_2201_2202_e 2201 2202 836.944
r_2201_2202_i 2201_2202 2202 4256.89
c_2201_2202_i 2201 2201_2202 4.67522e-10
r_2761_2762_e 2761 2762 836.944
r_2761_2762_i 2761_2762 2762 4256.89
c_2761_2762_i 2761 2761_2762 4.67522e-10
r_3321_3322_e 3321 3322 13758.3
r_3321_3322_i 3321_3322 3322 95645.6
c_3321_3322_i 3321 3321_3322 9.36084e-12
r_3881_3882_e 3881 3882 13758.3
r_3881_3882_i 3881_3882 3882 95645.6
c_3881_3882_i 3881 3881_3882 9.36084e-12
r_522_523_e 522 523 13376.4
r_522_523_i 522_523 523 93218.1
c_522_523_i 522 522_523 2.08965e-09
r_1082_1083_e 1082 1083 13376.4
r_1082_1083_i 1082_1083 1083 93218.1
c_1082_1083_i 1082 1082_1083 2.08965e-09
r_1642_1643_e 1642 1643 836.944
r_1642_1643_i 1642_1643 1643 4256.89
c_1642_1643_i 1642 1642_1643 4.67522e-10
r_2202_2203_e 2202 2203 836.944
r_2202_2203_i 2202_2203 2203 4256.89
c_2202_2203_i 2202 2202_2203 4.67522e-10
r_2762_2763_e 2762 2763 836.944
r_2762_2763_i 2762_2763 2763 4256.89
c_2762_2763_i 2762 2762_2763 4.67522e-10
r_3322_3323_e 3322 3323 13758.3
r_3322_3323_i 3322_3323 3323 95645.6
c_3322_3323_i 3322 3322_3323 9.36084e-12
r_3882_3883_e 3882 3883 13758.3
r_3882_3883_i 3882_3883 3883 95645.6
c_3882_3883_i 3882 3882_3883 9.36084e-12
r_523_524_e 523 524 13376.4
r_523_524_i 523_524 524 93218.1
c_523_524_i 523 523_524 2.08965e-09
r_1083_1084_e 1083 1084 396.501
r_1083_1084_i 1083_1084 1084 1004.77
c_1083_1084_i 1083 1083_1084 1.65876e-10
r_1643_1644_e 1643 1644 396.501
r_1643_1644_i 1643_1644 1644 1004.77
c_1643_1644_i 1643 1643_1644 1.65876e-10
r_2203_2204_e 2203 2204 836.944
r_2203_2204_i 2203_2204 2204 4256.89
c_2203_2204_i 2203 2203_2204 4.67522e-10
r_2763_2764_e 2763 2764 836.944
r_2763_2764_i 2763_2764 2764 4256.89
c_2763_2764_i 2763 2763_2764 4.67522e-10
r_3323_3324_e 3323 3324 13758.3
r_3323_3324_i 3323_3324 3324 95645.6
c_3323_3324_i 3323 3323_3324 9.36084e-12
r_3883_3884_e 3883 3884 13758.3
r_3883_3884_i 3883_3884 3884 95645.6
c_3883_3884_i 3883 3883_3884 9.36084e-12
r_524_525_e 524 525 13376.4
r_524_525_i 524_525 525 93218.1
c_524_525_i 524 524_525 2.08965e-09
r_1084_1085_e 1084 1085 13376.4
r_1084_1085_i 1084_1085 1085 93218.1
c_1084_1085_i 1084 1084_1085 2.08965e-09
r_1644_1645_e 1644 1645 836.944
r_1644_1645_i 1644_1645 1645 4256.89
c_1644_1645_i 1644 1644_1645 4.67522e-10
r_2204_2205_e 2204 2205 836.944
r_2204_2205_i 2204_2205 2205 4256.89
c_2204_2205_i 2204 2204_2205 4.67522e-10
r_2764_2765_e 2764 2765 836.944
r_2764_2765_i 2764_2765 2765 4256.89
c_2764_2765_i 2764 2764_2765 4.67522e-10
r_3324_3325_e 3324 3325 13758.3
r_3324_3325_i 3324_3325 3325 95645.6
c_3324_3325_i 3324 3324_3325 9.36084e-12
r_3884_3885_e 3884 3885 13758.3
r_3884_3885_i 3884_3885 3885 95645.6
c_3884_3885_i 3884 3884_3885 9.36084e-12
r_525_526_e 525 526 13376.4
r_525_526_i 525_526 526 93218.1
c_525_526_i 525 525_526 2.08965e-09
r_1085_1086_e 1085 1086 13376.4
r_1085_1086_i 1085_1086 1086 93218.1
c_1085_1086_i 1085 1085_1086 2.08965e-09
r_1645_1646_e 1645 1646 836.944
r_1645_1646_i 1645_1646 1646 4256.89
c_1645_1646_i 1645 1645_1646 4.67522e-10
r_2205_2206_e 2205 2206 836.944
r_2205_2206_i 2205_2206 2206 4256.89
c_2205_2206_i 2205 2205_2206 4.67522e-10
r_2765_2766_e 2765 2766 836.944
r_2765_2766_i 2765_2766 2766 4256.89
c_2765_2766_i 2765 2765_2766 4.67522e-10
r_3325_3326_e 3325 3326 13758.3
r_3325_3326_i 3325_3326 3326 95645.6
c_3325_3326_i 3325 3325_3326 9.36084e-12
r_3885_3886_e 3885 3886 13758.3
r_3885_3886_i 3885_3886 3886 95645.6
c_3885_3886_i 3885 3885_3886 9.36084e-12
r_526_527_e 526 527 13376.4
r_526_527_i 526_527 527 93218.1
c_526_527_i 526 526_527 2.08965e-09
r_1086_1087_e 1086 1087 13376.4
r_1086_1087_i 1086_1087 1087 93218.1
c_1086_1087_i 1086 1086_1087 2.08965e-09
r_1646_1647_e 1646 1647 836.944
r_1646_1647_i 1646_1647 1647 4256.89
c_1646_1647_i 1646 1646_1647 4.67522e-10
r_2206_2207_e 2206 2207 836.944
r_2206_2207_i 2206_2207 2207 4256.89
c_2206_2207_i 2206 2206_2207 4.67522e-10
r_2766_2767_e 2766 2767 836.944
r_2766_2767_i 2766_2767 2767 4256.89
c_2766_2767_i 2766 2766_2767 4.67522e-10
r_3326_3327_e 3326 3327 13758.3
r_3326_3327_i 3326_3327 3327 95645.6
c_3326_3327_i 3326 3326_3327 9.36084e-12
r_3886_3887_e 3886 3887 13758.3
r_3886_3887_i 3886_3887 3887 95645.6
c_3886_3887_i 3886 3886_3887 9.36084e-12
r_527_528_e 527 528 13376.4
r_527_528_i 527_528 528 93218.1
c_527_528_i 527 527_528 2.08965e-09
r_1087_1088_e 1087 1088 13376.4
r_1087_1088_i 1087_1088 1088 93218.1
c_1087_1088_i 1087 1087_1088 2.08965e-09
r_1647_1648_e 1647 1648 836.944
r_1647_1648_i 1647_1648 1648 4256.89
c_1647_1648_i 1647 1647_1648 4.67522e-10
r_2207_2208_e 2207 2208 836.944
r_2207_2208_i 2207_2208 2208 4256.89
c_2207_2208_i 2207 2207_2208 4.67522e-10
r_2767_2768_e 2767 2768 836.944
r_2767_2768_i 2767_2768 2768 4256.89
c_2767_2768_i 2767 2767_2768 4.67522e-10
r_3327_3328_e 3327 3328 13758.3
r_3327_3328_i 3327_3328 3328 95645.6
c_3327_3328_i 3327 3327_3328 9.36084e-12
r_3887_3888_e 3887 3888 13758.3
r_3887_3888_i 3887_3888 3888 95645.6
c_3887_3888_i 3887 3887_3888 9.36084e-12
r_529_530_e 529 530 13376.4
r_529_530_i 529_530 530 93218.1
c_529_530_i 529 529_530 2.08965e-09
r_1089_1090_e 1089 1090 13376.4
r_1089_1090_i 1089_1090 1090 93218.1
c_1089_1090_i 1089 1089_1090 2.08965e-09
r_1649_1650_e 1649 1650 13376.4
r_1649_1650_i 1649_1650 1650 93218.1
c_1649_1650_i 1649 1649_1650 2.08965e-09
r_2209_2210_e 2209 2210 13376.4
r_2209_2210_i 2209_2210 2210 93218.1
c_2209_2210_i 2209 2209_2210 2.08965e-09
r_2769_2770_e 2769 2770 13376.4
r_2769_2770_i 2769_2770 2770 93218.1
c_2769_2770_i 2769 2769_2770 2.08965e-09
r_3329_3330_e 3329 3330 13376.4
r_3329_3330_i 3329_3330 3330 93218.1
c_3329_3330_i 3329 3329_3330 2.08965e-09
r_3889_3890_e 3889 3890 13376.4
r_3889_3890_i 3889_3890 3890 93218.1
c_3889_3890_i 3889 3889_3890 2.08965e-09
r_530_531_e 530 531 13376.4
r_530_531_i 530_531 531 93218.1
c_530_531_i 530 530_531 2.08965e-09
r_1090_1091_e 1090 1091 13376.4
r_1090_1091_i 1090_1091 1091 93218.1
c_1090_1091_i 1090 1090_1091 2.08965e-09
r_1650_1651_e 1650 1651 13376.4
r_1650_1651_i 1650_1651 1651 93218.1
c_1650_1651_i 1650 1650_1651 2.08965e-09
r_2210_2211_e 2210 2211 13376.4
r_2210_2211_i 2210_2211 2211 93218.1
c_2210_2211_i 2210 2210_2211 2.08965e-09
r_2770_2771_e 2770 2771 13376.4
r_2770_2771_i 2770_2771 2771 93218.1
c_2770_2771_i 2770 2770_2771 2.08965e-09
r_3330_3331_e 3330 3331 13376.4
r_3330_3331_i 3330_3331 3331 93218.1
c_3330_3331_i 3330 3330_3331 2.08965e-09
r_3890_3891_e 3890 3891 13376.4
r_3890_3891_i 3890_3891 3891 93218.1
c_3890_3891_i 3890 3890_3891 2.08965e-09
r_531_532_e 531 532 13376.4
r_531_532_i 531_532 532 93218.1
c_531_532_i 531 531_532 2.08965e-09
r_1091_1092_e 1091 1092 13376.4
r_1091_1092_i 1091_1092 1092 93218.1
c_1091_1092_i 1091 1091_1092 2.08965e-09
r_1651_1652_e 1651 1652 836.944
r_1651_1652_i 1651_1652 1652 4256.89
c_1651_1652_i 1651 1651_1652 4.67522e-10
r_2211_2212_e 2211 2212 836.944
r_2211_2212_i 2211_2212 2212 4256.89
c_2211_2212_i 2211 2211_2212 4.67522e-10
r_2771_2772_e 2771 2772 836.944
r_2771_2772_i 2771_2772 2772 4256.89
c_2771_2772_i 2771 2771_2772 4.67522e-10
r_3331_3332_e 3331 3332 836.944
r_3331_3332_i 3331_3332 3332 4256.89
c_3331_3332_i 3331 3331_3332 4.67522e-10
r_3891_3892_e 3891 3892 836.944
r_3891_3892_i 3891_3892 3892 4256.89
c_3891_3892_i 3891 3891_3892 4.67522e-10
r_532_533_e 532 533 13376.4
r_532_533_i 532_533 533 93218.1
c_532_533_i 532 532_533 2.08965e-09
r_1092_1093_e 1092 1093 13376.4
r_1092_1093_i 1092_1093 1093 93218.1
c_1092_1093_i 1092 1092_1093 2.08965e-09
r_1652_1653_e 1652 1653 836.944
r_1652_1653_i 1652_1653 1653 4256.89
c_1652_1653_i 1652 1652_1653 4.67522e-10
r_2212_2213_e 2212 2213 836.944
r_2212_2213_i 2212_2213 2213 4256.89
c_2212_2213_i 2212 2212_2213 4.67522e-10
r_2772_2773_e 2772 2773 836.944
r_2772_2773_i 2772_2773 2773 4256.89
c_2772_2773_i 2772 2772_2773 4.67522e-10
r_3332_3333_e 3332 3333 13758.3
r_3332_3333_i 3332_3333 3333 95645.6
c_3332_3333_i 3332 3332_3333 9.36084e-12
r_3892_3893_e 3892 3893 13758.3
r_3892_3893_i 3892_3893 3893 95645.6
c_3892_3893_i 3892 3892_3893 9.36084e-12
r_533_534_e 533 534 13376.4
r_533_534_i 533_534 534 93218.1
c_533_534_i 533 533_534 2.08965e-09
r_1093_1094_e 1093 1094 13376.4
r_1093_1094_i 1093_1094 1094 93218.1
c_1093_1094_i 1093 1093_1094 2.08965e-09
r_1653_1654_e 1653 1654 836.944
r_1653_1654_i 1653_1654 1654 4256.89
c_1653_1654_i 1653 1653_1654 4.67522e-10
r_2213_2214_e 2213 2214 836.944
r_2213_2214_i 2213_2214 2214 4256.89
c_2213_2214_i 2213 2213_2214 4.67522e-10
r_2773_2774_e 2773 2774 836.944
r_2773_2774_i 2773_2774 2774 4256.89
c_2773_2774_i 2773 2773_2774 4.67522e-10
r_3333_3334_e 3333 3334 13758.3
r_3333_3334_i 3333_3334 3334 95645.6
c_3333_3334_i 3333 3333_3334 9.36084e-12
r_3893_3894_e 3893 3894 13758.3
r_3893_3894_i 3893_3894 3894 95645.6
c_3893_3894_i 3893 3893_3894 9.36084e-12
r_534_535_e 534 535 13376.4
r_534_535_i 534_535 535 93218.1
c_534_535_i 534 534_535 2.08965e-09
r_1094_1095_e 1094 1095 13376.4
r_1094_1095_i 1094_1095 1095 93218.1
c_1094_1095_i 1094 1094_1095 2.08965e-09
r_1654_1655_e 1654 1655 836.944
r_1654_1655_i 1654_1655 1655 4256.89
c_1654_1655_i 1654 1654_1655 4.67522e-10
r_2214_2215_e 2214 2215 836.944
r_2214_2215_i 2214_2215 2215 4256.89
c_2214_2215_i 2214 2214_2215 4.67522e-10
r_2774_2775_e 2774 2775 836.944
r_2774_2775_i 2774_2775 2775 4256.89
c_2774_2775_i 2774 2774_2775 4.67522e-10
r_3334_3335_e 3334 3335 13758.3
r_3334_3335_i 3334_3335 3335 95645.6
c_3334_3335_i 3334 3334_3335 9.36084e-12
r_3894_3895_e 3894 3895 13758.3
r_3894_3895_i 3894_3895 3895 95645.6
c_3894_3895_i 3894 3894_3895 9.36084e-12
r_535_536_e 535 536 13376.4
r_535_536_i 535_536 536 93218.1
c_535_536_i 535 535_536 2.08965e-09
r_1095_1096_e 1095 1096 13376.4
r_1095_1096_i 1095_1096 1096 93218.1
c_1095_1096_i 1095 1095_1096 2.08965e-09
r_1655_1656_e 1655 1656 836.944
r_1655_1656_i 1655_1656 1656 4256.89
c_1655_1656_i 1655 1655_1656 4.67522e-10
r_2215_2216_e 2215 2216 836.944
r_2215_2216_i 2215_2216 2216 4256.89
c_2215_2216_i 2215 2215_2216 4.67522e-10
r_2775_2776_e 2775 2776 836.944
r_2775_2776_i 2775_2776 2776 4256.89
c_2775_2776_i 2775 2775_2776 4.67522e-10
r_3335_3336_e 3335 3336 13758.3
r_3335_3336_i 3335_3336 3336 95645.6
c_3335_3336_i 3335 3335_3336 9.36084e-12
r_3895_3896_e 3895 3896 13758.3
r_3895_3896_i 3895_3896 3896 95645.6
c_3895_3896_i 3895 3895_3896 9.36084e-12
r_536_537_e 536 537 13376.4
r_536_537_i 536_537 537 93218.1
c_536_537_i 536 536_537 2.08965e-09
r_1096_1097_e 1096 1097 13376.4
r_1096_1097_i 1096_1097 1097 93218.1
c_1096_1097_i 1096 1096_1097 2.08965e-09
r_1656_1657_e 1656 1657 836.944
r_1656_1657_i 1656_1657 1657 4256.89
c_1656_1657_i 1656 1656_1657 4.67522e-10
r_2216_2217_e 2216 2217 836.944
r_2216_2217_i 2216_2217 2217 4256.89
c_2216_2217_i 2216 2216_2217 4.67522e-10
r_2776_2777_e 2776 2777 836.944
r_2776_2777_i 2776_2777 2777 4256.89
c_2776_2777_i 2776 2776_2777 4.67522e-10
r_3336_3337_e 3336 3337 13758.3
r_3336_3337_i 3336_3337 3337 95645.6
c_3336_3337_i 3336 3336_3337 9.36084e-12
r_3896_3897_e 3896 3897 13758.3
r_3896_3897_i 3896_3897 3897 95645.6
c_3896_3897_i 3896 3896_3897 9.36084e-12
r_537_538_e 537 538 13376.4
r_537_538_i 537_538 538 93218.1
c_537_538_i 537 537_538 2.08965e-09
r_1097_1098_e 1097 1098 13376.4
r_1097_1098_i 1097_1098 1098 93218.1
c_1097_1098_i 1097 1097_1098 2.08965e-09
r_1657_1658_e 1657 1658 836.944
r_1657_1658_i 1657_1658 1658 4256.89
c_1657_1658_i 1657 1657_1658 4.67522e-10
r_2217_2218_e 2217 2218 836.944
r_2217_2218_i 2217_2218 2218 4256.89
c_2217_2218_i 2217 2217_2218 4.67522e-10
r_2777_2778_e 2777 2778 836.944
r_2777_2778_i 2777_2778 2778 4256.89
c_2777_2778_i 2777 2777_2778 4.67522e-10
r_3337_3338_e 3337 3338 13758.3
r_3337_3338_i 3337_3338 3338 95645.6
c_3337_3338_i 3337 3337_3338 9.36084e-12
r_3897_3898_e 3897 3898 13758.3
r_3897_3898_i 3897_3898 3898 95645.6
c_3897_3898_i 3897 3897_3898 9.36084e-12
r_538_539_e 538 539 13376.4
r_538_539_i 538_539 539 93218.1
c_538_539_i 538 538_539 2.08965e-09
r_1098_1099_e 1098 1099 13376.4
r_1098_1099_i 1098_1099 1099 93218.1
c_1098_1099_i 1098 1098_1099 2.08965e-09
r_1658_1659_e 1658 1659 836.944
r_1658_1659_i 1658_1659 1659 4256.89
c_1658_1659_i 1658 1658_1659 4.67522e-10
r_2218_2219_e 2218 2219 836.944
r_2218_2219_i 2218_2219 2219 4256.89
c_2218_2219_i 2218 2218_2219 4.67522e-10
r_2778_2779_e 2778 2779 836.944
r_2778_2779_i 2778_2779 2779 4256.89
c_2778_2779_i 2778 2778_2779 4.67522e-10
r_3338_3339_e 3338 3339 13758.3
r_3338_3339_i 3338_3339 3339 95645.6
c_3338_3339_i 3338 3338_3339 9.36084e-12
r_3898_3899_e 3898 3899 13758.3
r_3898_3899_i 3898_3899 3899 95645.6
c_3898_3899_i 3898 3898_3899 9.36084e-12
r_539_540_e 539 540 13376.4
r_539_540_i 539_540 540 93218.1
c_539_540_i 539 539_540 2.08965e-09
r_1099_1100_e 1099 1100 396.493
r_1099_1100_i 1099_1100 1100 1004.75
c_1099_1100_i 1099 1099_1100 1.6588e-10
r_1659_1660_e 1659 1660 396.493
r_1659_1660_i 1659_1660 1660 1004.75
c_1659_1660_i 1659 1659_1660 1.6588e-10
r_2219_2220_e 2219 2220 836.944
r_2219_2220_i 2219_2220 2220 4256.89
c_2219_2220_i 2219 2219_2220 4.67522e-10
r_2779_2780_e 2779 2780 836.944
r_2779_2780_i 2779_2780 2780 4256.89
c_2779_2780_i 2779 2779_2780 4.67522e-10
r_3339_3340_e 3339 3340 13758.3
r_3339_3340_i 3339_3340 3340 95645.6
c_3339_3340_i 3339 3339_3340 9.36084e-12
r_3899_3900_e 3899 3900 13758.3
r_3899_3900_i 3899_3900 3900 95645.6
c_3899_3900_i 3899 3899_3900 9.36084e-12
r_540_541_e 540 541 13376.4
r_540_541_i 540_541 541 93218.1
c_540_541_i 540 540_541 2.08965e-09
r_1100_1101_e 1100 1101 13376.4
r_1100_1101_i 1100_1101 1101 93218.1
c_1100_1101_i 1100 1100_1101 2.08965e-09
r_1660_1661_e 1660 1661 836.944
r_1660_1661_i 1660_1661 1661 4256.89
c_1660_1661_i 1660 1660_1661 4.67522e-10
r_2220_2221_e 2220 2221 836.944
r_2220_2221_i 2220_2221 2221 4256.89
c_2220_2221_i 2220 2220_2221 4.67522e-10
r_2780_2781_e 2780 2781 836.944
r_2780_2781_i 2780_2781 2781 4256.89
c_2780_2781_i 2780 2780_2781 4.67522e-10
r_3340_3341_e 3340 3341 13758.3
r_3340_3341_i 3340_3341 3341 95645.6
c_3340_3341_i 3340 3340_3341 9.36084e-12
r_3900_3901_e 3900 3901 13758.3
r_3900_3901_i 3900_3901 3901 95645.6
c_3900_3901_i 3900 3900_3901 9.36084e-12
r_541_542_e 541 542 13376.4
r_541_542_i 541_542 542 93218.1
c_541_542_i 541 541_542 2.08965e-09
r_1101_1102_e 1101 1102 13376.4
r_1101_1102_i 1101_1102 1102 93218.1
c_1101_1102_i 1101 1101_1102 2.08965e-09
r_1661_1662_e 1661 1662 836.944
r_1661_1662_i 1661_1662 1662 4256.89
c_1661_1662_i 1661 1661_1662 4.67522e-10
r_2221_2222_e 2221 2222 836.944
r_2221_2222_i 2221_2222 2222 4256.89
c_2221_2222_i 2221 2221_2222 4.67522e-10
r_2781_2782_e 2781 2782 836.944
r_2781_2782_i 2781_2782 2782 4256.89
c_2781_2782_i 2781 2781_2782 4.67522e-10
r_3341_3342_e 3341 3342 13758.3
r_3341_3342_i 3341_3342 3342 95645.6
c_3341_3342_i 3341 3341_3342 9.36084e-12
r_3901_3902_e 3901 3902 13758.3
r_3901_3902_i 3901_3902 3902 95645.6
c_3901_3902_i 3901 3901_3902 9.36084e-12
r_542_543_e 542 543 13376.4
r_542_543_i 542_543 543 93218.1
c_542_543_i 542 542_543 2.08965e-09
r_1102_1103_e 1102 1103 13376.4
r_1102_1103_i 1102_1103 1103 93218.1
c_1102_1103_i 1102 1102_1103 2.08965e-09
r_1662_1663_e 1662 1663 836.944
r_1662_1663_i 1662_1663 1663 4256.89
c_1662_1663_i 1662 1662_1663 4.67522e-10
r_2222_2223_e 2222 2223 836.944
r_2222_2223_i 2222_2223 2223 4256.89
c_2222_2223_i 2222 2222_2223 4.67522e-10
r_2782_2783_e 2782 2783 836.944
r_2782_2783_i 2782_2783 2783 4256.89
c_2782_2783_i 2782 2782_2783 4.67522e-10
r_3342_3343_e 3342 3343 13758.3
r_3342_3343_i 3342_3343 3343 95645.6
c_3342_3343_i 3342 3342_3343 9.36084e-12
r_3902_3903_e 3902 3903 13758.3
r_3902_3903_i 3902_3903 3903 95645.6
c_3902_3903_i 3902 3902_3903 9.36084e-12
r_543_544_e 543 544 13376.4
r_543_544_i 543_544 544 93218.1
c_543_544_i 543 543_544 2.08965e-09
r_1103_1104_e 1103 1104 13376.4
r_1103_1104_i 1103_1104 1104 93218.1
c_1103_1104_i 1103 1103_1104 2.08965e-09
r_1663_1664_e 1663 1664 836.944
r_1663_1664_i 1663_1664 1664 4256.89
c_1663_1664_i 1663 1663_1664 4.67522e-10
r_2223_2224_e 2223 2224 836.944
r_2223_2224_i 2223_2224 2224 4256.89
c_2223_2224_i 2223 2223_2224 4.67522e-10
r_2783_2784_e 2783 2784 836.944
r_2783_2784_i 2783_2784 2784 4256.89
c_2783_2784_i 2783 2783_2784 4.67522e-10
r_3343_3344_e 3343 3344 13758.3
r_3343_3344_i 3343_3344 3344 95645.6
c_3343_3344_i 3343 3343_3344 9.36084e-12
r_3903_3904_e 3903 3904 13758.3
r_3903_3904_i 3903_3904 3904 95645.6
c_3903_3904_i 3903 3903_3904 9.36084e-12
r_545_546_e 545 546 13376.4
r_545_546_i 545_546 546 93218.1
c_545_546_i 545 545_546 2.08965e-09
r_1105_1106_e 1105 1106 13376.4
r_1105_1106_i 1105_1106 1106 93218.1
c_1105_1106_i 1105 1105_1106 2.08965e-09
r_1665_1666_e 1665 1666 13376.4
r_1665_1666_i 1665_1666 1666 93218.1
c_1665_1666_i 1665 1665_1666 2.08965e-09
r_2225_2226_e 2225 2226 13376.4
r_2225_2226_i 2225_2226 2226 93218.1
c_2225_2226_i 2225 2225_2226 2.08965e-09
r_2785_2786_e 2785 2786 13376.4
r_2785_2786_i 2785_2786 2786 93218.1
c_2785_2786_i 2785 2785_2786 2.08965e-09
r_3345_3346_e 3345 3346 13376.4
r_3345_3346_i 3345_3346 3346 93218.1
c_3345_3346_i 3345 3345_3346 2.08965e-09
r_3905_3906_e 3905 3906 13376.4
r_3905_3906_i 3905_3906 3906 93218.1
c_3905_3906_i 3905 3905_3906 2.08965e-09
r_546_547_e 546 547 13376.4
r_546_547_i 546_547 547 93218.1
c_546_547_i 546 546_547 2.08965e-09
r_1106_1107_e 1106 1107 13376.4
r_1106_1107_i 1106_1107 1107 93218.1
c_1106_1107_i 1106 1106_1107 2.08965e-09
r_1666_1667_e 1666 1667 13376.4
r_1666_1667_i 1666_1667 1667 93218.1
c_1666_1667_i 1666 1666_1667 2.08965e-09
r_2226_2227_e 2226 2227 13376.4
r_2226_2227_i 2226_2227 2227 93218.1
c_2226_2227_i 2226 2226_2227 2.08965e-09
r_2786_2787_e 2786 2787 13376.4
r_2786_2787_i 2786_2787 2787 93218.1
c_2786_2787_i 2786 2786_2787 2.08965e-09
r_3346_3347_e 3346 3347 13376.4
r_3346_3347_i 3346_3347 3347 93218.1
c_3346_3347_i 3346 3346_3347 2.08965e-09
r_3906_3907_e 3906 3907 13376.4
r_3906_3907_i 3906_3907 3907 93218.1
c_3906_3907_i 3906 3906_3907 2.08965e-09
r_547_548_e 547 548 13376.4
r_547_548_i 547_548 548 93218.1
c_547_548_i 547 547_548 2.08965e-09
r_1107_1108_e 1107 1108 13376.4
r_1107_1108_i 1107_1108 1108 93218.1
c_1107_1108_i 1107 1107_1108 2.08965e-09
r_1667_1668_e 1667 1668 836.944
r_1667_1668_i 1667_1668 1668 4256.89
c_1667_1668_i 1667 1667_1668 4.67522e-10
r_2227_2228_e 2227 2228 836.944
r_2227_2228_i 2227_2228 2228 4256.89
c_2227_2228_i 2227 2227_2228 4.67522e-10
r_2787_2788_e 2787 2788 836.944
r_2787_2788_i 2787_2788 2788 4256.89
c_2787_2788_i 2787 2787_2788 4.67522e-10
r_3347_3348_e 3347 3348 836.944
r_3347_3348_i 3347_3348 3348 4256.89
c_3347_3348_i 3347 3347_3348 4.67522e-10
r_3907_3908_e 3907 3908 836.944
r_3907_3908_i 3907_3908 3908 4256.89
c_3907_3908_i 3907 3907_3908 4.67522e-10
r_548_549_e 548 549 13376.4
r_548_549_i 548_549 549 93218.1
c_548_549_i 548 548_549 2.08965e-09
r_1108_1109_e 1108 1109 13376.4
r_1108_1109_i 1108_1109 1109 93218.1
c_1108_1109_i 1108 1108_1109 2.08965e-09
r_1668_1669_e 1668 1669 836.944
r_1668_1669_i 1668_1669 1669 4256.89
c_1668_1669_i 1668 1668_1669 4.67522e-10
r_2228_2229_e 2228 2229 836.944
r_2228_2229_i 2228_2229 2229 4256.89
c_2228_2229_i 2228 2228_2229 4.67522e-10
r_2788_2789_e 2788 2789 836.944
r_2788_2789_i 2788_2789 2789 4256.89
c_2788_2789_i 2788 2788_2789 4.67522e-10
r_3348_3349_e 3348 3349 13758.3
r_3348_3349_i 3348_3349 3349 95645.6
c_3348_3349_i 3348 3348_3349 9.36084e-12
r_3908_3909_e 3908 3909 13758.3
r_3908_3909_i 3908_3909 3909 95645.6
c_3908_3909_i 3908 3908_3909 9.36084e-12
r_549_550_e 549 550 13376.4
r_549_550_i 549_550 550 93218.1
c_549_550_i 549 549_550 2.08965e-09
r_1109_1110_e 1109 1110 13376.4
r_1109_1110_i 1109_1110 1110 93218.1
c_1109_1110_i 1109 1109_1110 2.08965e-09
r_1669_1670_e 1669 1670 836.944
r_1669_1670_i 1669_1670 1670 4256.89
c_1669_1670_i 1669 1669_1670 4.67522e-10
r_2229_2230_e 2229 2230 836.944
r_2229_2230_i 2229_2230 2230 4256.89
c_2229_2230_i 2229 2229_2230 4.67522e-10
r_2789_2790_e 2789 2790 836.944
r_2789_2790_i 2789_2790 2790 4256.89
c_2789_2790_i 2789 2789_2790 4.67522e-10
r_3349_3350_e 3349 3350 13758.3
r_3349_3350_i 3349_3350 3350 95645.6
c_3349_3350_i 3349 3349_3350 9.36084e-12
r_3909_3910_e 3909 3910 13758.3
r_3909_3910_i 3909_3910 3910 95645.6
c_3909_3910_i 3909 3909_3910 9.36084e-12
r_550_551_e 550 551 13376.4
r_550_551_i 550_551 551 93218.1
c_550_551_i 550 550_551 2.08965e-09
r_1110_1111_e 1110 1111 13376.4
r_1110_1111_i 1110_1111 1111 93218.1
c_1110_1111_i 1110 1110_1111 2.08965e-09
r_1670_1671_e 1670 1671 836.944
r_1670_1671_i 1670_1671 1671 4256.89
c_1670_1671_i 1670 1670_1671 4.67522e-10
r_2230_2231_e 2230 2231 836.944
r_2230_2231_i 2230_2231 2231 4256.89
c_2230_2231_i 2230 2230_2231 4.67522e-10
r_2790_2791_e 2790 2791 836.944
r_2790_2791_i 2790_2791 2791 4256.89
c_2790_2791_i 2790 2790_2791 4.67522e-10
r_3350_3351_e 3350 3351 13758.3
r_3350_3351_i 3350_3351 3351 95645.6
c_3350_3351_i 3350 3350_3351 9.36084e-12
r_3910_3911_e 3910 3911 13758.3
r_3910_3911_i 3910_3911 3911 95645.6
c_3910_3911_i 3910 3910_3911 9.36084e-12
r_551_552_e 551 552 13376.4
r_551_552_i 551_552 552 93218.1
c_551_552_i 551 551_552 2.08965e-09
r_1111_1112_e 1111 1112 13376.4
r_1111_1112_i 1111_1112 1112 93218.1
c_1111_1112_i 1111 1111_1112 2.08965e-09
r_1671_1672_e 1671 1672 836.944
r_1671_1672_i 1671_1672 1672 4256.89
c_1671_1672_i 1671 1671_1672 4.67522e-10
r_2231_2232_e 2231 2232 836.944
r_2231_2232_i 2231_2232 2232 4256.89
c_2231_2232_i 2231 2231_2232 4.67522e-10
r_2791_2792_e 2791 2792 836.944
r_2791_2792_i 2791_2792 2792 4256.89
c_2791_2792_i 2791 2791_2792 4.67522e-10
r_3351_3352_e 3351 3352 13758.3
r_3351_3352_i 3351_3352 3352 95645.6
c_3351_3352_i 3351 3351_3352 9.36084e-12
r_3911_3912_e 3911 3912 13758.3
r_3911_3912_i 3911_3912 3912 95645.6
c_3911_3912_i 3911 3911_3912 9.36084e-12
r_552_553_e 552 553 13376.4
r_552_553_i 552_553 553 93218.1
c_552_553_i 552 552_553 2.08965e-09
r_1112_1113_e 1112 1113 13376.4
r_1112_1113_i 1112_1113 1113 93218.1
c_1112_1113_i 1112 1112_1113 2.08965e-09
r_1672_1673_e 1672 1673 836.944
r_1672_1673_i 1672_1673 1673 4256.89
c_1672_1673_i 1672 1672_1673 4.67522e-10
r_2232_2233_e 2232 2233 836.944
r_2232_2233_i 2232_2233 2233 4256.89
c_2232_2233_i 2232 2232_2233 4.67522e-10
r_2792_2793_e 2792 2793 836.944
r_2792_2793_i 2792_2793 2793 4256.89
c_2792_2793_i 2792 2792_2793 4.67522e-10
r_3352_3353_e 3352 3353 13758.3
r_3352_3353_i 3352_3353 3353 95645.6
c_3352_3353_i 3352 3352_3353 9.36084e-12
r_3912_3913_e 3912 3913 13758.3
r_3912_3913_i 3912_3913 3913 95645.6
c_3912_3913_i 3912 3912_3913 9.36084e-12
r_553_554_e 553 554 13376.4
r_553_554_i 553_554 554 93218.1
c_553_554_i 553 553_554 2.08965e-09
r_1113_1114_e 1113 1114 13376.4
r_1113_1114_i 1113_1114 1114 93218.1
c_1113_1114_i 1113 1113_1114 2.08965e-09
r_1673_1674_e 1673 1674 836.944
r_1673_1674_i 1673_1674 1674 4256.89
c_1673_1674_i 1673 1673_1674 4.67522e-10
r_2233_2234_e 2233 2234 836.944
r_2233_2234_i 2233_2234 2234 4256.89
c_2233_2234_i 2233 2233_2234 4.67522e-10
r_2793_2794_e 2793 2794 836.944
r_2793_2794_i 2793_2794 2794 4256.89
c_2793_2794_i 2793 2793_2794 4.67522e-10
r_3353_3354_e 3353 3354 13758.3
r_3353_3354_i 3353_3354 3354 95645.6
c_3353_3354_i 3353 3353_3354 9.36084e-12
r_3913_3914_e 3913 3914 13758.3
r_3913_3914_i 3913_3914 3914 95645.6
c_3913_3914_i 3913 3913_3914 9.36084e-12
r_554_555_e 554 555 13376.4
r_554_555_i 554_555 555 93218.1
c_554_555_i 554 554_555 2.08965e-09
r_1114_1115_e 1114 1115 13376.4
r_1114_1115_i 1114_1115 1115 93218.1
c_1114_1115_i 1114 1114_1115 2.08965e-09
r_1674_1675_e 1674 1675 836.944
r_1674_1675_i 1674_1675 1675 4256.89
c_1674_1675_i 1674 1674_1675 4.67522e-10
r_2234_2235_e 2234 2235 836.944
r_2234_2235_i 2234_2235 2235 4256.89
c_2234_2235_i 2234 2234_2235 4.67522e-10
r_2794_2795_e 2794 2795 836.944
r_2794_2795_i 2794_2795 2795 4256.89
c_2794_2795_i 2794 2794_2795 4.67522e-10
r_3354_3355_e 3354 3355 13758.3
r_3354_3355_i 3354_3355 3355 95645.6
c_3354_3355_i 3354 3354_3355 9.36084e-12
r_3914_3915_e 3914 3915 13758.3
r_3914_3915_i 3914_3915 3915 95645.6
c_3914_3915_i 3914 3914_3915 9.36084e-12
r_555_556_e 555 556 13376.4
r_555_556_i 555_556 556 93218.1
c_555_556_i 555 555_556 2.08965e-09
r_1115_1116_e 1115 1116 396.485
r_1115_1116_i 1115_1116 1116 1004.73
c_1115_1116_i 1115 1115_1116 1.65883e-10
r_1675_1676_e 1675 1676 396.485
r_1675_1676_i 1675_1676 1676 1004.73
c_1675_1676_i 1675 1675_1676 1.65883e-10
r_2235_2236_e 2235 2236 836.944
r_2235_2236_i 2235_2236 2236 4256.89
c_2235_2236_i 2235 2235_2236 4.67522e-10
r_2795_2796_e 2795 2796 836.944
r_2795_2796_i 2795_2796 2796 4256.89
c_2795_2796_i 2795 2795_2796 4.67522e-10
r_3355_3356_e 3355 3356 13758.3
r_3355_3356_i 3355_3356 3356 95645.6
c_3355_3356_i 3355 3355_3356 9.36084e-12
r_3915_3916_e 3915 3916 13758.3
r_3915_3916_i 3915_3916 3916 95645.6
c_3915_3916_i 3915 3915_3916 9.36084e-12
r_556_557_e 556 557 13376.4
r_556_557_i 556_557 557 93218.1
c_556_557_i 556 556_557 2.08965e-09
r_1116_1117_e 1116 1117 13376.4
r_1116_1117_i 1116_1117 1117 93218.1
c_1116_1117_i 1116 1116_1117 2.08965e-09
r_1676_1677_e 1676 1677 836.944
r_1676_1677_i 1676_1677 1677 4256.89
c_1676_1677_i 1676 1676_1677 4.67522e-10
r_2236_2237_e 2236 2237 836.944
r_2236_2237_i 2236_2237 2237 4256.89
c_2236_2237_i 2236 2236_2237 4.67522e-10
r_2796_2797_e 2796 2797 836.944
r_2796_2797_i 2796_2797 2797 4256.89
c_2796_2797_i 2796 2796_2797 4.67522e-10
r_3356_3357_e 3356 3357 13758.3
r_3356_3357_i 3356_3357 3357 95645.6
c_3356_3357_i 3356 3356_3357 9.36084e-12
r_3916_3917_e 3916 3917 13758.3
r_3916_3917_i 3916_3917 3917 95645.6
c_3916_3917_i 3916 3916_3917 9.36084e-12
r_557_558_e 557 558 13376.4
r_557_558_i 557_558 558 93218.1
c_557_558_i 557 557_558 2.08965e-09
r_1117_1118_e 1117 1118 13376.4
r_1117_1118_i 1117_1118 1118 93218.1
c_1117_1118_i 1117 1117_1118 2.08965e-09
r_1677_1678_e 1677 1678 836.944
r_1677_1678_i 1677_1678 1678 4256.89
c_1677_1678_i 1677 1677_1678 4.67522e-10
r_2237_2238_e 2237 2238 836.944
r_2237_2238_i 2237_2238 2238 4256.89
c_2237_2238_i 2237 2237_2238 4.67522e-10
r_2797_2798_e 2797 2798 836.944
r_2797_2798_i 2797_2798 2798 4256.89
c_2797_2798_i 2797 2797_2798 4.67522e-10
r_3357_3358_e 3357 3358 13758.3
r_3357_3358_i 3357_3358 3358 95645.6
c_3357_3358_i 3357 3357_3358 9.36084e-12
r_3917_3918_e 3917 3918 13758.3
r_3917_3918_i 3917_3918 3918 95645.6
c_3917_3918_i 3917 3917_3918 9.36084e-12
r_558_559_e 558 559 13376.4
r_558_559_i 558_559 559 93218.1
c_558_559_i 558 558_559 2.08965e-09
r_1118_1119_e 1118 1119 13376.4
r_1118_1119_i 1118_1119 1119 93218.1
c_1118_1119_i 1118 1118_1119 2.08965e-09
r_1678_1679_e 1678 1679 836.944
r_1678_1679_i 1678_1679 1679 4256.89
c_1678_1679_i 1678 1678_1679 4.67522e-10
r_2238_2239_e 2238 2239 836.944
r_2238_2239_i 2238_2239 2239 4256.89
c_2238_2239_i 2238 2238_2239 4.67522e-10
r_2798_2799_e 2798 2799 836.944
r_2798_2799_i 2798_2799 2799 4256.89
c_2798_2799_i 2798 2798_2799 4.67522e-10
r_3358_3359_e 3358 3359 13758.3
r_3358_3359_i 3358_3359 3359 95645.6
c_3358_3359_i 3358 3358_3359 9.36084e-12
r_3918_3919_e 3918 3919 13758.3
r_3918_3919_i 3918_3919 3919 95645.6
c_3918_3919_i 3918 3918_3919 9.36084e-12
r_559_560_e 559 560 13376.4
r_559_560_i 559_560 560 93218.1
c_559_560_i 559 559_560 2.08965e-09
r_1119_1120_e 1119 1120 13376.4
r_1119_1120_i 1119_1120 1120 93218.1
c_1119_1120_i 1119 1119_1120 2.08965e-09
r_1679_1680_e 1679 1680 836.944
r_1679_1680_i 1679_1680 1680 4256.89
c_1679_1680_i 1679 1679_1680 4.67522e-10
r_2239_2240_e 2239 2240 836.944
r_2239_2240_i 2239_2240 2240 4256.89
c_2239_2240_i 2239 2239_2240 4.67522e-10
r_2799_2800_e 2799 2800 836.944
r_2799_2800_i 2799_2800 2800 4256.89
c_2799_2800_i 2799 2799_2800 4.67522e-10
r_3359_3360_e 3359 3360 13758.3
r_3359_3360_i 3359_3360 3360 95645.6
c_3359_3360_i 3359 3359_3360 9.36084e-12
r_3919_3920_e 3919 3920 13758.3
r_3919_3920_i 3919_3920 3920 95645.6
c_3919_3920_i 3919 3919_3920 9.36084e-12
r_1_17_e 1 17 13376.4
r_1_17_i 1_17 17 93218.1
c_1_17_i 1 1_17 2.08965e-09
r_561_577_e 561 577 13376.4
r_561_577_i 561_577 577 93218.1
c_561_577_i 561 561_577 2.08965e-09
r_1121_1137_e 1121 1137 13376.4
r_1121_1137_i 1121_1137 1137 93218.1
c_1121_1137_i 1121 1121_1137 2.08965e-09
r_1681_1697_e 1681 1697 13376.4
r_1681_1697_i 1681_1697 1697 93218.1
c_1681_1697_i 1681 1681_1697 2.08965e-09
r_2241_2257_e 2241 2257 13376.4
r_2241_2257_i 2241_2257 2257 93218.1
c_2241_2257_i 2241 2241_2257 2.08965e-09
r_2801_2817_e 2801 2817 13376.4
r_2801_2817_i 2801_2817 2817 93218.1
c_2801_2817_i 2801 2801_2817 2.08965e-09
r_3361_3377_e 3361 3377 13376.4
r_3361_3377_i 3361_3377 3377 93218.1
c_3361_3377_i 3361 3361_3377 2.08965e-09
r_2_18_e 2 18 13376.4
r_2_18_i 2_18 18 93218.1
c_2_18_i 2 2_18 2.08965e-09
r_562_578_e 562 578 13376.4
r_562_578_i 562_578 578 93218.1
c_562_578_i 562 562_578 2.08965e-09
r_1122_1138_e 1122 1138 13376.4
r_1122_1138_i 1122_1138 1138 93218.1
c_1122_1138_i 1122 1122_1138 2.08965e-09
r_1682_1698_e 1682 1698 13376.4
r_1682_1698_i 1682_1698 1698 93218.1
c_1682_1698_i 1682 1682_1698 2.08965e-09
r_2242_2258_e 2242 2258 13376.4
r_2242_2258_i 2242_2258 2258 93218.1
c_2242_2258_i 2242 2242_2258 2.08965e-09
r_2802_2818_e 2802 2818 13376.4
r_2802_2818_i 2802_2818 2818 93218.1
c_2802_2818_i 2802 2802_2818 2.08965e-09
r_3362_3378_e 3362 3378 13376.4
r_3362_3378_i 3362_3378 3378 93218.1
c_3362_3378_i 3362 3362_3378 2.08965e-09
r_3_19_e 3 19 13376.4
r_3_19_i 3_19 19 93218.1
c_3_19_i 3 3_19 2.08965e-09
r_563_579_e 563 579 13376.4
r_563_579_i 563_579 579 93218.1
c_563_579_i 563 563_579 2.08965e-09
r_1123_1139_e 1123 1139 836.944
r_1123_1139_i 1123_1139 1139 4256.89
c_1123_1139_i 1123 1123_1139 4.67522e-10
r_1683_1699_e 1683 1699 836.944
r_1683_1699_i 1683_1699 1699 4256.89
c_1683_1699_i 1683 1683_1699 4.67522e-10
r_2243_2259_e 2243 2259 836.944
r_2243_2259_i 2243_2259 2259 4256.89
c_2243_2259_i 2243 2243_2259 4.67522e-10
r_2803_2819_e 2803 2819 836.944
r_2803_2819_i 2803_2819 2819 4256.89
c_2803_2819_i 2803 2803_2819 4.67522e-10
r_3363_3379_e 3363 3379 836.944
r_3363_3379_i 3363_3379 3379 4256.89
c_3363_3379_i 3363 3363_3379 4.67522e-10
r_4_20_e 4 20 13376.4
r_4_20_i 4_20 20 93218.1
c_4_20_i 4 4_20 2.08965e-09
r_564_580_e 564 580 13376.4
r_564_580_i 564_580 580 93218.1
c_564_580_i 564 564_580 2.08965e-09
r_1124_1140_e 1124 1140 836.944
r_1124_1140_i 1124_1140 1140 4256.89
c_1124_1140_i 1124 1124_1140 4.67522e-10
r_1684_1700_e 1684 1700 836.944
r_1684_1700_i 1684_1700 1700 4256.89
c_1684_1700_i 1684 1684_1700 4.67522e-10
r_2244_2260_e 2244 2260 836.944
r_2244_2260_i 2244_2260 2260 4256.89
c_2244_2260_i 2244 2244_2260 4.67522e-10
r_2804_2820_e 2804 2820 13758.3
r_2804_2820_i 2804_2820 2820 95645.6
c_2804_2820_i 2804 2804_2820 9.36084e-12
r_3364_3380_e 3364 3380 13758.3
r_3364_3380_i 3364_3380 3380 95645.6
c_3364_3380_i 3364 3364_3380 9.36084e-12
r_5_21_e 5 21 13376.4
r_5_21_i 5_21 21 93218.1
c_5_21_i 5 5_21 2.08965e-09
r_565_581_e 565 581 13376.4
r_565_581_i 565_581 581 93218.1
c_565_581_i 565 565_581 2.08965e-09
r_1125_1141_e 1125 1141 836.944
r_1125_1141_i 1125_1141 1141 4256.89
c_1125_1141_i 1125 1125_1141 4.67522e-10
r_1685_1701_e 1685 1701 836.944
r_1685_1701_i 1685_1701 1701 4256.89
c_1685_1701_i 1685 1685_1701 4.67522e-10
r_2245_2261_e 2245 2261 836.944
r_2245_2261_i 2245_2261 2261 4256.89
c_2245_2261_i 2245 2245_2261 4.67522e-10
r_2805_2821_e 2805 2821 13758.3
r_2805_2821_i 2805_2821 2821 95645.6
c_2805_2821_i 2805 2805_2821 9.36084e-12
r_3365_3381_e 3365 3381 13758.3
r_3365_3381_i 3365_3381 3381 95645.6
c_3365_3381_i 3365 3365_3381 9.36084e-12
r_6_22_e 6 22 13376.4
r_6_22_i 6_22 22 93218.1
c_6_22_i 6 6_22 2.08965e-09
r_566_582_e 566 582 13376.4
r_566_582_i 566_582 582 93218.1
c_566_582_i 566 566_582 2.08965e-09
r_1126_1142_e 1126 1142 836.944
r_1126_1142_i 1126_1142 1142 4256.89
c_1126_1142_i 1126 1126_1142 4.67522e-10
r_1686_1702_e 1686 1702 836.944
r_1686_1702_i 1686_1702 1702 4256.89
c_1686_1702_i 1686 1686_1702 4.67522e-10
r_2246_2262_e 2246 2262 836.944
r_2246_2262_i 2246_2262 2262 4256.89
c_2246_2262_i 2246 2246_2262 4.67522e-10
r_2806_2822_e 2806 2822 13758.3
r_2806_2822_i 2806_2822 2822 95645.6
c_2806_2822_i 2806 2806_2822 9.36084e-12
r_3366_3382_e 3366 3382 13758.3
r_3366_3382_i 3366_3382 3382 95645.6
c_3366_3382_i 3366 3366_3382 9.36084e-12
r_7_23_e 7 23 13376.4
r_7_23_i 7_23 23 93218.1
c_7_23_i 7 7_23 2.08965e-09
r_567_583_e 567 583 13376.4
r_567_583_i 567_583 583 93218.1
c_567_583_i 567 567_583 2.08965e-09
r_1127_1143_e 1127 1143 836.944
r_1127_1143_i 1127_1143 1143 4256.89
c_1127_1143_i 1127 1127_1143 4.67522e-10
r_1687_1703_e 1687 1703 836.944
r_1687_1703_i 1687_1703 1703 4256.89
c_1687_1703_i 1687 1687_1703 4.67522e-10
r_2247_2263_e 2247 2263 836.944
r_2247_2263_i 2247_2263 2263 4256.89
c_2247_2263_i 2247 2247_2263 4.67522e-10
r_2807_2823_e 2807 2823 13758.3
r_2807_2823_i 2807_2823 2823 95645.6
c_2807_2823_i 2807 2807_2823 9.36084e-12
r_3367_3383_e 3367 3383 13758.3
r_3367_3383_i 3367_3383 3383 95645.6
c_3367_3383_i 3367 3367_3383 9.36084e-12
r_8_24_e 8 24 13376.4
r_8_24_i 8_24 24 93218.1
c_8_24_i 8 8_24 2.08965e-09
r_568_584_e 568 584 13376.4
r_568_584_i 568_584 584 93218.1
c_568_584_i 568 568_584 2.08965e-09
r_1128_1144_e 1128 1144 836.944
r_1128_1144_i 1128_1144 1144 4256.89
c_1128_1144_i 1128 1128_1144 4.67522e-10
r_1688_1704_e 1688 1704 836.944
r_1688_1704_i 1688_1704 1704 4256.89
c_1688_1704_i 1688 1688_1704 4.67522e-10
r_2248_2264_e 2248 2264 836.944
r_2248_2264_i 2248_2264 2264 4256.89
c_2248_2264_i 2248 2248_2264 4.67522e-10
r_2808_2824_e 2808 2824 13758.3
r_2808_2824_i 2808_2824 2824 95645.6
c_2808_2824_i 2808 2808_2824 9.36084e-12
r_3368_3384_e 3368 3384 13758.3
r_3368_3384_i 3368_3384 3384 95645.6
c_3368_3384_i 3368 3368_3384 9.36084e-12
r_9_25_e 9 25 13376.4
r_9_25_i 9_25 25 93218.1
c_9_25_i 9 9_25 2.08965e-09
r_569_585_e 569 585 13376.4
r_569_585_i 569_585 585 93218.1
c_569_585_i 569 569_585 2.08965e-09
r_1129_1145_e 1129 1145 836.944
r_1129_1145_i 1129_1145 1145 4256.89
c_1129_1145_i 1129 1129_1145 4.67522e-10
r_1689_1705_e 1689 1705 836.944
r_1689_1705_i 1689_1705 1705 4256.89
c_1689_1705_i 1689 1689_1705 4.67522e-10
r_2249_2265_e 2249 2265 836.944
r_2249_2265_i 2249_2265 2265 4256.89
c_2249_2265_i 2249 2249_2265 4.67522e-10
r_2809_2825_e 2809 2825 13758.3
r_2809_2825_i 2809_2825 2825 95645.6
c_2809_2825_i 2809 2809_2825 9.36084e-12
r_3369_3385_e 3369 3385 13758.3
r_3369_3385_i 3369_3385 3385 95645.6
c_3369_3385_i 3369 3369_3385 9.36084e-12
r_10_26_e 10 26 13376.4
r_10_26_i 10_26 26 93218.1
c_10_26_i 10 10_26 2.08965e-09
r_570_586_e 570 586 13376.4
r_570_586_i 570_586 586 93218.1
c_570_586_i 570 570_586 2.08965e-09
r_1130_1146_e 1130 1146 836.944
r_1130_1146_i 1130_1146 1146 4256.89
c_1130_1146_i 1130 1130_1146 4.67522e-10
r_1690_1706_e 1690 1706 836.944
r_1690_1706_i 1690_1706 1706 4256.89
c_1690_1706_i 1690 1690_1706 4.67522e-10
r_2250_2266_e 2250 2266 836.944
r_2250_2266_i 2250_2266 2266 4256.89
c_2250_2266_i 2250 2250_2266 4.67522e-10
r_2810_2826_e 2810 2826 13758.3
r_2810_2826_i 2810_2826 2826 95645.6
c_2810_2826_i 2810 2810_2826 9.36084e-12
r_3370_3386_e 3370 3386 13758.3
r_3370_3386_i 3370_3386 3386 95645.6
c_3370_3386_i 3370 3370_3386 9.36084e-12
r_11_27_e 11 27 13376.4
r_11_27_i 11_27 27 93218.1
c_11_27_i 11 11_27 2.08965e-09
r_571_587_e 571 587 13376.4
r_571_587_i 571_587 587 93218.1
c_571_587_i 571 571_587 2.08965e-09
r_1131_1147_e 1131 1147 396.769
r_1131_1147_i 1131_1147 1147 1005.45
c_1131_1147_i 1131 1131_1147 1.65766e-10
r_1691_1707_e 1691 1707 396.769
r_1691_1707_i 1691_1707 1707 1005.45
c_1691_1707_i 1691 1691_1707 1.65766e-10
r_2251_2267_e 2251 2267 836.944
r_2251_2267_i 2251_2267 2267 4256.89
c_2251_2267_i 2251 2251_2267 4.67522e-10
r_2811_2827_e 2811 2827 13758.3
r_2811_2827_i 2811_2827 2827 95645.6
c_2811_2827_i 2811 2811_2827 9.36084e-12
r_3371_3387_e 3371 3387 13758.3
r_3371_3387_i 3371_3387 3387 95645.6
c_3371_3387_i 3371 3371_3387 9.36084e-12
r_12_28_e 12 28 13376.4
r_12_28_i 12_28 28 93218.1
c_12_28_i 12 12_28 2.08965e-09
r_572_588_e 572 588 13376.4
r_572_588_i 572_588 588 93218.1
c_572_588_i 572 572_588 2.08965e-09
r_1132_1148_e 1132 1148 396.769
r_1132_1148_i 1132_1148 1148 1005.45
c_1132_1148_i 1132 1132_1148 1.65766e-10
r_1692_1708_e 1692 1708 396.769
r_1692_1708_i 1692_1708 1708 1005.45
c_1692_1708_i 1692 1692_1708 1.65766e-10
r_2252_2268_e 2252 2268 836.944
r_2252_2268_i 2252_2268 2268 4256.89
c_2252_2268_i 2252 2252_2268 4.67522e-10
r_2812_2828_e 2812 2828 13758.3
r_2812_2828_i 2812_2828 2828 95645.6
c_2812_2828_i 2812 2812_2828 9.36084e-12
r_3372_3388_e 3372 3388 13758.3
r_3372_3388_i 3372_3388 3388 95645.6
c_3372_3388_i 3372 3372_3388 9.36084e-12
r_13_29_e 13 29 13376.4
r_13_29_i 13_29 29 93218.1
c_13_29_i 13 13_29 2.08965e-09
r_573_589_e 573 589 13376.4
r_573_589_i 573_589 589 93218.1
c_573_589_i 573 573_589 2.08965e-09
r_1133_1149_e 1133 1149 836.944
r_1133_1149_i 1133_1149 1149 4256.89
c_1133_1149_i 1133 1133_1149 4.67522e-10
r_1693_1709_e 1693 1709 836.944
r_1693_1709_i 1693_1709 1709 4256.89
c_1693_1709_i 1693 1693_1709 4.67522e-10
r_2253_2269_e 2253 2269 836.944
r_2253_2269_i 2253_2269 2269 4256.89
c_2253_2269_i 2253 2253_2269 4.67522e-10
r_2813_2829_e 2813 2829 13758.3
r_2813_2829_i 2813_2829 2829 95645.6
c_2813_2829_i 2813 2813_2829 9.36084e-12
r_3373_3389_e 3373 3389 13758.3
r_3373_3389_i 3373_3389 3389 95645.6
c_3373_3389_i 3373 3373_3389 9.36084e-12
r_14_30_e 14 30 13376.4
r_14_30_i 14_30 30 93218.1
c_14_30_i 14 14_30 2.08965e-09
r_574_590_e 574 590 13376.4
r_574_590_i 574_590 590 93218.1
c_574_590_i 574 574_590 2.08965e-09
r_1134_1150_e 1134 1150 836.944
r_1134_1150_i 1134_1150 1150 4256.89
c_1134_1150_i 1134 1134_1150 4.67522e-10
r_1694_1710_e 1694 1710 836.944
r_1694_1710_i 1694_1710 1710 4256.89
c_1694_1710_i 1694 1694_1710 4.67522e-10
r_2254_2270_e 2254 2270 836.944
r_2254_2270_i 2254_2270 2270 4256.89
c_2254_2270_i 2254 2254_2270 4.67522e-10
r_2814_2830_e 2814 2830 13758.3
r_2814_2830_i 2814_2830 2830 95645.6
c_2814_2830_i 2814 2814_2830 9.36084e-12
r_3374_3390_e 3374 3390 13758.3
r_3374_3390_i 3374_3390 3390 95645.6
c_3374_3390_i 3374 3374_3390 9.36084e-12
r_15_31_e 15 31 13376.4
r_15_31_i 15_31 31 93218.1
c_15_31_i 15 15_31 2.08965e-09
r_575_591_e 575 591 13376.4
r_575_591_i 575_591 591 93218.1
c_575_591_i 575 575_591 2.08965e-09
r_1135_1151_e 1135 1151 836.944
r_1135_1151_i 1135_1151 1151 4256.89
c_1135_1151_i 1135 1135_1151 4.67522e-10
r_1695_1711_e 1695 1711 836.944
r_1695_1711_i 1695_1711 1711 4256.89
c_1695_1711_i 1695 1695_1711 4.67522e-10
r_2255_2271_e 2255 2271 836.944
r_2255_2271_i 2255_2271 2271 4256.89
c_2255_2271_i 2255 2255_2271 4.67522e-10
r_2815_2831_e 2815 2831 13758.3
r_2815_2831_i 2815_2831 2831 95645.6
c_2815_2831_i 2815 2815_2831 9.36084e-12
r_3375_3391_e 3375 3391 13758.3
r_3375_3391_i 3375_3391 3391 95645.6
c_3375_3391_i 3375 3375_3391 9.36084e-12
r_16_32_e 16 32 13376.4
r_16_32_i 16_32 32 93218.1
c_16_32_i 16 16_32 2.08965e-09
r_576_592_e 576 592 13376.4
r_576_592_i 576_592 592 93218.1
c_576_592_i 576 576_592 2.08965e-09
r_1136_1152_e 1136 1152 836.944
r_1136_1152_i 1136_1152 1152 4256.89
c_1136_1152_i 1136 1136_1152 4.67522e-10
r_1696_1712_e 1696 1712 836.944
r_1696_1712_i 1696_1712 1712 4256.89
c_1696_1712_i 1696 1696_1712 4.67522e-10
r_2256_2272_e 2256 2272 836.944
r_2256_2272_i 2256_2272 2272 4256.89
c_2256_2272_i 2256 2256_2272 4.67522e-10
r_2816_2832_e 2816 2832 13758.3
r_2816_2832_i 2816_2832 2832 95645.6
c_2816_2832_i 2816 2816_2832 9.36084e-12
r_3376_3392_e 3376 3392 13758.3
r_3376_3392_i 3376_3392 3392 95645.6
c_3376_3392_i 3376 3376_3392 9.36084e-12
r_17_33_e 17 33 13376.4
r_17_33_i 17_33 33 93218.1
c_17_33_i 17 17_33 2.08965e-09
r_577_593_e 577 593 13376.4
r_577_593_i 577_593 593 93218.1
c_577_593_i 577 577_593 2.08965e-09
r_1137_1153_e 1137 1153 13376.4
r_1137_1153_i 1137_1153 1153 93218.1
c_1137_1153_i 1137 1137_1153 2.08965e-09
r_1697_1713_e 1697 1713 13376.4
r_1697_1713_i 1697_1713 1713 93218.1
c_1697_1713_i 1697 1697_1713 2.08965e-09
r_2257_2273_e 2257 2273 13376.4
r_2257_2273_i 2257_2273 2273 93218.1
c_2257_2273_i 2257 2257_2273 2.08965e-09
r_2817_2833_e 2817 2833 13376.4
r_2817_2833_i 2817_2833 2833 93218.1
c_2817_2833_i 2817 2817_2833 2.08965e-09
r_3377_3393_e 3377 3393 13376.4
r_3377_3393_i 3377_3393 3393 93218.1
c_3377_3393_i 3377 3377_3393 2.08965e-09
r_18_34_e 18 34 13376.4
r_18_34_i 18_34 34 93218.1
c_18_34_i 18 18_34 2.08965e-09
r_578_594_e 578 594 13376.4
r_578_594_i 578_594 594 93218.1
c_578_594_i 578 578_594 2.08965e-09
r_1138_1154_e 1138 1154 13376.4
r_1138_1154_i 1138_1154 1154 93218.1
c_1138_1154_i 1138 1138_1154 2.08965e-09
r_1698_1714_e 1698 1714 13376.4
r_1698_1714_i 1698_1714 1714 93218.1
c_1698_1714_i 1698 1698_1714 2.08965e-09
r_2258_2274_e 2258 2274 13376.4
r_2258_2274_i 2258_2274 2274 93218.1
c_2258_2274_i 2258 2258_2274 2.08965e-09
r_2818_2834_e 2818 2834 13376.4
r_2818_2834_i 2818_2834 2834 93218.1
c_2818_2834_i 2818 2818_2834 2.08965e-09
r_3378_3394_e 3378 3394 13376.4
r_3378_3394_i 3378_3394 3394 93218.1
c_3378_3394_i 3378 3378_3394 2.08965e-09
r_19_35_e 19 35 13376.4
r_19_35_i 19_35 35 93218.1
c_19_35_i 19 19_35 2.08965e-09
r_579_595_e 579 595 13376.4
r_579_595_i 579_595 595 93218.1
c_579_595_i 579 579_595 2.08965e-09
r_1139_1155_e 1139 1155 836.944
r_1139_1155_i 1139_1155 1155 4256.89
c_1139_1155_i 1139 1139_1155 4.67522e-10
r_1699_1715_e 1699 1715 836.944
r_1699_1715_i 1699_1715 1715 4256.89
c_1699_1715_i 1699 1699_1715 4.67522e-10
r_2259_2275_e 2259 2275 836.944
r_2259_2275_i 2259_2275 2275 4256.89
c_2259_2275_i 2259 2259_2275 4.67522e-10
r_2819_2835_e 2819 2835 836.944
r_2819_2835_i 2819_2835 2835 4256.89
c_2819_2835_i 2819 2819_2835 4.67522e-10
r_3379_3395_e 3379 3395 836.944
r_3379_3395_i 3379_3395 3395 4256.89
c_3379_3395_i 3379 3379_3395 4.67522e-10
r_20_36_e 20 36 13376.4
r_20_36_i 20_36 36 93218.1
c_20_36_i 20 20_36 2.08965e-09
r_580_596_e 580 596 13376.4
r_580_596_i 580_596 596 93218.1
c_580_596_i 580 580_596 2.08965e-09
r_1140_1156_e 1140 1156 836.944
r_1140_1156_i 1140_1156 1156 4256.89
c_1140_1156_i 1140 1140_1156 4.67522e-10
r_1700_1716_e 1700 1716 836.944
r_1700_1716_i 1700_1716 1716 4256.89
c_1700_1716_i 1700 1700_1716 4.67522e-10
r_2260_2276_e 2260 2276 836.944
r_2260_2276_i 2260_2276 2276 4256.89
c_2260_2276_i 2260 2260_2276 4.67522e-10
r_2820_2836_e 2820 2836 13758.3
r_2820_2836_i 2820_2836 2836 95645.6
c_2820_2836_i 2820 2820_2836 9.36084e-12
r_3380_3396_e 3380 3396 13758.3
r_3380_3396_i 3380_3396 3396 95645.6
c_3380_3396_i 3380 3380_3396 9.36084e-12
r_21_37_e 21 37 13376.4
r_21_37_i 21_37 37 93218.1
c_21_37_i 21 21_37 2.08965e-09
r_581_597_e 581 597 13376.4
r_581_597_i 581_597 597 93218.1
c_581_597_i 581 581_597 2.08965e-09
r_1141_1157_e 1141 1157 836.944
r_1141_1157_i 1141_1157 1157 4256.89
c_1141_1157_i 1141 1141_1157 4.67522e-10
r_1701_1717_e 1701 1717 836.944
r_1701_1717_i 1701_1717 1717 4256.89
c_1701_1717_i 1701 1701_1717 4.67522e-10
r_2261_2277_e 2261 2277 836.944
r_2261_2277_i 2261_2277 2277 4256.89
c_2261_2277_i 2261 2261_2277 4.67522e-10
r_2821_2837_e 2821 2837 13758.3
r_2821_2837_i 2821_2837 2837 95645.6
c_2821_2837_i 2821 2821_2837 9.36084e-12
r_3381_3397_e 3381 3397 13758.3
r_3381_3397_i 3381_3397 3397 95645.6
c_3381_3397_i 3381 3381_3397 9.36084e-12
r_22_38_e 22 38 13376.4
r_22_38_i 22_38 38 93218.1
c_22_38_i 22 22_38 2.08965e-09
r_582_598_e 582 598 13376.4
r_582_598_i 582_598 598 93218.1
c_582_598_i 582 582_598 2.08965e-09
r_1142_1158_e 1142 1158 836.944
r_1142_1158_i 1142_1158 1158 4256.89
c_1142_1158_i 1142 1142_1158 4.67522e-10
r_1702_1718_e 1702 1718 836.944
r_1702_1718_i 1702_1718 1718 4256.89
c_1702_1718_i 1702 1702_1718 4.67522e-10
r_2262_2278_e 2262 2278 836.944
r_2262_2278_i 2262_2278 2278 4256.89
c_2262_2278_i 2262 2262_2278 4.67522e-10
r_2822_2838_e 2822 2838 13758.3
r_2822_2838_i 2822_2838 2838 95645.6
c_2822_2838_i 2822 2822_2838 9.36084e-12
r_3382_3398_e 3382 3398 13758.3
r_3382_3398_i 3382_3398 3398 95645.6
c_3382_3398_i 3382 3382_3398 9.36084e-12
r_23_39_e 23 39 13376.4
r_23_39_i 23_39 39 93218.1
c_23_39_i 23 23_39 2.08965e-09
r_583_599_e 583 599 13376.4
r_583_599_i 583_599 599 93218.1
c_583_599_i 583 583_599 2.08965e-09
r_1143_1159_e 1143 1159 836.944
r_1143_1159_i 1143_1159 1159 4256.89
c_1143_1159_i 1143 1143_1159 4.67522e-10
r_1703_1719_e 1703 1719 836.944
r_1703_1719_i 1703_1719 1719 4256.89
c_1703_1719_i 1703 1703_1719 4.67522e-10
r_2263_2279_e 2263 2279 836.944
r_2263_2279_i 2263_2279 2279 4256.89
c_2263_2279_i 2263 2263_2279 4.67522e-10
r_2823_2839_e 2823 2839 13758.3
r_2823_2839_i 2823_2839 2839 95645.6
c_2823_2839_i 2823 2823_2839 9.36084e-12
r_3383_3399_e 3383 3399 13758.3
r_3383_3399_i 3383_3399 3399 95645.6
c_3383_3399_i 3383 3383_3399 9.36084e-12
r_24_40_e 24 40 13376.4
r_24_40_i 24_40 40 93218.1
c_24_40_i 24 24_40 2.08965e-09
r_584_600_e 584 600 13376.4
r_584_600_i 584_600 600 93218.1
c_584_600_i 584 584_600 2.08965e-09
r_1144_1160_e 1144 1160 836.944
r_1144_1160_i 1144_1160 1160 4256.89
c_1144_1160_i 1144 1144_1160 4.67522e-10
r_1704_1720_e 1704 1720 836.944
r_1704_1720_i 1704_1720 1720 4256.89
c_1704_1720_i 1704 1704_1720 4.67522e-10
r_2264_2280_e 2264 2280 836.944
r_2264_2280_i 2264_2280 2280 4256.89
c_2264_2280_i 2264 2264_2280 4.67522e-10
r_2824_2840_e 2824 2840 13758.3
r_2824_2840_i 2824_2840 2840 95645.6
c_2824_2840_i 2824 2824_2840 9.36084e-12
r_3384_3400_e 3384 3400 13758.3
r_3384_3400_i 3384_3400 3400 95645.6
c_3384_3400_i 3384 3384_3400 9.36084e-12
r_25_41_e 25 41 13376.4
r_25_41_i 25_41 41 93218.1
c_25_41_i 25 25_41 2.08965e-09
r_585_601_e 585 601 13376.4
r_585_601_i 585_601 601 93218.1
c_585_601_i 585 585_601 2.08965e-09
r_1145_1161_e 1145 1161 836.944
r_1145_1161_i 1145_1161 1161 4256.89
c_1145_1161_i 1145 1145_1161 4.67522e-10
r_1705_1721_e 1705 1721 836.944
r_1705_1721_i 1705_1721 1721 4256.89
c_1705_1721_i 1705 1705_1721 4.67522e-10
r_2265_2281_e 2265 2281 836.944
r_2265_2281_i 2265_2281 2281 4256.89
c_2265_2281_i 2265 2265_2281 4.67522e-10
r_2825_2841_e 2825 2841 13758.3
r_2825_2841_i 2825_2841 2841 95645.6
c_2825_2841_i 2825 2825_2841 9.36084e-12
r_3385_3401_e 3385 3401 13758.3
r_3385_3401_i 3385_3401 3401 95645.6
c_3385_3401_i 3385 3385_3401 9.36084e-12
r_26_42_e 26 42 13376.4
r_26_42_i 26_42 42 93218.1
c_26_42_i 26 26_42 2.08965e-09
r_586_602_e 586 602 13376.4
r_586_602_i 586_602 602 93218.1
c_586_602_i 586 586_602 2.08965e-09
r_1146_1162_e 1146 1162 836.944
r_1146_1162_i 1146_1162 1162 4256.89
c_1146_1162_i 1146 1146_1162 4.67522e-10
r_1706_1722_e 1706 1722 836.944
r_1706_1722_i 1706_1722 1722 4256.89
c_1706_1722_i 1706 1706_1722 4.67522e-10
r_2266_2282_e 2266 2282 836.944
r_2266_2282_i 2266_2282 2282 4256.89
c_2266_2282_i 2266 2266_2282 4.67522e-10
r_2826_2842_e 2826 2842 13758.3
r_2826_2842_i 2826_2842 2842 95645.6
c_2826_2842_i 2826 2826_2842 9.36084e-12
r_3386_3402_e 3386 3402 13758.3
r_3386_3402_i 3386_3402 3402 95645.6
c_3386_3402_i 3386 3386_3402 9.36084e-12
r_27_43_e 27 43 13376.4
r_27_43_i 27_43 43 93218.1
c_27_43_i 27 27_43 2.08965e-09
r_587_603_e 587 603 13376.4
r_587_603_i 587_603 603 93218.1
c_587_603_i 587 587_603 2.08965e-09
r_1147_1163_e 1147 1163 396.76
r_1147_1163_i 1147_1163 1163 1005.43
c_1147_1163_i 1147 1147_1163 1.6577e-10
r_1707_1723_e 1707 1723 396.76
r_1707_1723_i 1707_1723 1723 1005.43
c_1707_1723_i 1707 1707_1723 1.6577e-10
r_2267_2283_e 2267 2283 836.944
r_2267_2283_i 2267_2283 2283 4256.89
c_2267_2283_i 2267 2267_2283 4.67522e-10
r_2827_2843_e 2827 2843 13758.3
r_2827_2843_i 2827_2843 2843 95645.6
c_2827_2843_i 2827 2827_2843 9.36084e-12
r_3387_3403_e 3387 3403 13758.3
r_3387_3403_i 3387_3403 3403 95645.6
c_3387_3403_i 3387 3387_3403 9.36084e-12
r_28_44_e 28 44 13376.4
r_28_44_i 28_44 44 93218.1
c_28_44_i 28 28_44 2.08965e-09
r_588_604_e 588 604 13376.4
r_588_604_i 588_604 604 93218.1
c_588_604_i 588 588_604 2.08965e-09
r_1148_1164_e 1148 1164 396.76
r_1148_1164_i 1148_1164 1164 1005.43
c_1148_1164_i 1148 1148_1164 1.6577e-10
r_1708_1724_e 1708 1724 396.76
r_1708_1724_i 1708_1724 1724 1005.43
c_1708_1724_i 1708 1708_1724 1.6577e-10
r_2268_2284_e 2268 2284 836.944
r_2268_2284_i 2268_2284 2284 4256.89
c_2268_2284_i 2268 2268_2284 4.67522e-10
r_2828_2844_e 2828 2844 13758.3
r_2828_2844_i 2828_2844 2844 95645.6
c_2828_2844_i 2828 2828_2844 9.36084e-12
r_3388_3404_e 3388 3404 13758.3
r_3388_3404_i 3388_3404 3404 95645.6
c_3388_3404_i 3388 3388_3404 9.36084e-12
r_29_45_e 29 45 13376.4
r_29_45_i 29_45 45 93218.1
c_29_45_i 29 29_45 2.08965e-09
r_589_605_e 589 605 13376.4
r_589_605_i 589_605 605 93218.1
c_589_605_i 589 589_605 2.08965e-09
r_1149_1165_e 1149 1165 836.944
r_1149_1165_i 1149_1165 1165 4256.89
c_1149_1165_i 1149 1149_1165 4.67522e-10
r_1709_1725_e 1709 1725 836.944
r_1709_1725_i 1709_1725 1725 4256.89
c_1709_1725_i 1709 1709_1725 4.67522e-10
r_2269_2285_e 2269 2285 836.944
r_2269_2285_i 2269_2285 2285 4256.89
c_2269_2285_i 2269 2269_2285 4.67522e-10
r_2829_2845_e 2829 2845 13758.3
r_2829_2845_i 2829_2845 2845 95645.6
c_2829_2845_i 2829 2829_2845 9.36084e-12
r_3389_3405_e 3389 3405 13758.3
r_3389_3405_i 3389_3405 3405 95645.6
c_3389_3405_i 3389 3389_3405 9.36084e-12
r_30_46_e 30 46 13376.4
r_30_46_i 30_46 46 93218.1
c_30_46_i 30 30_46 2.08965e-09
r_590_606_e 590 606 13376.4
r_590_606_i 590_606 606 93218.1
c_590_606_i 590 590_606 2.08965e-09
r_1150_1166_e 1150 1166 836.944
r_1150_1166_i 1150_1166 1166 4256.89
c_1150_1166_i 1150 1150_1166 4.67522e-10
r_1710_1726_e 1710 1726 836.944
r_1710_1726_i 1710_1726 1726 4256.89
c_1710_1726_i 1710 1710_1726 4.67522e-10
r_2270_2286_e 2270 2286 836.944
r_2270_2286_i 2270_2286 2286 4256.89
c_2270_2286_i 2270 2270_2286 4.67522e-10
r_2830_2846_e 2830 2846 13758.3
r_2830_2846_i 2830_2846 2846 95645.6
c_2830_2846_i 2830 2830_2846 9.36084e-12
r_3390_3406_e 3390 3406 13758.3
r_3390_3406_i 3390_3406 3406 95645.6
c_3390_3406_i 3390 3390_3406 9.36084e-12
r_31_47_e 31 47 13376.4
r_31_47_i 31_47 47 93218.1
c_31_47_i 31 31_47 2.08965e-09
r_591_607_e 591 607 13376.4
r_591_607_i 591_607 607 93218.1
c_591_607_i 591 591_607 2.08965e-09
r_1151_1167_e 1151 1167 836.944
r_1151_1167_i 1151_1167 1167 4256.89
c_1151_1167_i 1151 1151_1167 4.67522e-10
r_1711_1727_e 1711 1727 836.944
r_1711_1727_i 1711_1727 1727 4256.89
c_1711_1727_i 1711 1711_1727 4.67522e-10
r_2271_2287_e 2271 2287 836.944
r_2271_2287_i 2271_2287 2287 4256.89
c_2271_2287_i 2271 2271_2287 4.67522e-10
r_2831_2847_e 2831 2847 13758.3
r_2831_2847_i 2831_2847 2847 95645.6
c_2831_2847_i 2831 2831_2847 9.36084e-12
r_3391_3407_e 3391 3407 13758.3
r_3391_3407_i 3391_3407 3407 95645.6
c_3391_3407_i 3391 3391_3407 9.36084e-12
r_32_48_e 32 48 13376.4
r_32_48_i 32_48 48 93218.1
c_32_48_i 32 32_48 2.08965e-09
r_592_608_e 592 608 13376.4
r_592_608_i 592_608 608 93218.1
c_592_608_i 592 592_608 2.08965e-09
r_1152_1168_e 1152 1168 836.944
r_1152_1168_i 1152_1168 1168 4256.89
c_1152_1168_i 1152 1152_1168 4.67522e-10
r_1712_1728_e 1712 1728 836.944
r_1712_1728_i 1712_1728 1728 4256.89
c_1712_1728_i 1712 1712_1728 4.67522e-10
r_2272_2288_e 2272 2288 836.944
r_2272_2288_i 2272_2288 2288 4256.89
c_2272_2288_i 2272 2272_2288 4.67522e-10
r_2832_2848_e 2832 2848 13758.3
r_2832_2848_i 2832_2848 2848 95645.6
c_2832_2848_i 2832 2832_2848 9.36084e-12
r_3392_3408_e 3392 3408 13758.3
r_3392_3408_i 3392_3408 3408 95645.6
c_3392_3408_i 3392 3392_3408 9.36084e-12
r_33_49_e 33 49 13376.4
r_33_49_i 33_49 49 93218.1
c_33_49_i 33 33_49 2.08965e-09
r_593_609_e 593 609 13376.4
r_593_609_i 593_609 609 93218.1
c_593_609_i 593 593_609 2.08965e-09
r_1153_1169_e 1153 1169 13376.4
r_1153_1169_i 1153_1169 1169 93218.1
c_1153_1169_i 1153 1153_1169 2.08965e-09
r_1713_1729_e 1713 1729 13376.4
r_1713_1729_i 1713_1729 1729 93218.1
c_1713_1729_i 1713 1713_1729 2.08965e-09
r_2273_2289_e 2273 2289 13376.4
r_2273_2289_i 2273_2289 2289 93218.1
c_2273_2289_i 2273 2273_2289 2.08965e-09
r_2833_2849_e 2833 2849 13376.4
r_2833_2849_i 2833_2849 2849 93218.1
c_2833_2849_i 2833 2833_2849 2.08965e-09
r_3393_3409_e 3393 3409 13376.4
r_3393_3409_i 3393_3409 3409 93218.1
c_3393_3409_i 3393 3393_3409 2.08965e-09
r_34_50_e 34 50 13376.4
r_34_50_i 34_50 50 93218.1
c_34_50_i 34 34_50 2.08965e-09
r_594_610_e 594 610 13376.4
r_594_610_i 594_610 610 93218.1
c_594_610_i 594 594_610 2.08965e-09
r_1154_1170_e 1154 1170 13376.4
r_1154_1170_i 1154_1170 1170 93218.1
c_1154_1170_i 1154 1154_1170 2.08965e-09
r_1714_1730_e 1714 1730 13376.4
r_1714_1730_i 1714_1730 1730 93218.1
c_1714_1730_i 1714 1714_1730 2.08965e-09
r_2274_2290_e 2274 2290 13376.4
r_2274_2290_i 2274_2290 2290 93218.1
c_2274_2290_i 2274 2274_2290 2.08965e-09
r_2834_2850_e 2834 2850 13376.4
r_2834_2850_i 2834_2850 2850 93218.1
c_2834_2850_i 2834 2834_2850 2.08965e-09
r_3394_3410_e 3394 3410 13376.4
r_3394_3410_i 3394_3410 3410 93218.1
c_3394_3410_i 3394 3394_3410 2.08965e-09
r_35_51_e 35 51 13376.4
r_35_51_i 35_51 51 93218.1
c_35_51_i 35 35_51 2.08965e-09
r_595_611_e 595 611 13376.4
r_595_611_i 595_611 611 93218.1
c_595_611_i 595 595_611 2.08965e-09
r_1155_1171_e 1155 1171 836.944
r_1155_1171_i 1155_1171 1171 4256.89
c_1155_1171_i 1155 1155_1171 4.67522e-10
r_1715_1731_e 1715 1731 836.944
r_1715_1731_i 1715_1731 1731 4256.89
c_1715_1731_i 1715 1715_1731 4.67522e-10
r_2275_2291_e 2275 2291 836.944
r_2275_2291_i 2275_2291 2291 4256.89
c_2275_2291_i 2275 2275_2291 4.67522e-10
r_2835_2851_e 2835 2851 836.944
r_2835_2851_i 2835_2851 2851 4256.89
c_2835_2851_i 2835 2835_2851 4.67522e-10
r_3395_3411_e 3395 3411 836.944
r_3395_3411_i 3395_3411 3411 4256.89
c_3395_3411_i 3395 3395_3411 4.67522e-10
r_36_52_e 36 52 13376.4
r_36_52_i 36_52 52 93218.1
c_36_52_i 36 36_52 2.08965e-09
r_596_612_e 596 612 13376.4
r_596_612_i 596_612 612 93218.1
c_596_612_i 596 596_612 2.08965e-09
r_1156_1172_e 1156 1172 836.944
r_1156_1172_i 1156_1172 1172 4256.89
c_1156_1172_i 1156 1156_1172 4.67522e-10
r_1716_1732_e 1716 1732 836.944
r_1716_1732_i 1716_1732 1732 4256.89
c_1716_1732_i 1716 1716_1732 4.67522e-10
r_2276_2292_e 2276 2292 836.944
r_2276_2292_i 2276_2292 2292 4256.89
c_2276_2292_i 2276 2276_2292 4.67522e-10
r_2836_2852_e 2836 2852 13758.3
r_2836_2852_i 2836_2852 2852 95645.6
c_2836_2852_i 2836 2836_2852 9.36084e-12
r_3396_3412_e 3396 3412 13758.3
r_3396_3412_i 3396_3412 3412 95645.6
c_3396_3412_i 3396 3396_3412 9.36084e-12
r_37_53_e 37 53 13376.4
r_37_53_i 37_53 53 93218.1
c_37_53_i 37 37_53 2.08965e-09
r_597_613_e 597 613 13376.4
r_597_613_i 597_613 613 93218.1
c_597_613_i 597 597_613 2.08965e-09
r_1157_1173_e 1157 1173 836.944
r_1157_1173_i 1157_1173 1173 4256.89
c_1157_1173_i 1157 1157_1173 4.67522e-10
r_1717_1733_e 1717 1733 836.944
r_1717_1733_i 1717_1733 1733 4256.89
c_1717_1733_i 1717 1717_1733 4.67522e-10
r_2277_2293_e 2277 2293 836.944
r_2277_2293_i 2277_2293 2293 4256.89
c_2277_2293_i 2277 2277_2293 4.67522e-10
r_2837_2853_e 2837 2853 13758.3
r_2837_2853_i 2837_2853 2853 95645.6
c_2837_2853_i 2837 2837_2853 9.36084e-12
r_3397_3413_e 3397 3413 13758.3
r_3397_3413_i 3397_3413 3413 95645.6
c_3397_3413_i 3397 3397_3413 9.36084e-12
r_38_54_e 38 54 13376.4
r_38_54_i 38_54 54 93218.1
c_38_54_i 38 38_54 2.08965e-09
r_598_614_e 598 614 13376.4
r_598_614_i 598_614 614 93218.1
c_598_614_i 598 598_614 2.08965e-09
r_1158_1174_e 1158 1174 836.944
r_1158_1174_i 1158_1174 1174 4256.89
c_1158_1174_i 1158 1158_1174 4.67522e-10
r_1718_1734_e 1718 1734 836.944
r_1718_1734_i 1718_1734 1734 4256.89
c_1718_1734_i 1718 1718_1734 4.67522e-10
r_2278_2294_e 2278 2294 836.944
r_2278_2294_i 2278_2294 2294 4256.89
c_2278_2294_i 2278 2278_2294 4.67522e-10
r_2838_2854_e 2838 2854 13758.3
r_2838_2854_i 2838_2854 2854 95645.6
c_2838_2854_i 2838 2838_2854 9.36084e-12
r_3398_3414_e 3398 3414 13758.3
r_3398_3414_i 3398_3414 3414 95645.6
c_3398_3414_i 3398 3398_3414 9.36084e-12
r_39_55_e 39 55 13376.4
r_39_55_i 39_55 55 93218.1
c_39_55_i 39 39_55 2.08965e-09
r_599_615_e 599 615 13376.4
r_599_615_i 599_615 615 93218.1
c_599_615_i 599 599_615 2.08965e-09
r_1159_1175_e 1159 1175 836.944
r_1159_1175_i 1159_1175 1175 4256.89
c_1159_1175_i 1159 1159_1175 4.67522e-10
r_1719_1735_e 1719 1735 836.944
r_1719_1735_i 1719_1735 1735 4256.89
c_1719_1735_i 1719 1719_1735 4.67522e-10
r_2279_2295_e 2279 2295 836.944
r_2279_2295_i 2279_2295 2295 4256.89
c_2279_2295_i 2279 2279_2295 4.67522e-10
r_2839_2855_e 2839 2855 13758.3
r_2839_2855_i 2839_2855 2855 95645.6
c_2839_2855_i 2839 2839_2855 9.36084e-12
r_3399_3415_e 3399 3415 13758.3
r_3399_3415_i 3399_3415 3415 95645.6
c_3399_3415_i 3399 3399_3415 9.36084e-12
r_40_56_e 40 56 13376.4
r_40_56_i 40_56 56 93218.1
c_40_56_i 40 40_56 2.08965e-09
r_600_616_e 600 616 13376.4
r_600_616_i 600_616 616 93218.1
c_600_616_i 600 600_616 2.08965e-09
r_1160_1176_e 1160 1176 836.944
r_1160_1176_i 1160_1176 1176 4256.89
c_1160_1176_i 1160 1160_1176 4.67522e-10
r_1720_1736_e 1720 1736 836.944
r_1720_1736_i 1720_1736 1736 4256.89
c_1720_1736_i 1720 1720_1736 4.67522e-10
r_2280_2296_e 2280 2296 836.944
r_2280_2296_i 2280_2296 2296 4256.89
c_2280_2296_i 2280 2280_2296 4.67522e-10
r_2840_2856_e 2840 2856 13758.3
r_2840_2856_i 2840_2856 2856 95645.6
c_2840_2856_i 2840 2840_2856 9.36084e-12
r_3400_3416_e 3400 3416 13758.3
r_3400_3416_i 3400_3416 3416 95645.6
c_3400_3416_i 3400 3400_3416 9.36084e-12
r_41_57_e 41 57 13376.4
r_41_57_i 41_57 57 93218.1
c_41_57_i 41 41_57 2.08965e-09
r_601_617_e 601 617 13376.4
r_601_617_i 601_617 617 93218.1
c_601_617_i 601 601_617 2.08965e-09
r_1161_1177_e 1161 1177 836.944
r_1161_1177_i 1161_1177 1177 4256.89
c_1161_1177_i 1161 1161_1177 4.67522e-10
r_1721_1737_e 1721 1737 836.944
r_1721_1737_i 1721_1737 1737 4256.89
c_1721_1737_i 1721 1721_1737 4.67522e-10
r_2281_2297_e 2281 2297 836.944
r_2281_2297_i 2281_2297 2297 4256.89
c_2281_2297_i 2281 2281_2297 4.67522e-10
r_2841_2857_e 2841 2857 13758.3
r_2841_2857_i 2841_2857 2857 95645.6
c_2841_2857_i 2841 2841_2857 9.36084e-12
r_3401_3417_e 3401 3417 13758.3
r_3401_3417_i 3401_3417 3417 95645.6
c_3401_3417_i 3401 3401_3417 9.36084e-12
r_42_58_e 42 58 13376.4
r_42_58_i 42_58 58 93218.1
c_42_58_i 42 42_58 2.08965e-09
r_602_618_e 602 618 13376.4
r_602_618_i 602_618 618 93218.1
c_602_618_i 602 602_618 2.08965e-09
r_1162_1178_e 1162 1178 836.944
r_1162_1178_i 1162_1178 1178 4256.89
c_1162_1178_i 1162 1162_1178 4.67522e-10
r_1722_1738_e 1722 1738 836.944
r_1722_1738_i 1722_1738 1738 4256.89
c_1722_1738_i 1722 1722_1738 4.67522e-10
r_2282_2298_e 2282 2298 836.944
r_2282_2298_i 2282_2298 2298 4256.89
c_2282_2298_i 2282 2282_2298 4.67522e-10
r_2842_2858_e 2842 2858 13758.3
r_2842_2858_i 2842_2858 2858 95645.6
c_2842_2858_i 2842 2842_2858 9.36084e-12
r_3402_3418_e 3402 3418 13758.3
r_3402_3418_i 3402_3418 3418 95645.6
c_3402_3418_i 3402 3402_3418 9.36084e-12
r_43_59_e 43 59 13376.4
r_43_59_i 43_59 59 93218.1
c_43_59_i 43 43_59 2.08965e-09
r_603_619_e 603 619 13376.4
r_603_619_i 603_619 619 93218.1
c_603_619_i 603 603_619 2.08965e-09
r_1163_1179_e 1163 1179 396.751
r_1163_1179_i 1163_1179 1179 1005.4
c_1163_1179_i 1163 1163_1179 1.65774e-10
r_1723_1739_e 1723 1739 396.751
r_1723_1739_i 1723_1739 1739 1005.4
c_1723_1739_i 1723 1723_1739 1.65774e-10
r_2283_2299_e 2283 2299 836.944
r_2283_2299_i 2283_2299 2299 4256.89
c_2283_2299_i 2283 2283_2299 4.67522e-10
r_2843_2859_e 2843 2859 13758.3
r_2843_2859_i 2843_2859 2859 95645.6
c_2843_2859_i 2843 2843_2859 9.36084e-12
r_3403_3419_e 3403 3419 13758.3
r_3403_3419_i 3403_3419 3419 95645.6
c_3403_3419_i 3403 3403_3419 9.36084e-12
r_44_60_e 44 60 13376.4
r_44_60_i 44_60 60 93218.1
c_44_60_i 44 44_60 2.08965e-09
r_604_620_e 604 620 13376.4
r_604_620_i 604_620 620 93218.1
c_604_620_i 604 604_620 2.08965e-09
r_1164_1180_e 1164 1180 396.751
r_1164_1180_i 1164_1180 1180 1005.4
c_1164_1180_i 1164 1164_1180 1.65774e-10
r_1724_1740_e 1724 1740 396.751
r_1724_1740_i 1724_1740 1740 1005.4
c_1724_1740_i 1724 1724_1740 1.65774e-10
r_2284_2300_e 2284 2300 836.944
r_2284_2300_i 2284_2300 2300 4256.89
c_2284_2300_i 2284 2284_2300 4.67522e-10
r_2844_2860_e 2844 2860 13758.3
r_2844_2860_i 2844_2860 2860 95645.6
c_2844_2860_i 2844 2844_2860 9.36084e-12
r_3404_3420_e 3404 3420 13758.3
r_3404_3420_i 3404_3420 3420 95645.6
c_3404_3420_i 3404 3404_3420 9.36084e-12
r_45_61_e 45 61 13376.4
r_45_61_i 45_61 61 93218.1
c_45_61_i 45 45_61 2.08965e-09
r_605_621_e 605 621 13376.4
r_605_621_i 605_621 621 93218.1
c_605_621_i 605 605_621 2.08965e-09
r_1165_1181_e 1165 1181 836.944
r_1165_1181_i 1165_1181 1181 4256.89
c_1165_1181_i 1165 1165_1181 4.67522e-10
r_1725_1741_e 1725 1741 836.944
r_1725_1741_i 1725_1741 1741 4256.89
c_1725_1741_i 1725 1725_1741 4.67522e-10
r_2285_2301_e 2285 2301 836.944
r_2285_2301_i 2285_2301 2301 4256.89
c_2285_2301_i 2285 2285_2301 4.67522e-10
r_2845_2861_e 2845 2861 13758.3
r_2845_2861_i 2845_2861 2861 95645.6
c_2845_2861_i 2845 2845_2861 9.36084e-12
r_3405_3421_e 3405 3421 13758.3
r_3405_3421_i 3405_3421 3421 95645.6
c_3405_3421_i 3405 3405_3421 9.36084e-12
r_46_62_e 46 62 13376.4
r_46_62_i 46_62 62 93218.1
c_46_62_i 46 46_62 2.08965e-09
r_606_622_e 606 622 13376.4
r_606_622_i 606_622 622 93218.1
c_606_622_i 606 606_622 2.08965e-09
r_1166_1182_e 1166 1182 836.944
r_1166_1182_i 1166_1182 1182 4256.89
c_1166_1182_i 1166 1166_1182 4.67522e-10
r_1726_1742_e 1726 1742 836.944
r_1726_1742_i 1726_1742 1742 4256.89
c_1726_1742_i 1726 1726_1742 4.67522e-10
r_2286_2302_e 2286 2302 836.944
r_2286_2302_i 2286_2302 2302 4256.89
c_2286_2302_i 2286 2286_2302 4.67522e-10
r_2846_2862_e 2846 2862 13758.3
r_2846_2862_i 2846_2862 2862 95645.6
c_2846_2862_i 2846 2846_2862 9.36084e-12
r_3406_3422_e 3406 3422 13758.3
r_3406_3422_i 3406_3422 3422 95645.6
c_3406_3422_i 3406 3406_3422 9.36084e-12
r_47_63_e 47 63 13376.4
r_47_63_i 47_63 63 93218.1
c_47_63_i 47 47_63 2.08965e-09
r_607_623_e 607 623 13376.4
r_607_623_i 607_623 623 93218.1
c_607_623_i 607 607_623 2.08965e-09
r_1167_1183_e 1167 1183 836.944
r_1167_1183_i 1167_1183 1183 4256.89
c_1167_1183_i 1167 1167_1183 4.67522e-10
r_1727_1743_e 1727 1743 836.944
r_1727_1743_i 1727_1743 1743 4256.89
c_1727_1743_i 1727 1727_1743 4.67522e-10
r_2287_2303_e 2287 2303 836.944
r_2287_2303_i 2287_2303 2303 4256.89
c_2287_2303_i 2287 2287_2303 4.67522e-10
r_2847_2863_e 2847 2863 13758.3
r_2847_2863_i 2847_2863 2863 95645.6
c_2847_2863_i 2847 2847_2863 9.36084e-12
r_3407_3423_e 3407 3423 13758.3
r_3407_3423_i 3407_3423 3423 95645.6
c_3407_3423_i 3407 3407_3423 9.36084e-12
r_48_64_e 48 64 13376.4
r_48_64_i 48_64 64 93218.1
c_48_64_i 48 48_64 2.08965e-09
r_608_624_e 608 624 13376.4
r_608_624_i 608_624 624 93218.1
c_608_624_i 608 608_624 2.08965e-09
r_1168_1184_e 1168 1184 836.944
r_1168_1184_i 1168_1184 1184 4256.89
c_1168_1184_i 1168 1168_1184 4.67522e-10
r_1728_1744_e 1728 1744 836.944
r_1728_1744_i 1728_1744 1744 4256.89
c_1728_1744_i 1728 1728_1744 4.67522e-10
r_2288_2304_e 2288 2304 836.944
r_2288_2304_i 2288_2304 2304 4256.89
c_2288_2304_i 2288 2288_2304 4.67522e-10
r_2848_2864_e 2848 2864 13758.3
r_2848_2864_i 2848_2864 2864 95645.6
c_2848_2864_i 2848 2848_2864 9.36084e-12
r_3408_3424_e 3408 3424 13758.3
r_3408_3424_i 3408_3424 3424 95645.6
c_3408_3424_i 3408 3408_3424 9.36084e-12
r_49_65_e 49 65 13376.4
r_49_65_i 49_65 65 93218.1
c_49_65_i 49 49_65 2.08965e-09
r_609_625_e 609 625 13376.4
r_609_625_i 609_625 625 93218.1
c_609_625_i 609 609_625 2.08965e-09
r_1169_1185_e 1169 1185 13376.4
r_1169_1185_i 1169_1185 1185 93218.1
c_1169_1185_i 1169 1169_1185 2.08965e-09
r_1729_1745_e 1729 1745 13376.4
r_1729_1745_i 1729_1745 1745 93218.1
c_1729_1745_i 1729 1729_1745 2.08965e-09
r_2289_2305_e 2289 2305 13376.4
r_2289_2305_i 2289_2305 2305 93218.1
c_2289_2305_i 2289 2289_2305 2.08965e-09
r_2849_2865_e 2849 2865 13376.4
r_2849_2865_i 2849_2865 2865 93218.1
c_2849_2865_i 2849 2849_2865 2.08965e-09
r_3409_3425_e 3409 3425 13376.4
r_3409_3425_i 3409_3425 3425 93218.1
c_3409_3425_i 3409 3409_3425 2.08965e-09
r_50_66_e 50 66 13376.4
r_50_66_i 50_66 66 93218.1
c_50_66_i 50 50_66 2.08965e-09
r_610_626_e 610 626 13376.4
r_610_626_i 610_626 626 93218.1
c_610_626_i 610 610_626 2.08965e-09
r_1170_1186_e 1170 1186 13376.4
r_1170_1186_i 1170_1186 1186 93218.1
c_1170_1186_i 1170 1170_1186 2.08965e-09
r_1730_1746_e 1730 1746 13376.4
r_1730_1746_i 1730_1746 1746 93218.1
c_1730_1746_i 1730 1730_1746 2.08965e-09
r_2290_2306_e 2290 2306 13376.4
r_2290_2306_i 2290_2306 2306 93218.1
c_2290_2306_i 2290 2290_2306 2.08965e-09
r_2850_2866_e 2850 2866 13376.4
r_2850_2866_i 2850_2866 2866 93218.1
c_2850_2866_i 2850 2850_2866 2.08965e-09
r_3410_3426_e 3410 3426 13376.4
r_3410_3426_i 3410_3426 3426 93218.1
c_3410_3426_i 3410 3410_3426 2.08965e-09
r_51_67_e 51 67 13376.4
r_51_67_i 51_67 67 93218.1
c_51_67_i 51 51_67 2.08965e-09
r_611_627_e 611 627 13376.4
r_611_627_i 611_627 627 93218.1
c_611_627_i 611 611_627 2.08965e-09
r_1171_1187_e 1171 1187 836.944
r_1171_1187_i 1171_1187 1187 4256.89
c_1171_1187_i 1171 1171_1187 4.67522e-10
r_1731_1747_e 1731 1747 836.944
r_1731_1747_i 1731_1747 1747 4256.89
c_1731_1747_i 1731 1731_1747 4.67522e-10
r_2291_2307_e 2291 2307 836.944
r_2291_2307_i 2291_2307 2307 4256.89
c_2291_2307_i 2291 2291_2307 4.67522e-10
r_2851_2867_e 2851 2867 836.944
r_2851_2867_i 2851_2867 2867 4256.89
c_2851_2867_i 2851 2851_2867 4.67522e-10
r_3411_3427_e 3411 3427 836.944
r_3411_3427_i 3411_3427 3427 4256.89
c_3411_3427_i 3411 3411_3427 4.67522e-10
r_52_68_e 52 68 13376.4
r_52_68_i 52_68 68 93218.1
c_52_68_i 52 52_68 2.08965e-09
r_612_628_e 612 628 13376.4
r_612_628_i 612_628 628 93218.1
c_612_628_i 612 612_628 2.08965e-09
r_1172_1188_e 1172 1188 836.944
r_1172_1188_i 1172_1188 1188 4256.89
c_1172_1188_i 1172 1172_1188 4.67522e-10
r_1732_1748_e 1732 1748 836.944
r_1732_1748_i 1732_1748 1748 4256.89
c_1732_1748_i 1732 1732_1748 4.67522e-10
r_2292_2308_e 2292 2308 836.944
r_2292_2308_i 2292_2308 2308 4256.89
c_2292_2308_i 2292 2292_2308 4.67522e-10
r_2852_2868_e 2852 2868 13758.3
r_2852_2868_i 2852_2868 2868 95645.6
c_2852_2868_i 2852 2852_2868 9.36084e-12
r_3412_3428_e 3412 3428 13758.3
r_3412_3428_i 3412_3428 3428 95645.6
c_3412_3428_i 3412 3412_3428 9.36084e-12
r_53_69_e 53 69 13376.4
r_53_69_i 53_69 69 93218.1
c_53_69_i 53 53_69 2.08965e-09
r_613_629_e 613 629 13376.4
r_613_629_i 613_629 629 93218.1
c_613_629_i 613 613_629 2.08965e-09
r_1173_1189_e 1173 1189 836.944
r_1173_1189_i 1173_1189 1189 4256.89
c_1173_1189_i 1173 1173_1189 4.67522e-10
r_1733_1749_e 1733 1749 836.944
r_1733_1749_i 1733_1749 1749 4256.89
c_1733_1749_i 1733 1733_1749 4.67522e-10
r_2293_2309_e 2293 2309 836.944
r_2293_2309_i 2293_2309 2309 4256.89
c_2293_2309_i 2293 2293_2309 4.67522e-10
r_2853_2869_e 2853 2869 13758.3
r_2853_2869_i 2853_2869 2869 95645.6
c_2853_2869_i 2853 2853_2869 9.36084e-12
r_3413_3429_e 3413 3429 13758.3
r_3413_3429_i 3413_3429 3429 95645.6
c_3413_3429_i 3413 3413_3429 9.36084e-12
r_54_70_e 54 70 13376.4
r_54_70_i 54_70 70 93218.1
c_54_70_i 54 54_70 2.08965e-09
r_614_630_e 614 630 13376.4
r_614_630_i 614_630 630 93218.1
c_614_630_i 614 614_630 2.08965e-09
r_1174_1190_e 1174 1190 836.944
r_1174_1190_i 1174_1190 1190 4256.89
c_1174_1190_i 1174 1174_1190 4.67522e-10
r_1734_1750_e 1734 1750 836.944
r_1734_1750_i 1734_1750 1750 4256.89
c_1734_1750_i 1734 1734_1750 4.67522e-10
r_2294_2310_e 2294 2310 836.944
r_2294_2310_i 2294_2310 2310 4256.89
c_2294_2310_i 2294 2294_2310 4.67522e-10
r_2854_2870_e 2854 2870 13758.3
r_2854_2870_i 2854_2870 2870 95645.6
c_2854_2870_i 2854 2854_2870 9.36084e-12
r_3414_3430_e 3414 3430 13758.3
r_3414_3430_i 3414_3430 3430 95645.6
c_3414_3430_i 3414 3414_3430 9.36084e-12
r_55_71_e 55 71 13376.4
r_55_71_i 55_71 71 93218.1
c_55_71_i 55 55_71 2.08965e-09
r_615_631_e 615 631 13376.4
r_615_631_i 615_631 631 93218.1
c_615_631_i 615 615_631 2.08965e-09
r_1175_1191_e 1175 1191 836.944
r_1175_1191_i 1175_1191 1191 4256.89
c_1175_1191_i 1175 1175_1191 4.67522e-10
r_1735_1751_e 1735 1751 836.944
r_1735_1751_i 1735_1751 1751 4256.89
c_1735_1751_i 1735 1735_1751 4.67522e-10
r_2295_2311_e 2295 2311 836.944
r_2295_2311_i 2295_2311 2311 4256.89
c_2295_2311_i 2295 2295_2311 4.67522e-10
r_2855_2871_e 2855 2871 13758.3
r_2855_2871_i 2855_2871 2871 95645.6
c_2855_2871_i 2855 2855_2871 9.36084e-12
r_3415_3431_e 3415 3431 13758.3
r_3415_3431_i 3415_3431 3431 95645.6
c_3415_3431_i 3415 3415_3431 9.36084e-12
r_56_72_e 56 72 13376.4
r_56_72_i 56_72 72 93218.1
c_56_72_i 56 56_72 2.08965e-09
r_616_632_e 616 632 13376.4
r_616_632_i 616_632 632 93218.1
c_616_632_i 616 616_632 2.08965e-09
r_1176_1192_e 1176 1192 836.944
r_1176_1192_i 1176_1192 1192 4256.89
c_1176_1192_i 1176 1176_1192 4.67522e-10
r_1736_1752_e 1736 1752 836.944
r_1736_1752_i 1736_1752 1752 4256.89
c_1736_1752_i 1736 1736_1752 4.67522e-10
r_2296_2312_e 2296 2312 836.944
r_2296_2312_i 2296_2312 2312 4256.89
c_2296_2312_i 2296 2296_2312 4.67522e-10
r_2856_2872_e 2856 2872 13758.3
r_2856_2872_i 2856_2872 2872 95645.6
c_2856_2872_i 2856 2856_2872 9.36084e-12
r_3416_3432_e 3416 3432 13758.3
r_3416_3432_i 3416_3432 3432 95645.6
c_3416_3432_i 3416 3416_3432 9.36084e-12
r_57_73_e 57 73 13376.4
r_57_73_i 57_73 73 93218.1
c_57_73_i 57 57_73 2.08965e-09
r_617_633_e 617 633 13376.4
r_617_633_i 617_633 633 93218.1
c_617_633_i 617 617_633 2.08965e-09
r_1177_1193_e 1177 1193 836.944
r_1177_1193_i 1177_1193 1193 4256.89
c_1177_1193_i 1177 1177_1193 4.67522e-10
r_1737_1753_e 1737 1753 836.944
r_1737_1753_i 1737_1753 1753 4256.89
c_1737_1753_i 1737 1737_1753 4.67522e-10
r_2297_2313_e 2297 2313 836.944
r_2297_2313_i 2297_2313 2313 4256.89
c_2297_2313_i 2297 2297_2313 4.67522e-10
r_2857_2873_e 2857 2873 13758.3
r_2857_2873_i 2857_2873 2873 95645.6
c_2857_2873_i 2857 2857_2873 9.36084e-12
r_3417_3433_e 3417 3433 13758.3
r_3417_3433_i 3417_3433 3433 95645.6
c_3417_3433_i 3417 3417_3433 9.36084e-12
r_58_74_e 58 74 13376.4
r_58_74_i 58_74 74 93218.1
c_58_74_i 58 58_74 2.08965e-09
r_618_634_e 618 634 13376.4
r_618_634_i 618_634 634 93218.1
c_618_634_i 618 618_634 2.08965e-09
r_1178_1194_e 1178 1194 836.944
r_1178_1194_i 1178_1194 1194 4256.89
c_1178_1194_i 1178 1178_1194 4.67522e-10
r_1738_1754_e 1738 1754 836.944
r_1738_1754_i 1738_1754 1754 4256.89
c_1738_1754_i 1738 1738_1754 4.67522e-10
r_2298_2314_e 2298 2314 836.944
r_2298_2314_i 2298_2314 2314 4256.89
c_2298_2314_i 2298 2298_2314 4.67522e-10
r_2858_2874_e 2858 2874 13758.3
r_2858_2874_i 2858_2874 2874 95645.6
c_2858_2874_i 2858 2858_2874 9.36084e-12
r_3418_3434_e 3418 3434 13758.3
r_3418_3434_i 3418_3434 3434 95645.6
c_3418_3434_i 3418 3418_3434 9.36084e-12
r_59_75_e 59 75 13376.4
r_59_75_i 59_75 75 93218.1
c_59_75_i 59 59_75 2.08965e-09
r_619_635_e 619 635 13376.4
r_619_635_i 619_635 635 93218.1
c_619_635_i 619 619_635 2.08965e-09
r_1179_1195_e 1179 1195 396.742
r_1179_1195_i 1179_1195 1195 1005.38
c_1179_1195_i 1179 1179_1195 1.65777e-10
r_1739_1755_e 1739 1755 396.742
r_1739_1755_i 1739_1755 1755 1005.38
c_1739_1755_i 1739 1739_1755 1.65777e-10
r_2299_2315_e 2299 2315 836.944
r_2299_2315_i 2299_2315 2315 4256.89
c_2299_2315_i 2299 2299_2315 4.67522e-10
r_2859_2875_e 2859 2875 13758.3
r_2859_2875_i 2859_2875 2875 95645.6
c_2859_2875_i 2859 2859_2875 9.36084e-12
r_3419_3435_e 3419 3435 13758.3
r_3419_3435_i 3419_3435 3435 95645.6
c_3419_3435_i 3419 3419_3435 9.36084e-12
r_60_76_e 60 76 13376.4
r_60_76_i 60_76 76 93218.1
c_60_76_i 60 60_76 2.08965e-09
r_620_636_e 620 636 13376.4
r_620_636_i 620_636 636 93218.1
c_620_636_i 620 620_636 2.08965e-09
r_1180_1196_e 1180 1196 396.742
r_1180_1196_i 1180_1196 1196 1005.38
c_1180_1196_i 1180 1180_1196 1.65777e-10
r_1740_1756_e 1740 1756 396.742
r_1740_1756_i 1740_1756 1756 1005.38
c_1740_1756_i 1740 1740_1756 1.65777e-10
r_2300_2316_e 2300 2316 836.944
r_2300_2316_i 2300_2316 2316 4256.89
c_2300_2316_i 2300 2300_2316 4.67522e-10
r_2860_2876_e 2860 2876 13758.3
r_2860_2876_i 2860_2876 2876 95645.6
c_2860_2876_i 2860 2860_2876 9.36084e-12
r_3420_3436_e 3420 3436 13758.3
r_3420_3436_i 3420_3436 3436 95645.6
c_3420_3436_i 3420 3420_3436 9.36084e-12
r_61_77_e 61 77 13376.4
r_61_77_i 61_77 77 93218.1
c_61_77_i 61 61_77 2.08965e-09
r_621_637_e 621 637 13376.4
r_621_637_i 621_637 637 93218.1
c_621_637_i 621 621_637 2.08965e-09
r_1181_1197_e 1181 1197 836.944
r_1181_1197_i 1181_1197 1197 4256.89
c_1181_1197_i 1181 1181_1197 4.67522e-10
r_1741_1757_e 1741 1757 836.944
r_1741_1757_i 1741_1757 1757 4256.89
c_1741_1757_i 1741 1741_1757 4.67522e-10
r_2301_2317_e 2301 2317 836.944
r_2301_2317_i 2301_2317 2317 4256.89
c_2301_2317_i 2301 2301_2317 4.67522e-10
r_2861_2877_e 2861 2877 13758.3
r_2861_2877_i 2861_2877 2877 95645.6
c_2861_2877_i 2861 2861_2877 9.36084e-12
r_3421_3437_e 3421 3437 13758.3
r_3421_3437_i 3421_3437 3437 95645.6
c_3421_3437_i 3421 3421_3437 9.36084e-12
r_62_78_e 62 78 13376.4
r_62_78_i 62_78 78 93218.1
c_62_78_i 62 62_78 2.08965e-09
r_622_638_e 622 638 13376.4
r_622_638_i 622_638 638 93218.1
c_622_638_i 622 622_638 2.08965e-09
r_1182_1198_e 1182 1198 836.944
r_1182_1198_i 1182_1198 1198 4256.89
c_1182_1198_i 1182 1182_1198 4.67522e-10
r_1742_1758_e 1742 1758 836.944
r_1742_1758_i 1742_1758 1758 4256.89
c_1742_1758_i 1742 1742_1758 4.67522e-10
r_2302_2318_e 2302 2318 836.944
r_2302_2318_i 2302_2318 2318 4256.89
c_2302_2318_i 2302 2302_2318 4.67522e-10
r_2862_2878_e 2862 2878 13758.3
r_2862_2878_i 2862_2878 2878 95645.6
c_2862_2878_i 2862 2862_2878 9.36084e-12
r_3422_3438_e 3422 3438 13758.3
r_3422_3438_i 3422_3438 3438 95645.6
c_3422_3438_i 3422 3422_3438 9.36084e-12
r_63_79_e 63 79 13376.4
r_63_79_i 63_79 79 93218.1
c_63_79_i 63 63_79 2.08965e-09
r_623_639_e 623 639 13376.4
r_623_639_i 623_639 639 93218.1
c_623_639_i 623 623_639 2.08965e-09
r_1183_1199_e 1183 1199 836.944
r_1183_1199_i 1183_1199 1199 4256.89
c_1183_1199_i 1183 1183_1199 4.67522e-10
r_1743_1759_e 1743 1759 836.944
r_1743_1759_i 1743_1759 1759 4256.89
c_1743_1759_i 1743 1743_1759 4.67522e-10
r_2303_2319_e 2303 2319 836.944
r_2303_2319_i 2303_2319 2319 4256.89
c_2303_2319_i 2303 2303_2319 4.67522e-10
r_2863_2879_e 2863 2879 13758.3
r_2863_2879_i 2863_2879 2879 95645.6
c_2863_2879_i 2863 2863_2879 9.36084e-12
r_3423_3439_e 3423 3439 13758.3
r_3423_3439_i 3423_3439 3439 95645.6
c_3423_3439_i 3423 3423_3439 9.36084e-12
r_64_80_e 64 80 13376.4
r_64_80_i 64_80 80 93218.1
c_64_80_i 64 64_80 2.08965e-09
r_624_640_e 624 640 13376.4
r_624_640_i 624_640 640 93218.1
c_624_640_i 624 624_640 2.08965e-09
r_1184_1200_e 1184 1200 836.944
r_1184_1200_i 1184_1200 1200 4256.89
c_1184_1200_i 1184 1184_1200 4.67522e-10
r_1744_1760_e 1744 1760 836.944
r_1744_1760_i 1744_1760 1760 4256.89
c_1744_1760_i 1744 1744_1760 4.67522e-10
r_2304_2320_e 2304 2320 836.944
r_2304_2320_i 2304_2320 2320 4256.89
c_2304_2320_i 2304 2304_2320 4.67522e-10
r_2864_2880_e 2864 2880 13758.3
r_2864_2880_i 2864_2880 2880 95645.6
c_2864_2880_i 2864 2864_2880 9.36084e-12
r_3424_3440_e 3424 3440 13758.3
r_3424_3440_i 3424_3440 3440 95645.6
c_3424_3440_i 3424 3424_3440 9.36084e-12
r_65_81_e 65 81 13376.4
r_65_81_i 65_81 81 93218.1
c_65_81_i 65 65_81 2.08965e-09
r_625_641_e 625 641 13376.4
r_625_641_i 625_641 641 93218.1
c_625_641_i 625 625_641 2.08965e-09
r_1185_1201_e 1185 1201 13376.4
r_1185_1201_i 1185_1201 1201 93218.1
c_1185_1201_i 1185 1185_1201 2.08965e-09
r_1745_1761_e 1745 1761 13376.4
r_1745_1761_i 1745_1761 1761 93218.1
c_1745_1761_i 1745 1745_1761 2.08965e-09
r_2305_2321_e 2305 2321 13376.4
r_2305_2321_i 2305_2321 2321 93218.1
c_2305_2321_i 2305 2305_2321 2.08965e-09
r_2865_2881_e 2865 2881 13376.4
r_2865_2881_i 2865_2881 2881 93218.1
c_2865_2881_i 2865 2865_2881 2.08965e-09
r_3425_3441_e 3425 3441 13376.4
r_3425_3441_i 3425_3441 3441 93218.1
c_3425_3441_i 3425 3425_3441 2.08965e-09
r_66_82_e 66 82 13376.4
r_66_82_i 66_82 82 93218.1
c_66_82_i 66 66_82 2.08965e-09
r_626_642_e 626 642 13376.4
r_626_642_i 626_642 642 93218.1
c_626_642_i 626 626_642 2.08965e-09
r_1186_1202_e 1186 1202 13376.4
r_1186_1202_i 1186_1202 1202 93218.1
c_1186_1202_i 1186 1186_1202 2.08965e-09
r_1746_1762_e 1746 1762 13376.4
r_1746_1762_i 1746_1762 1762 93218.1
c_1746_1762_i 1746 1746_1762 2.08965e-09
r_2306_2322_e 2306 2322 13376.4
r_2306_2322_i 2306_2322 2322 93218.1
c_2306_2322_i 2306 2306_2322 2.08965e-09
r_2866_2882_e 2866 2882 13376.4
r_2866_2882_i 2866_2882 2882 93218.1
c_2866_2882_i 2866 2866_2882 2.08965e-09
r_3426_3442_e 3426 3442 13376.4
r_3426_3442_i 3426_3442 3442 93218.1
c_3426_3442_i 3426 3426_3442 2.08965e-09
r_67_83_e 67 83 13376.4
r_67_83_i 67_83 83 93218.1
c_67_83_i 67 67_83 2.08965e-09
r_627_643_e 627 643 13376.4
r_627_643_i 627_643 643 93218.1
c_627_643_i 627 627_643 2.08965e-09
r_1187_1203_e 1187 1203 836.944
r_1187_1203_i 1187_1203 1203 4256.89
c_1187_1203_i 1187 1187_1203 4.67522e-10
r_1747_1763_e 1747 1763 836.944
r_1747_1763_i 1747_1763 1763 4256.89
c_1747_1763_i 1747 1747_1763 4.67522e-10
r_2307_2323_e 2307 2323 836.944
r_2307_2323_i 2307_2323 2323 4256.89
c_2307_2323_i 2307 2307_2323 4.67522e-10
r_2867_2883_e 2867 2883 836.944
r_2867_2883_i 2867_2883 2883 4256.89
c_2867_2883_i 2867 2867_2883 4.67522e-10
r_3427_3443_e 3427 3443 836.944
r_3427_3443_i 3427_3443 3443 4256.89
c_3427_3443_i 3427 3427_3443 4.67522e-10
r_68_84_e 68 84 13376.4
r_68_84_i 68_84 84 93218.1
c_68_84_i 68 68_84 2.08965e-09
r_628_644_e 628 644 13376.4
r_628_644_i 628_644 644 93218.1
c_628_644_i 628 628_644 2.08965e-09
r_1188_1204_e 1188 1204 836.944
r_1188_1204_i 1188_1204 1204 4256.89
c_1188_1204_i 1188 1188_1204 4.67522e-10
r_1748_1764_e 1748 1764 836.944
r_1748_1764_i 1748_1764 1764 4256.89
c_1748_1764_i 1748 1748_1764 4.67522e-10
r_2308_2324_e 2308 2324 836.944
r_2308_2324_i 2308_2324 2324 4256.89
c_2308_2324_i 2308 2308_2324 4.67522e-10
r_2868_2884_e 2868 2884 13758.3
r_2868_2884_i 2868_2884 2884 95645.6
c_2868_2884_i 2868 2868_2884 9.36084e-12
r_3428_3444_e 3428 3444 13758.3
r_3428_3444_i 3428_3444 3444 95645.6
c_3428_3444_i 3428 3428_3444 9.36084e-12
r_69_85_e 69 85 13376.4
r_69_85_i 69_85 85 93218.1
c_69_85_i 69 69_85 2.08965e-09
r_629_645_e 629 645 13376.4
r_629_645_i 629_645 645 93218.1
c_629_645_i 629 629_645 2.08965e-09
r_1189_1205_e 1189 1205 836.944
r_1189_1205_i 1189_1205 1205 4256.89
c_1189_1205_i 1189 1189_1205 4.67522e-10
r_1749_1765_e 1749 1765 836.944
r_1749_1765_i 1749_1765 1765 4256.89
c_1749_1765_i 1749 1749_1765 4.67522e-10
r_2309_2325_e 2309 2325 836.944
r_2309_2325_i 2309_2325 2325 4256.89
c_2309_2325_i 2309 2309_2325 4.67522e-10
r_2869_2885_e 2869 2885 13758.3
r_2869_2885_i 2869_2885 2885 95645.6
c_2869_2885_i 2869 2869_2885 9.36084e-12
r_3429_3445_e 3429 3445 13758.3
r_3429_3445_i 3429_3445 3445 95645.6
c_3429_3445_i 3429 3429_3445 9.36084e-12
r_70_86_e 70 86 13376.4
r_70_86_i 70_86 86 93218.1
c_70_86_i 70 70_86 2.08965e-09
r_630_646_e 630 646 13376.4
r_630_646_i 630_646 646 93218.1
c_630_646_i 630 630_646 2.08965e-09
r_1190_1206_e 1190 1206 836.944
r_1190_1206_i 1190_1206 1206 4256.89
c_1190_1206_i 1190 1190_1206 4.67522e-10
r_1750_1766_e 1750 1766 836.944
r_1750_1766_i 1750_1766 1766 4256.89
c_1750_1766_i 1750 1750_1766 4.67522e-10
r_2310_2326_e 2310 2326 836.944
r_2310_2326_i 2310_2326 2326 4256.89
c_2310_2326_i 2310 2310_2326 4.67522e-10
r_2870_2886_e 2870 2886 13758.3
r_2870_2886_i 2870_2886 2886 95645.6
c_2870_2886_i 2870 2870_2886 9.36084e-12
r_3430_3446_e 3430 3446 13758.3
r_3430_3446_i 3430_3446 3446 95645.6
c_3430_3446_i 3430 3430_3446 9.36084e-12
r_71_87_e 71 87 13376.4
r_71_87_i 71_87 87 93218.1
c_71_87_i 71 71_87 2.08965e-09
r_631_647_e 631 647 13376.4
r_631_647_i 631_647 647 93218.1
c_631_647_i 631 631_647 2.08965e-09
r_1191_1207_e 1191 1207 836.944
r_1191_1207_i 1191_1207 1207 4256.89
c_1191_1207_i 1191 1191_1207 4.67522e-10
r_1751_1767_e 1751 1767 836.944
r_1751_1767_i 1751_1767 1767 4256.89
c_1751_1767_i 1751 1751_1767 4.67522e-10
r_2311_2327_e 2311 2327 836.944
r_2311_2327_i 2311_2327 2327 4256.89
c_2311_2327_i 2311 2311_2327 4.67522e-10
r_2871_2887_e 2871 2887 13758.3
r_2871_2887_i 2871_2887 2887 95645.6
c_2871_2887_i 2871 2871_2887 9.36084e-12
r_3431_3447_e 3431 3447 13758.3
r_3431_3447_i 3431_3447 3447 95645.6
c_3431_3447_i 3431 3431_3447 9.36084e-12
r_72_88_e 72 88 13376.4
r_72_88_i 72_88 88 93218.1
c_72_88_i 72 72_88 2.08965e-09
r_632_648_e 632 648 13376.4
r_632_648_i 632_648 648 93218.1
c_632_648_i 632 632_648 2.08965e-09
r_1192_1208_e 1192 1208 836.944
r_1192_1208_i 1192_1208 1208 4256.89
c_1192_1208_i 1192 1192_1208 4.67522e-10
r_1752_1768_e 1752 1768 836.944
r_1752_1768_i 1752_1768 1768 4256.89
c_1752_1768_i 1752 1752_1768 4.67522e-10
r_2312_2328_e 2312 2328 836.944
r_2312_2328_i 2312_2328 2328 4256.89
c_2312_2328_i 2312 2312_2328 4.67522e-10
r_2872_2888_e 2872 2888 13758.3
r_2872_2888_i 2872_2888 2888 95645.6
c_2872_2888_i 2872 2872_2888 9.36084e-12
r_3432_3448_e 3432 3448 13758.3
r_3432_3448_i 3432_3448 3448 95645.6
c_3432_3448_i 3432 3432_3448 9.36084e-12
r_73_89_e 73 89 13376.4
r_73_89_i 73_89 89 93218.1
c_73_89_i 73 73_89 2.08965e-09
r_633_649_e 633 649 13376.4
r_633_649_i 633_649 649 93218.1
c_633_649_i 633 633_649 2.08965e-09
r_1193_1209_e 1193 1209 836.944
r_1193_1209_i 1193_1209 1209 4256.89
c_1193_1209_i 1193 1193_1209 4.67522e-10
r_1753_1769_e 1753 1769 836.944
r_1753_1769_i 1753_1769 1769 4256.89
c_1753_1769_i 1753 1753_1769 4.67522e-10
r_2313_2329_e 2313 2329 836.944
r_2313_2329_i 2313_2329 2329 4256.89
c_2313_2329_i 2313 2313_2329 4.67522e-10
r_2873_2889_e 2873 2889 13758.3
r_2873_2889_i 2873_2889 2889 95645.6
c_2873_2889_i 2873 2873_2889 9.36084e-12
r_3433_3449_e 3433 3449 13758.3
r_3433_3449_i 3433_3449 3449 95645.6
c_3433_3449_i 3433 3433_3449 9.36084e-12
r_74_90_e 74 90 13376.4
r_74_90_i 74_90 90 93218.1
c_74_90_i 74 74_90 2.08965e-09
r_634_650_e 634 650 13376.4
r_634_650_i 634_650 650 93218.1
c_634_650_i 634 634_650 2.08965e-09
r_1194_1210_e 1194 1210 836.944
r_1194_1210_i 1194_1210 1210 4256.89
c_1194_1210_i 1194 1194_1210 4.67522e-10
r_1754_1770_e 1754 1770 836.944
r_1754_1770_i 1754_1770 1770 4256.89
c_1754_1770_i 1754 1754_1770 4.67522e-10
r_2314_2330_e 2314 2330 836.944
r_2314_2330_i 2314_2330 2330 4256.89
c_2314_2330_i 2314 2314_2330 4.67522e-10
r_2874_2890_e 2874 2890 13758.3
r_2874_2890_i 2874_2890 2890 95645.6
c_2874_2890_i 2874 2874_2890 9.36084e-12
r_3434_3450_e 3434 3450 13758.3
r_3434_3450_i 3434_3450 3450 95645.6
c_3434_3450_i 3434 3434_3450 9.36084e-12
r_75_91_e 75 91 13376.4
r_75_91_i 75_91 91 93218.1
c_75_91_i 75 75_91 2.08965e-09
r_635_651_e 635 651 13376.4
r_635_651_i 635_651 651 93218.1
c_635_651_i 635 635_651 2.08965e-09
r_1195_1211_e 1195 1211 396.733
r_1195_1211_i 1195_1211 1211 1005.36
c_1195_1211_i 1195 1195_1211 1.65781e-10
r_1755_1771_e 1755 1771 396.733
r_1755_1771_i 1755_1771 1771 1005.36
c_1755_1771_i 1755 1755_1771 1.65781e-10
r_2315_2331_e 2315 2331 836.944
r_2315_2331_i 2315_2331 2331 4256.89
c_2315_2331_i 2315 2315_2331 4.67522e-10
r_2875_2891_e 2875 2891 13758.3
r_2875_2891_i 2875_2891 2891 95645.6
c_2875_2891_i 2875 2875_2891 9.36084e-12
r_3435_3451_e 3435 3451 13758.3
r_3435_3451_i 3435_3451 3451 95645.6
c_3435_3451_i 3435 3435_3451 9.36084e-12
r_76_92_e 76 92 13376.4
r_76_92_i 76_92 92 93218.1
c_76_92_i 76 76_92 2.08965e-09
r_636_652_e 636 652 13376.4
r_636_652_i 636_652 652 93218.1
c_636_652_i 636 636_652 2.08965e-09
r_1196_1212_e 1196 1212 396.733
r_1196_1212_i 1196_1212 1212 1005.36
c_1196_1212_i 1196 1196_1212 1.65781e-10
r_1756_1772_e 1756 1772 396.733
r_1756_1772_i 1756_1772 1772 1005.36
c_1756_1772_i 1756 1756_1772 1.65781e-10
r_2316_2332_e 2316 2332 836.944
r_2316_2332_i 2316_2332 2332 4256.89
c_2316_2332_i 2316 2316_2332 4.67522e-10
r_2876_2892_e 2876 2892 13758.3
r_2876_2892_i 2876_2892 2892 95645.6
c_2876_2892_i 2876 2876_2892 9.36084e-12
r_3436_3452_e 3436 3452 13758.3
r_3436_3452_i 3436_3452 3452 95645.6
c_3436_3452_i 3436 3436_3452 9.36084e-12
r_77_93_e 77 93 13376.4
r_77_93_i 77_93 93 93218.1
c_77_93_i 77 77_93 2.08965e-09
r_637_653_e 637 653 13376.4
r_637_653_i 637_653 653 93218.1
c_637_653_i 637 637_653 2.08965e-09
r_1197_1213_e 1197 1213 836.944
r_1197_1213_i 1197_1213 1213 4256.89
c_1197_1213_i 1197 1197_1213 4.67522e-10
r_1757_1773_e 1757 1773 836.944
r_1757_1773_i 1757_1773 1773 4256.89
c_1757_1773_i 1757 1757_1773 4.67522e-10
r_2317_2333_e 2317 2333 836.944
r_2317_2333_i 2317_2333 2333 4256.89
c_2317_2333_i 2317 2317_2333 4.67522e-10
r_2877_2893_e 2877 2893 13758.3
r_2877_2893_i 2877_2893 2893 95645.6
c_2877_2893_i 2877 2877_2893 9.36084e-12
r_3437_3453_e 3437 3453 13758.3
r_3437_3453_i 3437_3453 3453 95645.6
c_3437_3453_i 3437 3437_3453 9.36084e-12
r_78_94_e 78 94 13376.4
r_78_94_i 78_94 94 93218.1
c_78_94_i 78 78_94 2.08965e-09
r_638_654_e 638 654 13376.4
r_638_654_i 638_654 654 93218.1
c_638_654_i 638 638_654 2.08965e-09
r_1198_1214_e 1198 1214 836.944
r_1198_1214_i 1198_1214 1214 4256.89
c_1198_1214_i 1198 1198_1214 4.67522e-10
r_1758_1774_e 1758 1774 836.944
r_1758_1774_i 1758_1774 1774 4256.89
c_1758_1774_i 1758 1758_1774 4.67522e-10
r_2318_2334_e 2318 2334 836.944
r_2318_2334_i 2318_2334 2334 4256.89
c_2318_2334_i 2318 2318_2334 4.67522e-10
r_2878_2894_e 2878 2894 13758.3
r_2878_2894_i 2878_2894 2894 95645.6
c_2878_2894_i 2878 2878_2894 9.36084e-12
r_3438_3454_e 3438 3454 13758.3
r_3438_3454_i 3438_3454 3454 95645.6
c_3438_3454_i 3438 3438_3454 9.36084e-12
r_79_95_e 79 95 13376.4
r_79_95_i 79_95 95 93218.1
c_79_95_i 79 79_95 2.08965e-09
r_639_655_e 639 655 13376.4
r_639_655_i 639_655 655 93218.1
c_639_655_i 639 639_655 2.08965e-09
r_1199_1215_e 1199 1215 836.944
r_1199_1215_i 1199_1215 1215 4256.89
c_1199_1215_i 1199 1199_1215 4.67522e-10
r_1759_1775_e 1759 1775 836.944
r_1759_1775_i 1759_1775 1775 4256.89
c_1759_1775_i 1759 1759_1775 4.67522e-10
r_2319_2335_e 2319 2335 836.944
r_2319_2335_i 2319_2335 2335 4256.89
c_2319_2335_i 2319 2319_2335 4.67522e-10
r_2879_2895_e 2879 2895 13758.3
r_2879_2895_i 2879_2895 2895 95645.6
c_2879_2895_i 2879 2879_2895 9.36084e-12
r_3439_3455_e 3439 3455 13758.3
r_3439_3455_i 3439_3455 3455 95645.6
c_3439_3455_i 3439 3439_3455 9.36084e-12
r_80_96_e 80 96 13376.4
r_80_96_i 80_96 96 93218.1
c_80_96_i 80 80_96 2.08965e-09
r_640_656_e 640 656 13376.4
r_640_656_i 640_656 656 93218.1
c_640_656_i 640 640_656 2.08965e-09
r_1200_1216_e 1200 1216 836.944
r_1200_1216_i 1200_1216 1216 4256.89
c_1200_1216_i 1200 1200_1216 4.67522e-10
r_1760_1776_e 1760 1776 836.944
r_1760_1776_i 1760_1776 1776 4256.89
c_1760_1776_i 1760 1760_1776 4.67522e-10
r_2320_2336_e 2320 2336 836.944
r_2320_2336_i 2320_2336 2336 4256.89
c_2320_2336_i 2320 2320_2336 4.67522e-10
r_2880_2896_e 2880 2896 13758.3
r_2880_2896_i 2880_2896 2896 95645.6
c_2880_2896_i 2880 2880_2896 9.36084e-12
r_3440_3456_e 3440 3456 13758.3
r_3440_3456_i 3440_3456 3456 95645.6
c_3440_3456_i 3440 3440_3456 9.36084e-12
r_81_97_e 81 97 13376.4
r_81_97_i 81_97 97 93218.1
c_81_97_i 81 81_97 2.08965e-09
r_641_657_e 641 657 13376.4
r_641_657_i 641_657 657 93218.1
c_641_657_i 641 641_657 2.08965e-09
r_1201_1217_e 1201 1217 13376.4
r_1201_1217_i 1201_1217 1217 93218.1
c_1201_1217_i 1201 1201_1217 2.08965e-09
r_1761_1777_e 1761 1777 13376.4
r_1761_1777_i 1761_1777 1777 93218.1
c_1761_1777_i 1761 1761_1777 2.08965e-09
r_2321_2337_e 2321 2337 13376.4
r_2321_2337_i 2321_2337 2337 93218.1
c_2321_2337_i 2321 2321_2337 2.08965e-09
r_2881_2897_e 2881 2897 13376.4
r_2881_2897_i 2881_2897 2897 93218.1
c_2881_2897_i 2881 2881_2897 2.08965e-09
r_3441_3457_e 3441 3457 13376.4
r_3441_3457_i 3441_3457 3457 93218.1
c_3441_3457_i 3441 3441_3457 2.08965e-09
r_82_98_e 82 98 13376.4
r_82_98_i 82_98 98 93218.1
c_82_98_i 82 82_98 2.08965e-09
r_642_658_e 642 658 13376.4
r_642_658_i 642_658 658 93218.1
c_642_658_i 642 642_658 2.08965e-09
r_1202_1218_e 1202 1218 13376.4
r_1202_1218_i 1202_1218 1218 93218.1
c_1202_1218_i 1202 1202_1218 2.08965e-09
r_1762_1778_e 1762 1778 13376.4
r_1762_1778_i 1762_1778 1778 93218.1
c_1762_1778_i 1762 1762_1778 2.08965e-09
r_2322_2338_e 2322 2338 13376.4
r_2322_2338_i 2322_2338 2338 93218.1
c_2322_2338_i 2322 2322_2338 2.08965e-09
r_2882_2898_e 2882 2898 13376.4
r_2882_2898_i 2882_2898 2898 93218.1
c_2882_2898_i 2882 2882_2898 2.08965e-09
r_3442_3458_e 3442 3458 13376.4
r_3442_3458_i 3442_3458 3458 93218.1
c_3442_3458_i 3442 3442_3458 2.08965e-09
r_83_99_e 83 99 13376.4
r_83_99_i 83_99 99 93218.1
c_83_99_i 83 83_99 2.08965e-09
r_643_659_e 643 659 13376.4
r_643_659_i 643_659 659 93218.1
c_643_659_i 643 643_659 2.08965e-09
r_1203_1219_e 1203 1219 836.944
r_1203_1219_i 1203_1219 1219 4256.89
c_1203_1219_i 1203 1203_1219 4.67522e-10
r_1763_1779_e 1763 1779 836.944
r_1763_1779_i 1763_1779 1779 4256.89
c_1763_1779_i 1763 1763_1779 4.67522e-10
r_2323_2339_e 2323 2339 836.944
r_2323_2339_i 2323_2339 2339 4256.89
c_2323_2339_i 2323 2323_2339 4.67522e-10
r_2883_2899_e 2883 2899 836.944
r_2883_2899_i 2883_2899 2899 4256.89
c_2883_2899_i 2883 2883_2899 4.67522e-10
r_3443_3459_e 3443 3459 836.944
r_3443_3459_i 3443_3459 3459 4256.89
c_3443_3459_i 3443 3443_3459 4.67522e-10
r_84_100_e 84 100 13376.4
r_84_100_i 84_100 100 93218.1
c_84_100_i 84 84_100 2.08965e-09
r_644_660_e 644 660 13376.4
r_644_660_i 644_660 660 93218.1
c_644_660_i 644 644_660 2.08965e-09
r_1204_1220_e 1204 1220 836.944
r_1204_1220_i 1204_1220 1220 4256.89
c_1204_1220_i 1204 1204_1220 4.67522e-10
r_1764_1780_e 1764 1780 836.944
r_1764_1780_i 1764_1780 1780 4256.89
c_1764_1780_i 1764 1764_1780 4.67522e-10
r_2324_2340_e 2324 2340 836.944
r_2324_2340_i 2324_2340 2340 4256.89
c_2324_2340_i 2324 2324_2340 4.67522e-10
r_2884_2900_e 2884 2900 13758.3
r_2884_2900_i 2884_2900 2900 95645.6
c_2884_2900_i 2884 2884_2900 9.36084e-12
r_3444_3460_e 3444 3460 13758.3
r_3444_3460_i 3444_3460 3460 95645.6
c_3444_3460_i 3444 3444_3460 9.36084e-12
r_85_101_e 85 101 13376.4
r_85_101_i 85_101 101 93218.1
c_85_101_i 85 85_101 2.08965e-09
r_645_661_e 645 661 13376.4
r_645_661_i 645_661 661 93218.1
c_645_661_i 645 645_661 2.08965e-09
r_1205_1221_e 1205 1221 836.944
r_1205_1221_i 1205_1221 1221 4256.89
c_1205_1221_i 1205 1205_1221 4.67522e-10
r_1765_1781_e 1765 1781 836.944
r_1765_1781_i 1765_1781 1781 4256.89
c_1765_1781_i 1765 1765_1781 4.67522e-10
r_2325_2341_e 2325 2341 836.944
r_2325_2341_i 2325_2341 2341 4256.89
c_2325_2341_i 2325 2325_2341 4.67522e-10
r_2885_2901_e 2885 2901 13758.3
r_2885_2901_i 2885_2901 2901 95645.6
c_2885_2901_i 2885 2885_2901 9.36084e-12
r_3445_3461_e 3445 3461 13758.3
r_3445_3461_i 3445_3461 3461 95645.6
c_3445_3461_i 3445 3445_3461 9.36084e-12
r_86_102_e 86 102 13376.4
r_86_102_i 86_102 102 93218.1
c_86_102_i 86 86_102 2.08965e-09
r_646_662_e 646 662 13376.4
r_646_662_i 646_662 662 93218.1
c_646_662_i 646 646_662 2.08965e-09
r_1206_1222_e 1206 1222 836.944
r_1206_1222_i 1206_1222 1222 4256.89
c_1206_1222_i 1206 1206_1222 4.67522e-10
r_1766_1782_e 1766 1782 836.944
r_1766_1782_i 1766_1782 1782 4256.89
c_1766_1782_i 1766 1766_1782 4.67522e-10
r_2326_2342_e 2326 2342 836.944
r_2326_2342_i 2326_2342 2342 4256.89
c_2326_2342_i 2326 2326_2342 4.67522e-10
r_2886_2902_e 2886 2902 13758.3
r_2886_2902_i 2886_2902 2902 95645.6
c_2886_2902_i 2886 2886_2902 9.36084e-12
r_3446_3462_e 3446 3462 13758.3
r_3446_3462_i 3446_3462 3462 95645.6
c_3446_3462_i 3446 3446_3462 9.36084e-12
r_87_103_e 87 103 13376.4
r_87_103_i 87_103 103 93218.1
c_87_103_i 87 87_103 2.08965e-09
r_647_663_e 647 663 13376.4
r_647_663_i 647_663 663 93218.1
c_647_663_i 647 647_663 2.08965e-09
r_1207_1223_e 1207 1223 836.944
r_1207_1223_i 1207_1223 1223 4256.89
c_1207_1223_i 1207 1207_1223 4.67522e-10
r_1767_1783_e 1767 1783 836.944
r_1767_1783_i 1767_1783 1783 4256.89
c_1767_1783_i 1767 1767_1783 4.67522e-10
r_2327_2343_e 2327 2343 836.944
r_2327_2343_i 2327_2343 2343 4256.89
c_2327_2343_i 2327 2327_2343 4.67522e-10
r_2887_2903_e 2887 2903 13758.3
r_2887_2903_i 2887_2903 2903 95645.6
c_2887_2903_i 2887 2887_2903 9.36084e-12
r_3447_3463_e 3447 3463 13758.3
r_3447_3463_i 3447_3463 3463 95645.6
c_3447_3463_i 3447 3447_3463 9.36084e-12
r_88_104_e 88 104 13376.4
r_88_104_i 88_104 104 93218.1
c_88_104_i 88 88_104 2.08965e-09
r_648_664_e 648 664 13376.4
r_648_664_i 648_664 664 93218.1
c_648_664_i 648 648_664 2.08965e-09
r_1208_1224_e 1208 1224 836.944
r_1208_1224_i 1208_1224 1224 4256.89
c_1208_1224_i 1208 1208_1224 4.67522e-10
r_1768_1784_e 1768 1784 836.944
r_1768_1784_i 1768_1784 1784 4256.89
c_1768_1784_i 1768 1768_1784 4.67522e-10
r_2328_2344_e 2328 2344 836.944
r_2328_2344_i 2328_2344 2344 4256.89
c_2328_2344_i 2328 2328_2344 4.67522e-10
r_2888_2904_e 2888 2904 13758.3
r_2888_2904_i 2888_2904 2904 95645.6
c_2888_2904_i 2888 2888_2904 9.36084e-12
r_3448_3464_e 3448 3464 13758.3
r_3448_3464_i 3448_3464 3464 95645.6
c_3448_3464_i 3448 3448_3464 9.36084e-12
r_89_105_e 89 105 13376.4
r_89_105_i 89_105 105 93218.1
c_89_105_i 89 89_105 2.08965e-09
r_649_665_e 649 665 13376.4
r_649_665_i 649_665 665 93218.1
c_649_665_i 649 649_665 2.08965e-09
r_1209_1225_e 1209 1225 836.944
r_1209_1225_i 1209_1225 1225 4256.89
c_1209_1225_i 1209 1209_1225 4.67522e-10
r_1769_1785_e 1769 1785 836.944
r_1769_1785_i 1769_1785 1785 4256.89
c_1769_1785_i 1769 1769_1785 4.67522e-10
r_2329_2345_e 2329 2345 836.944
r_2329_2345_i 2329_2345 2345 4256.89
c_2329_2345_i 2329 2329_2345 4.67522e-10
r_2889_2905_e 2889 2905 13758.3
r_2889_2905_i 2889_2905 2905 95645.6
c_2889_2905_i 2889 2889_2905 9.36084e-12
r_3449_3465_e 3449 3465 13758.3
r_3449_3465_i 3449_3465 3465 95645.6
c_3449_3465_i 3449 3449_3465 9.36084e-12
r_90_106_e 90 106 13376.4
r_90_106_i 90_106 106 93218.1
c_90_106_i 90 90_106 2.08965e-09
r_650_666_e 650 666 13376.4
r_650_666_i 650_666 666 93218.1
c_650_666_i 650 650_666 2.08965e-09
r_1210_1226_e 1210 1226 836.944
r_1210_1226_i 1210_1226 1226 4256.89
c_1210_1226_i 1210 1210_1226 4.67522e-10
r_1770_1786_e 1770 1786 836.944
r_1770_1786_i 1770_1786 1786 4256.89
c_1770_1786_i 1770 1770_1786 4.67522e-10
r_2330_2346_e 2330 2346 836.944
r_2330_2346_i 2330_2346 2346 4256.89
c_2330_2346_i 2330 2330_2346 4.67522e-10
r_2890_2906_e 2890 2906 13758.3
r_2890_2906_i 2890_2906 2906 95645.6
c_2890_2906_i 2890 2890_2906 9.36084e-12
r_3450_3466_e 3450 3466 13758.3
r_3450_3466_i 3450_3466 3466 95645.6
c_3450_3466_i 3450 3450_3466 9.36084e-12
r_91_107_e 91 107 13376.4
r_91_107_i 91_107 107 93218.1
c_91_107_i 91 91_107 2.08965e-09
r_651_667_e 651 667 13376.4
r_651_667_i 651_667 667 93218.1
c_651_667_i 651 651_667 2.08965e-09
r_1211_1227_e 1211 1227 396.724
r_1211_1227_i 1211_1227 1227 1005.34
c_1211_1227_i 1211 1211_1227 1.65785e-10
r_1771_1787_e 1771 1787 396.724
r_1771_1787_i 1771_1787 1787 1005.34
c_1771_1787_i 1771 1771_1787 1.65785e-10
r_2331_2347_e 2331 2347 836.944
r_2331_2347_i 2331_2347 2347 4256.89
c_2331_2347_i 2331 2331_2347 4.67522e-10
r_2891_2907_e 2891 2907 13758.3
r_2891_2907_i 2891_2907 2907 95645.6
c_2891_2907_i 2891 2891_2907 9.36084e-12
r_3451_3467_e 3451 3467 13758.3
r_3451_3467_i 3451_3467 3467 95645.6
c_3451_3467_i 3451 3451_3467 9.36084e-12
r_92_108_e 92 108 13376.4
r_92_108_i 92_108 108 93218.1
c_92_108_i 92 92_108 2.08965e-09
r_652_668_e 652 668 13376.4
r_652_668_i 652_668 668 93218.1
c_652_668_i 652 652_668 2.08965e-09
r_1212_1228_e 1212 1228 396.724
r_1212_1228_i 1212_1228 1228 1005.34
c_1212_1228_i 1212 1212_1228 1.65785e-10
r_1772_1788_e 1772 1788 396.724
r_1772_1788_i 1772_1788 1788 1005.34
c_1772_1788_i 1772 1772_1788 1.65785e-10
r_2332_2348_e 2332 2348 836.944
r_2332_2348_i 2332_2348 2348 4256.89
c_2332_2348_i 2332 2332_2348 4.67522e-10
r_2892_2908_e 2892 2908 13758.3
r_2892_2908_i 2892_2908 2908 95645.6
c_2892_2908_i 2892 2892_2908 9.36084e-12
r_3452_3468_e 3452 3468 13758.3
r_3452_3468_i 3452_3468 3468 95645.6
c_3452_3468_i 3452 3452_3468 9.36084e-12
r_93_109_e 93 109 13376.4
r_93_109_i 93_109 109 93218.1
c_93_109_i 93 93_109 2.08965e-09
r_653_669_e 653 669 13376.4
r_653_669_i 653_669 669 93218.1
c_653_669_i 653 653_669 2.08965e-09
r_1213_1229_e 1213 1229 836.944
r_1213_1229_i 1213_1229 1229 4256.89
c_1213_1229_i 1213 1213_1229 4.67522e-10
r_1773_1789_e 1773 1789 836.944
r_1773_1789_i 1773_1789 1789 4256.89
c_1773_1789_i 1773 1773_1789 4.67522e-10
r_2333_2349_e 2333 2349 836.944
r_2333_2349_i 2333_2349 2349 4256.89
c_2333_2349_i 2333 2333_2349 4.67522e-10
r_2893_2909_e 2893 2909 13758.3
r_2893_2909_i 2893_2909 2909 95645.6
c_2893_2909_i 2893 2893_2909 9.36084e-12
r_3453_3469_e 3453 3469 13758.3
r_3453_3469_i 3453_3469 3469 95645.6
c_3453_3469_i 3453 3453_3469 9.36084e-12
r_94_110_e 94 110 13376.4
r_94_110_i 94_110 110 93218.1
c_94_110_i 94 94_110 2.08965e-09
r_654_670_e 654 670 13376.4
r_654_670_i 654_670 670 93218.1
c_654_670_i 654 654_670 2.08965e-09
r_1214_1230_e 1214 1230 836.944
r_1214_1230_i 1214_1230 1230 4256.89
c_1214_1230_i 1214 1214_1230 4.67522e-10
r_1774_1790_e 1774 1790 836.944
r_1774_1790_i 1774_1790 1790 4256.89
c_1774_1790_i 1774 1774_1790 4.67522e-10
r_2334_2350_e 2334 2350 836.944
r_2334_2350_i 2334_2350 2350 4256.89
c_2334_2350_i 2334 2334_2350 4.67522e-10
r_2894_2910_e 2894 2910 13758.3
r_2894_2910_i 2894_2910 2910 95645.6
c_2894_2910_i 2894 2894_2910 9.36084e-12
r_3454_3470_e 3454 3470 13758.3
r_3454_3470_i 3454_3470 3470 95645.6
c_3454_3470_i 3454 3454_3470 9.36084e-12
r_95_111_e 95 111 13376.4
r_95_111_i 95_111 111 93218.1
c_95_111_i 95 95_111 2.08965e-09
r_655_671_e 655 671 13376.4
r_655_671_i 655_671 671 93218.1
c_655_671_i 655 655_671 2.08965e-09
r_1215_1231_e 1215 1231 836.944
r_1215_1231_i 1215_1231 1231 4256.89
c_1215_1231_i 1215 1215_1231 4.67522e-10
r_1775_1791_e 1775 1791 836.944
r_1775_1791_i 1775_1791 1791 4256.89
c_1775_1791_i 1775 1775_1791 4.67522e-10
r_2335_2351_e 2335 2351 836.944
r_2335_2351_i 2335_2351 2351 4256.89
c_2335_2351_i 2335 2335_2351 4.67522e-10
r_2895_2911_e 2895 2911 13758.3
r_2895_2911_i 2895_2911 2911 95645.6
c_2895_2911_i 2895 2895_2911 9.36084e-12
r_3455_3471_e 3455 3471 13758.3
r_3455_3471_i 3455_3471 3471 95645.6
c_3455_3471_i 3455 3455_3471 9.36084e-12
r_96_112_e 96 112 13376.4
r_96_112_i 96_112 112 93218.1
c_96_112_i 96 96_112 2.08965e-09
r_656_672_e 656 672 13376.4
r_656_672_i 656_672 672 93218.1
c_656_672_i 656 656_672 2.08965e-09
r_1216_1232_e 1216 1232 836.944
r_1216_1232_i 1216_1232 1232 4256.89
c_1216_1232_i 1216 1216_1232 4.67522e-10
r_1776_1792_e 1776 1792 836.944
r_1776_1792_i 1776_1792 1792 4256.89
c_1776_1792_i 1776 1776_1792 4.67522e-10
r_2336_2352_e 2336 2352 836.944
r_2336_2352_i 2336_2352 2352 4256.89
c_2336_2352_i 2336 2336_2352 4.67522e-10
r_2896_2912_e 2896 2912 13758.3
r_2896_2912_i 2896_2912 2912 95645.6
c_2896_2912_i 2896 2896_2912 9.36084e-12
r_3456_3472_e 3456 3472 13758.3
r_3456_3472_i 3456_3472 3472 95645.6
c_3456_3472_i 3456 3456_3472 9.36084e-12
r_97_113_e 97 113 13376.4
r_97_113_i 97_113 113 93218.1
c_97_113_i 97 97_113 2.08965e-09
r_657_673_e 657 673 13376.4
r_657_673_i 657_673 673 93218.1
c_657_673_i 657 657_673 2.08965e-09
r_1217_1233_e 1217 1233 13376.4
r_1217_1233_i 1217_1233 1233 93218.1
c_1217_1233_i 1217 1217_1233 2.08965e-09
r_1777_1793_e 1777 1793 13376.4
r_1777_1793_i 1777_1793 1793 93218.1
c_1777_1793_i 1777 1777_1793 2.08965e-09
r_2337_2353_e 2337 2353 13376.4
r_2337_2353_i 2337_2353 2353 93218.1
c_2337_2353_i 2337 2337_2353 2.08965e-09
r_2897_2913_e 2897 2913 13376.4
r_2897_2913_i 2897_2913 2913 93218.1
c_2897_2913_i 2897 2897_2913 2.08965e-09
r_3457_3473_e 3457 3473 13376.4
r_3457_3473_i 3457_3473 3473 93218.1
c_3457_3473_i 3457 3457_3473 2.08965e-09
r_98_114_e 98 114 13376.4
r_98_114_i 98_114 114 93218.1
c_98_114_i 98 98_114 2.08965e-09
r_658_674_e 658 674 13376.4
r_658_674_i 658_674 674 93218.1
c_658_674_i 658 658_674 2.08965e-09
r_1218_1234_e 1218 1234 13376.4
r_1218_1234_i 1218_1234 1234 93218.1
c_1218_1234_i 1218 1218_1234 2.08965e-09
r_1778_1794_e 1778 1794 13376.4
r_1778_1794_i 1778_1794 1794 93218.1
c_1778_1794_i 1778 1778_1794 2.08965e-09
r_2338_2354_e 2338 2354 13376.4
r_2338_2354_i 2338_2354 2354 93218.1
c_2338_2354_i 2338 2338_2354 2.08965e-09
r_2898_2914_e 2898 2914 13376.4
r_2898_2914_i 2898_2914 2914 93218.1
c_2898_2914_i 2898 2898_2914 2.08965e-09
r_3458_3474_e 3458 3474 13376.4
r_3458_3474_i 3458_3474 3474 93218.1
c_3458_3474_i 3458 3458_3474 2.08965e-09
r_99_115_e 99 115 13376.4
r_99_115_i 99_115 115 93218.1
c_99_115_i 99 99_115 2.08965e-09
r_659_675_e 659 675 13376.4
r_659_675_i 659_675 675 93218.1
c_659_675_i 659 659_675 2.08965e-09
r_1219_1235_e 1219 1235 836.944
r_1219_1235_i 1219_1235 1235 4256.89
c_1219_1235_i 1219 1219_1235 4.67522e-10
r_1779_1795_e 1779 1795 836.944
r_1779_1795_i 1779_1795 1795 4256.89
c_1779_1795_i 1779 1779_1795 4.67522e-10
r_2339_2355_e 2339 2355 836.944
r_2339_2355_i 2339_2355 2355 4256.89
c_2339_2355_i 2339 2339_2355 4.67522e-10
r_2899_2915_e 2899 2915 836.944
r_2899_2915_i 2899_2915 2915 4256.89
c_2899_2915_i 2899 2899_2915 4.67522e-10
r_3459_3475_e 3459 3475 836.944
r_3459_3475_i 3459_3475 3475 4256.89
c_3459_3475_i 3459 3459_3475 4.67522e-10
r_100_116_e 100 116 13376.4
r_100_116_i 100_116 116 93218.1
c_100_116_i 100 100_116 2.08965e-09
r_660_676_e 660 676 13376.4
r_660_676_i 660_676 676 93218.1
c_660_676_i 660 660_676 2.08965e-09
r_1220_1236_e 1220 1236 836.944
r_1220_1236_i 1220_1236 1236 4256.89
c_1220_1236_i 1220 1220_1236 4.67522e-10
r_1780_1796_e 1780 1796 836.944
r_1780_1796_i 1780_1796 1796 4256.89
c_1780_1796_i 1780 1780_1796 4.67522e-10
r_2340_2356_e 2340 2356 836.944
r_2340_2356_i 2340_2356 2356 4256.89
c_2340_2356_i 2340 2340_2356 4.67522e-10
r_2900_2916_e 2900 2916 13758.3
r_2900_2916_i 2900_2916 2916 95645.6
c_2900_2916_i 2900 2900_2916 9.36084e-12
r_3460_3476_e 3460 3476 13758.3
r_3460_3476_i 3460_3476 3476 95645.6
c_3460_3476_i 3460 3460_3476 9.36084e-12
r_101_117_e 101 117 13376.4
r_101_117_i 101_117 117 93218.1
c_101_117_i 101 101_117 2.08965e-09
r_661_677_e 661 677 13376.4
r_661_677_i 661_677 677 93218.1
c_661_677_i 661 661_677 2.08965e-09
r_1221_1237_e 1221 1237 836.944
r_1221_1237_i 1221_1237 1237 4256.89
c_1221_1237_i 1221 1221_1237 4.67522e-10
r_1781_1797_e 1781 1797 836.944
r_1781_1797_i 1781_1797 1797 4256.89
c_1781_1797_i 1781 1781_1797 4.67522e-10
r_2341_2357_e 2341 2357 836.944
r_2341_2357_i 2341_2357 2357 4256.89
c_2341_2357_i 2341 2341_2357 4.67522e-10
r_2901_2917_e 2901 2917 13758.3
r_2901_2917_i 2901_2917 2917 95645.6
c_2901_2917_i 2901 2901_2917 9.36084e-12
r_3461_3477_e 3461 3477 13758.3
r_3461_3477_i 3461_3477 3477 95645.6
c_3461_3477_i 3461 3461_3477 9.36084e-12
r_102_118_e 102 118 13376.4
r_102_118_i 102_118 118 93218.1
c_102_118_i 102 102_118 2.08965e-09
r_662_678_e 662 678 13376.4
r_662_678_i 662_678 678 93218.1
c_662_678_i 662 662_678 2.08965e-09
r_1222_1238_e 1222 1238 836.944
r_1222_1238_i 1222_1238 1238 4256.89
c_1222_1238_i 1222 1222_1238 4.67522e-10
r_1782_1798_e 1782 1798 836.944
r_1782_1798_i 1782_1798 1798 4256.89
c_1782_1798_i 1782 1782_1798 4.67522e-10
r_2342_2358_e 2342 2358 836.944
r_2342_2358_i 2342_2358 2358 4256.89
c_2342_2358_i 2342 2342_2358 4.67522e-10
r_2902_2918_e 2902 2918 13758.3
r_2902_2918_i 2902_2918 2918 95645.6
c_2902_2918_i 2902 2902_2918 9.36084e-12
r_3462_3478_e 3462 3478 13758.3
r_3462_3478_i 3462_3478 3478 95645.6
c_3462_3478_i 3462 3462_3478 9.36084e-12
r_103_119_e 103 119 13376.4
r_103_119_i 103_119 119 93218.1
c_103_119_i 103 103_119 2.08965e-09
r_663_679_e 663 679 13376.4
r_663_679_i 663_679 679 93218.1
c_663_679_i 663 663_679 2.08965e-09
r_1223_1239_e 1223 1239 836.944
r_1223_1239_i 1223_1239 1239 4256.89
c_1223_1239_i 1223 1223_1239 4.67522e-10
r_1783_1799_e 1783 1799 836.944
r_1783_1799_i 1783_1799 1799 4256.89
c_1783_1799_i 1783 1783_1799 4.67522e-10
r_2343_2359_e 2343 2359 836.944
r_2343_2359_i 2343_2359 2359 4256.89
c_2343_2359_i 2343 2343_2359 4.67522e-10
r_2903_2919_e 2903 2919 13758.3
r_2903_2919_i 2903_2919 2919 95645.6
c_2903_2919_i 2903 2903_2919 9.36084e-12
r_3463_3479_e 3463 3479 13758.3
r_3463_3479_i 3463_3479 3479 95645.6
c_3463_3479_i 3463 3463_3479 9.36084e-12
r_104_120_e 104 120 13376.4
r_104_120_i 104_120 120 93218.1
c_104_120_i 104 104_120 2.08965e-09
r_664_680_e 664 680 13376.4
r_664_680_i 664_680 680 93218.1
c_664_680_i 664 664_680 2.08965e-09
r_1224_1240_e 1224 1240 836.944
r_1224_1240_i 1224_1240 1240 4256.89
c_1224_1240_i 1224 1224_1240 4.67522e-10
r_1784_1800_e 1784 1800 836.944
r_1784_1800_i 1784_1800 1800 4256.89
c_1784_1800_i 1784 1784_1800 4.67522e-10
r_2344_2360_e 2344 2360 836.944
r_2344_2360_i 2344_2360 2360 4256.89
c_2344_2360_i 2344 2344_2360 4.67522e-10
r_2904_2920_e 2904 2920 13758.3
r_2904_2920_i 2904_2920 2920 95645.6
c_2904_2920_i 2904 2904_2920 9.36084e-12
r_3464_3480_e 3464 3480 13758.3
r_3464_3480_i 3464_3480 3480 95645.6
c_3464_3480_i 3464 3464_3480 9.36084e-12
r_105_121_e 105 121 13376.4
r_105_121_i 105_121 121 93218.1
c_105_121_i 105 105_121 2.08965e-09
r_665_681_e 665 681 13376.4
r_665_681_i 665_681 681 93218.1
c_665_681_i 665 665_681 2.08965e-09
r_1225_1241_e 1225 1241 836.944
r_1225_1241_i 1225_1241 1241 4256.89
c_1225_1241_i 1225 1225_1241 4.67522e-10
r_1785_1801_e 1785 1801 836.944
r_1785_1801_i 1785_1801 1801 4256.89
c_1785_1801_i 1785 1785_1801 4.67522e-10
r_2345_2361_e 2345 2361 836.944
r_2345_2361_i 2345_2361 2361 4256.89
c_2345_2361_i 2345 2345_2361 4.67522e-10
r_2905_2921_e 2905 2921 13758.3
r_2905_2921_i 2905_2921 2921 95645.6
c_2905_2921_i 2905 2905_2921 9.36084e-12
r_3465_3481_e 3465 3481 13758.3
r_3465_3481_i 3465_3481 3481 95645.6
c_3465_3481_i 3465 3465_3481 9.36084e-12
r_106_122_e 106 122 13376.4
r_106_122_i 106_122 122 93218.1
c_106_122_i 106 106_122 2.08965e-09
r_666_682_e 666 682 13376.4
r_666_682_i 666_682 682 93218.1
c_666_682_i 666 666_682 2.08965e-09
r_1226_1242_e 1226 1242 836.944
r_1226_1242_i 1226_1242 1242 4256.89
c_1226_1242_i 1226 1226_1242 4.67522e-10
r_1786_1802_e 1786 1802 836.944
r_1786_1802_i 1786_1802 1802 4256.89
c_1786_1802_i 1786 1786_1802 4.67522e-10
r_2346_2362_e 2346 2362 836.944
r_2346_2362_i 2346_2362 2362 4256.89
c_2346_2362_i 2346 2346_2362 4.67522e-10
r_2906_2922_e 2906 2922 13758.3
r_2906_2922_i 2906_2922 2922 95645.6
c_2906_2922_i 2906 2906_2922 9.36084e-12
r_3466_3482_e 3466 3482 13758.3
r_3466_3482_i 3466_3482 3482 95645.6
c_3466_3482_i 3466 3466_3482 9.36084e-12
r_107_123_e 107 123 13376.4
r_107_123_i 107_123 123 93218.1
c_107_123_i 107 107_123 2.08965e-09
r_667_683_e 667 683 13376.4
r_667_683_i 667_683 683 93218.1
c_667_683_i 667 667_683 2.08965e-09
r_1227_1243_e 1227 1243 396.715
r_1227_1243_i 1227_1243 1243 1005.31
c_1227_1243_i 1227 1227_1243 1.65788e-10
r_1787_1803_e 1787 1803 396.715
r_1787_1803_i 1787_1803 1803 1005.31
c_1787_1803_i 1787 1787_1803 1.65788e-10
r_2347_2363_e 2347 2363 836.944
r_2347_2363_i 2347_2363 2363 4256.89
c_2347_2363_i 2347 2347_2363 4.67522e-10
r_2907_2923_e 2907 2923 13758.3
r_2907_2923_i 2907_2923 2923 95645.6
c_2907_2923_i 2907 2907_2923 9.36084e-12
r_3467_3483_e 3467 3483 13758.3
r_3467_3483_i 3467_3483 3483 95645.6
c_3467_3483_i 3467 3467_3483 9.36084e-12
r_108_124_e 108 124 13376.4
r_108_124_i 108_124 124 93218.1
c_108_124_i 108 108_124 2.08965e-09
r_668_684_e 668 684 13376.4
r_668_684_i 668_684 684 93218.1
c_668_684_i 668 668_684 2.08965e-09
r_1228_1244_e 1228 1244 396.715
r_1228_1244_i 1228_1244 1244 1005.31
c_1228_1244_i 1228 1228_1244 1.65788e-10
r_1788_1804_e 1788 1804 396.715
r_1788_1804_i 1788_1804 1804 1005.31
c_1788_1804_i 1788 1788_1804 1.65788e-10
r_2348_2364_e 2348 2364 836.944
r_2348_2364_i 2348_2364 2364 4256.89
c_2348_2364_i 2348 2348_2364 4.67522e-10
r_2908_2924_e 2908 2924 13758.3
r_2908_2924_i 2908_2924 2924 95645.6
c_2908_2924_i 2908 2908_2924 9.36084e-12
r_3468_3484_e 3468 3484 13758.3
r_3468_3484_i 3468_3484 3484 95645.6
c_3468_3484_i 3468 3468_3484 9.36084e-12
r_109_125_e 109 125 13376.4
r_109_125_i 109_125 125 93218.1
c_109_125_i 109 109_125 2.08965e-09
r_669_685_e 669 685 13376.4
r_669_685_i 669_685 685 93218.1
c_669_685_i 669 669_685 2.08965e-09
r_1229_1245_e 1229 1245 836.944
r_1229_1245_i 1229_1245 1245 4256.89
c_1229_1245_i 1229 1229_1245 4.67522e-10
r_1789_1805_e 1789 1805 836.944
r_1789_1805_i 1789_1805 1805 4256.89
c_1789_1805_i 1789 1789_1805 4.67522e-10
r_2349_2365_e 2349 2365 836.944
r_2349_2365_i 2349_2365 2365 4256.89
c_2349_2365_i 2349 2349_2365 4.67522e-10
r_2909_2925_e 2909 2925 13758.3
r_2909_2925_i 2909_2925 2925 95645.6
c_2909_2925_i 2909 2909_2925 9.36084e-12
r_3469_3485_e 3469 3485 13758.3
r_3469_3485_i 3469_3485 3485 95645.6
c_3469_3485_i 3469 3469_3485 9.36084e-12
r_110_126_e 110 126 13376.4
r_110_126_i 110_126 126 93218.1
c_110_126_i 110 110_126 2.08965e-09
r_670_686_e 670 686 13376.4
r_670_686_i 670_686 686 93218.1
c_670_686_i 670 670_686 2.08965e-09
r_1230_1246_e 1230 1246 836.944
r_1230_1246_i 1230_1246 1246 4256.89
c_1230_1246_i 1230 1230_1246 4.67522e-10
r_1790_1806_e 1790 1806 836.944
r_1790_1806_i 1790_1806 1806 4256.89
c_1790_1806_i 1790 1790_1806 4.67522e-10
r_2350_2366_e 2350 2366 836.944
r_2350_2366_i 2350_2366 2366 4256.89
c_2350_2366_i 2350 2350_2366 4.67522e-10
r_2910_2926_e 2910 2926 13758.3
r_2910_2926_i 2910_2926 2926 95645.6
c_2910_2926_i 2910 2910_2926 9.36084e-12
r_3470_3486_e 3470 3486 13758.3
r_3470_3486_i 3470_3486 3486 95645.6
c_3470_3486_i 3470 3470_3486 9.36084e-12
r_111_127_e 111 127 13376.4
r_111_127_i 111_127 127 93218.1
c_111_127_i 111 111_127 2.08965e-09
r_671_687_e 671 687 13376.4
r_671_687_i 671_687 687 93218.1
c_671_687_i 671 671_687 2.08965e-09
r_1231_1247_e 1231 1247 836.944
r_1231_1247_i 1231_1247 1247 4256.89
c_1231_1247_i 1231 1231_1247 4.67522e-10
r_1791_1807_e 1791 1807 836.944
r_1791_1807_i 1791_1807 1807 4256.89
c_1791_1807_i 1791 1791_1807 4.67522e-10
r_2351_2367_e 2351 2367 836.944
r_2351_2367_i 2351_2367 2367 4256.89
c_2351_2367_i 2351 2351_2367 4.67522e-10
r_2911_2927_e 2911 2927 13758.3
r_2911_2927_i 2911_2927 2927 95645.6
c_2911_2927_i 2911 2911_2927 9.36084e-12
r_3471_3487_e 3471 3487 13758.3
r_3471_3487_i 3471_3487 3487 95645.6
c_3471_3487_i 3471 3471_3487 9.36084e-12
r_112_128_e 112 128 13376.4
r_112_128_i 112_128 128 93218.1
c_112_128_i 112 112_128 2.08965e-09
r_672_688_e 672 688 13376.4
r_672_688_i 672_688 688 93218.1
c_672_688_i 672 672_688 2.08965e-09
r_1232_1248_e 1232 1248 836.944
r_1232_1248_i 1232_1248 1248 4256.89
c_1232_1248_i 1232 1232_1248 4.67522e-10
r_1792_1808_e 1792 1808 836.944
r_1792_1808_i 1792_1808 1808 4256.89
c_1792_1808_i 1792 1792_1808 4.67522e-10
r_2352_2368_e 2352 2368 836.944
r_2352_2368_i 2352_2368 2368 4256.89
c_2352_2368_i 2352 2352_2368 4.67522e-10
r_2912_2928_e 2912 2928 13758.3
r_2912_2928_i 2912_2928 2928 95645.6
c_2912_2928_i 2912 2912_2928 9.36084e-12
r_3472_3488_e 3472 3488 13758.3
r_3472_3488_i 3472_3488 3488 95645.6
c_3472_3488_i 3472 3472_3488 9.36084e-12
r_113_129_e 113 129 13376.4
r_113_129_i 113_129 129 93218.1
c_113_129_i 113 113_129 2.08965e-09
r_673_689_e 673 689 13376.4
r_673_689_i 673_689 689 93218.1
c_673_689_i 673 673_689 2.08965e-09
r_1233_1249_e 1233 1249 13376.4
r_1233_1249_i 1233_1249 1249 93218.1
c_1233_1249_i 1233 1233_1249 2.08965e-09
r_1793_1809_e 1793 1809 13376.4
r_1793_1809_i 1793_1809 1809 93218.1
c_1793_1809_i 1793 1793_1809 2.08965e-09
r_2353_2369_e 2353 2369 13376.4
r_2353_2369_i 2353_2369 2369 93218.1
c_2353_2369_i 2353 2353_2369 2.08965e-09
r_2913_2929_e 2913 2929 13376.4
r_2913_2929_i 2913_2929 2929 93218.1
c_2913_2929_i 2913 2913_2929 2.08965e-09
r_3473_3489_e 3473 3489 13376.4
r_3473_3489_i 3473_3489 3489 93218.1
c_3473_3489_i 3473 3473_3489 2.08965e-09
r_114_130_e 114 130 13376.4
r_114_130_i 114_130 130 93218.1
c_114_130_i 114 114_130 2.08965e-09
r_674_690_e 674 690 13376.4
r_674_690_i 674_690 690 93218.1
c_674_690_i 674 674_690 2.08965e-09
r_1234_1250_e 1234 1250 13376.4
r_1234_1250_i 1234_1250 1250 93218.1
c_1234_1250_i 1234 1234_1250 2.08965e-09
r_1794_1810_e 1794 1810 13376.4
r_1794_1810_i 1794_1810 1810 93218.1
c_1794_1810_i 1794 1794_1810 2.08965e-09
r_2354_2370_e 2354 2370 13376.4
r_2354_2370_i 2354_2370 2370 93218.1
c_2354_2370_i 2354 2354_2370 2.08965e-09
r_2914_2930_e 2914 2930 13376.4
r_2914_2930_i 2914_2930 2930 93218.1
c_2914_2930_i 2914 2914_2930 2.08965e-09
r_3474_3490_e 3474 3490 13376.4
r_3474_3490_i 3474_3490 3490 93218.1
c_3474_3490_i 3474 3474_3490 2.08965e-09
r_115_131_e 115 131 13376.4
r_115_131_i 115_131 131 93218.1
c_115_131_i 115 115_131 2.08965e-09
r_675_691_e 675 691 13376.4
r_675_691_i 675_691 691 93218.1
c_675_691_i 675 675_691 2.08965e-09
r_1235_1251_e 1235 1251 836.944
r_1235_1251_i 1235_1251 1251 4256.89
c_1235_1251_i 1235 1235_1251 4.67522e-10
r_1795_1811_e 1795 1811 836.944
r_1795_1811_i 1795_1811 1811 4256.89
c_1795_1811_i 1795 1795_1811 4.67522e-10
r_2355_2371_e 2355 2371 836.944
r_2355_2371_i 2355_2371 2371 4256.89
c_2355_2371_i 2355 2355_2371 4.67522e-10
r_2915_2931_e 2915 2931 836.944
r_2915_2931_i 2915_2931 2931 4256.89
c_2915_2931_i 2915 2915_2931 4.67522e-10
r_3475_3491_e 3475 3491 836.944
r_3475_3491_i 3475_3491 3491 4256.89
c_3475_3491_i 3475 3475_3491 4.67522e-10
r_116_132_e 116 132 13376.4
r_116_132_i 116_132 132 93218.1
c_116_132_i 116 116_132 2.08965e-09
r_676_692_e 676 692 13376.4
r_676_692_i 676_692 692 93218.1
c_676_692_i 676 676_692 2.08965e-09
r_1236_1252_e 1236 1252 836.944
r_1236_1252_i 1236_1252 1252 4256.89
c_1236_1252_i 1236 1236_1252 4.67522e-10
r_1796_1812_e 1796 1812 836.944
r_1796_1812_i 1796_1812 1812 4256.89
c_1796_1812_i 1796 1796_1812 4.67522e-10
r_2356_2372_e 2356 2372 836.944
r_2356_2372_i 2356_2372 2372 4256.89
c_2356_2372_i 2356 2356_2372 4.67522e-10
r_2916_2932_e 2916 2932 13758.3
r_2916_2932_i 2916_2932 2932 95645.6
c_2916_2932_i 2916 2916_2932 9.36084e-12
r_3476_3492_e 3476 3492 13758.3
r_3476_3492_i 3476_3492 3492 95645.6
c_3476_3492_i 3476 3476_3492 9.36084e-12
r_117_133_e 117 133 13376.4
r_117_133_i 117_133 133 93218.1
c_117_133_i 117 117_133 2.08965e-09
r_677_693_e 677 693 13376.4
r_677_693_i 677_693 693 93218.1
c_677_693_i 677 677_693 2.08965e-09
r_1237_1253_e 1237 1253 836.944
r_1237_1253_i 1237_1253 1253 4256.89
c_1237_1253_i 1237 1237_1253 4.67522e-10
r_1797_1813_e 1797 1813 836.944
r_1797_1813_i 1797_1813 1813 4256.89
c_1797_1813_i 1797 1797_1813 4.67522e-10
r_2357_2373_e 2357 2373 836.944
r_2357_2373_i 2357_2373 2373 4256.89
c_2357_2373_i 2357 2357_2373 4.67522e-10
r_2917_2933_e 2917 2933 13758.3
r_2917_2933_i 2917_2933 2933 95645.6
c_2917_2933_i 2917 2917_2933 9.36084e-12
r_3477_3493_e 3477 3493 13758.3
r_3477_3493_i 3477_3493 3493 95645.6
c_3477_3493_i 3477 3477_3493 9.36084e-12
r_118_134_e 118 134 13376.4
r_118_134_i 118_134 134 93218.1
c_118_134_i 118 118_134 2.08965e-09
r_678_694_e 678 694 13376.4
r_678_694_i 678_694 694 93218.1
c_678_694_i 678 678_694 2.08965e-09
r_1238_1254_e 1238 1254 836.944
r_1238_1254_i 1238_1254 1254 4256.89
c_1238_1254_i 1238 1238_1254 4.67522e-10
r_1798_1814_e 1798 1814 836.944
r_1798_1814_i 1798_1814 1814 4256.89
c_1798_1814_i 1798 1798_1814 4.67522e-10
r_2358_2374_e 2358 2374 836.944
r_2358_2374_i 2358_2374 2374 4256.89
c_2358_2374_i 2358 2358_2374 4.67522e-10
r_2918_2934_e 2918 2934 13758.3
r_2918_2934_i 2918_2934 2934 95645.6
c_2918_2934_i 2918 2918_2934 9.36084e-12
r_3478_3494_e 3478 3494 13758.3
r_3478_3494_i 3478_3494 3494 95645.6
c_3478_3494_i 3478 3478_3494 9.36084e-12
r_119_135_e 119 135 13376.4
r_119_135_i 119_135 135 93218.1
c_119_135_i 119 119_135 2.08965e-09
r_679_695_e 679 695 13376.4
r_679_695_i 679_695 695 93218.1
c_679_695_i 679 679_695 2.08965e-09
r_1239_1255_e 1239 1255 836.944
r_1239_1255_i 1239_1255 1255 4256.89
c_1239_1255_i 1239 1239_1255 4.67522e-10
r_1799_1815_e 1799 1815 836.944
r_1799_1815_i 1799_1815 1815 4256.89
c_1799_1815_i 1799 1799_1815 4.67522e-10
r_2359_2375_e 2359 2375 836.944
r_2359_2375_i 2359_2375 2375 4256.89
c_2359_2375_i 2359 2359_2375 4.67522e-10
r_2919_2935_e 2919 2935 13758.3
r_2919_2935_i 2919_2935 2935 95645.6
c_2919_2935_i 2919 2919_2935 9.36084e-12
r_3479_3495_e 3479 3495 13758.3
r_3479_3495_i 3479_3495 3495 95645.6
c_3479_3495_i 3479 3479_3495 9.36084e-12
r_120_136_e 120 136 13376.4
r_120_136_i 120_136 136 93218.1
c_120_136_i 120 120_136 2.08965e-09
r_680_696_e 680 696 13376.4
r_680_696_i 680_696 696 93218.1
c_680_696_i 680 680_696 2.08965e-09
r_1240_1256_e 1240 1256 836.944
r_1240_1256_i 1240_1256 1256 4256.89
c_1240_1256_i 1240 1240_1256 4.67522e-10
r_1800_1816_e 1800 1816 836.944
r_1800_1816_i 1800_1816 1816 4256.89
c_1800_1816_i 1800 1800_1816 4.67522e-10
r_2360_2376_e 2360 2376 836.944
r_2360_2376_i 2360_2376 2376 4256.89
c_2360_2376_i 2360 2360_2376 4.67522e-10
r_2920_2936_e 2920 2936 13758.3
r_2920_2936_i 2920_2936 2936 95645.6
c_2920_2936_i 2920 2920_2936 9.36084e-12
r_3480_3496_e 3480 3496 13758.3
r_3480_3496_i 3480_3496 3496 95645.6
c_3480_3496_i 3480 3480_3496 9.36084e-12
r_121_137_e 121 137 13376.4
r_121_137_i 121_137 137 93218.1
c_121_137_i 121 121_137 2.08965e-09
r_681_697_e 681 697 13376.4
r_681_697_i 681_697 697 93218.1
c_681_697_i 681 681_697 2.08965e-09
r_1241_1257_e 1241 1257 836.944
r_1241_1257_i 1241_1257 1257 4256.89
c_1241_1257_i 1241 1241_1257 4.67522e-10
r_1801_1817_e 1801 1817 836.944
r_1801_1817_i 1801_1817 1817 4256.89
c_1801_1817_i 1801 1801_1817 4.67522e-10
r_2361_2377_e 2361 2377 836.944
r_2361_2377_i 2361_2377 2377 4256.89
c_2361_2377_i 2361 2361_2377 4.67522e-10
r_2921_2937_e 2921 2937 13758.3
r_2921_2937_i 2921_2937 2937 95645.6
c_2921_2937_i 2921 2921_2937 9.36084e-12
r_3481_3497_e 3481 3497 13758.3
r_3481_3497_i 3481_3497 3497 95645.6
c_3481_3497_i 3481 3481_3497 9.36084e-12
r_122_138_e 122 138 13376.4
r_122_138_i 122_138 138 93218.1
c_122_138_i 122 122_138 2.08965e-09
r_682_698_e 682 698 13376.4
r_682_698_i 682_698 698 93218.1
c_682_698_i 682 682_698 2.08965e-09
r_1242_1258_e 1242 1258 836.944
r_1242_1258_i 1242_1258 1258 4256.89
c_1242_1258_i 1242 1242_1258 4.67522e-10
r_1802_1818_e 1802 1818 836.944
r_1802_1818_i 1802_1818 1818 4256.89
c_1802_1818_i 1802 1802_1818 4.67522e-10
r_2362_2378_e 2362 2378 836.944
r_2362_2378_i 2362_2378 2378 4256.89
c_2362_2378_i 2362 2362_2378 4.67522e-10
r_2922_2938_e 2922 2938 13758.3
r_2922_2938_i 2922_2938 2938 95645.6
c_2922_2938_i 2922 2922_2938 9.36084e-12
r_3482_3498_e 3482 3498 13758.3
r_3482_3498_i 3482_3498 3498 95645.6
c_3482_3498_i 3482 3482_3498 9.36084e-12
r_123_139_e 123 139 13376.4
r_123_139_i 123_139 139 93218.1
c_123_139_i 123 123_139 2.08965e-09
r_683_699_e 683 699 13376.4
r_683_699_i 683_699 699 93218.1
c_683_699_i 683 683_699 2.08965e-09
r_1243_1259_e 1243 1259 396.706
r_1243_1259_i 1243_1259 1259 1005.29
c_1243_1259_i 1243 1243_1259 1.65792e-10
r_1803_1819_e 1803 1819 396.706
r_1803_1819_i 1803_1819 1819 1005.29
c_1803_1819_i 1803 1803_1819 1.65792e-10
r_2363_2379_e 2363 2379 836.944
r_2363_2379_i 2363_2379 2379 4256.89
c_2363_2379_i 2363 2363_2379 4.67522e-10
r_2923_2939_e 2923 2939 13758.3
r_2923_2939_i 2923_2939 2939 95645.6
c_2923_2939_i 2923 2923_2939 9.36084e-12
r_3483_3499_e 3483 3499 13758.3
r_3483_3499_i 3483_3499 3499 95645.6
c_3483_3499_i 3483 3483_3499 9.36084e-12
r_124_140_e 124 140 13376.4
r_124_140_i 124_140 140 93218.1
c_124_140_i 124 124_140 2.08965e-09
r_684_700_e 684 700 13376.4
r_684_700_i 684_700 700 93218.1
c_684_700_i 684 684_700 2.08965e-09
r_1244_1260_e 1244 1260 396.706
r_1244_1260_i 1244_1260 1260 1005.29
c_1244_1260_i 1244 1244_1260 1.65792e-10
r_1804_1820_e 1804 1820 396.706
r_1804_1820_i 1804_1820 1820 1005.29
c_1804_1820_i 1804 1804_1820 1.65792e-10
r_2364_2380_e 2364 2380 836.944
r_2364_2380_i 2364_2380 2380 4256.89
c_2364_2380_i 2364 2364_2380 4.67522e-10
r_2924_2940_e 2924 2940 13758.3
r_2924_2940_i 2924_2940 2940 95645.6
c_2924_2940_i 2924 2924_2940 9.36084e-12
r_3484_3500_e 3484 3500 13758.3
r_3484_3500_i 3484_3500 3500 95645.6
c_3484_3500_i 3484 3484_3500 9.36084e-12
r_125_141_e 125 141 13376.4
r_125_141_i 125_141 141 93218.1
c_125_141_i 125 125_141 2.08965e-09
r_685_701_e 685 701 13376.4
r_685_701_i 685_701 701 93218.1
c_685_701_i 685 685_701 2.08965e-09
r_1245_1261_e 1245 1261 836.944
r_1245_1261_i 1245_1261 1261 4256.89
c_1245_1261_i 1245 1245_1261 4.67522e-10
r_1805_1821_e 1805 1821 836.944
r_1805_1821_i 1805_1821 1821 4256.89
c_1805_1821_i 1805 1805_1821 4.67522e-10
r_2365_2381_e 2365 2381 836.944
r_2365_2381_i 2365_2381 2381 4256.89
c_2365_2381_i 2365 2365_2381 4.67522e-10
r_2925_2941_e 2925 2941 13758.3
r_2925_2941_i 2925_2941 2941 95645.6
c_2925_2941_i 2925 2925_2941 9.36084e-12
r_3485_3501_e 3485 3501 13758.3
r_3485_3501_i 3485_3501 3501 95645.6
c_3485_3501_i 3485 3485_3501 9.36084e-12
r_126_142_e 126 142 13376.4
r_126_142_i 126_142 142 93218.1
c_126_142_i 126 126_142 2.08965e-09
r_686_702_e 686 702 13376.4
r_686_702_i 686_702 702 93218.1
c_686_702_i 686 686_702 2.08965e-09
r_1246_1262_e 1246 1262 836.944
r_1246_1262_i 1246_1262 1262 4256.89
c_1246_1262_i 1246 1246_1262 4.67522e-10
r_1806_1822_e 1806 1822 836.944
r_1806_1822_i 1806_1822 1822 4256.89
c_1806_1822_i 1806 1806_1822 4.67522e-10
r_2366_2382_e 2366 2382 836.944
r_2366_2382_i 2366_2382 2382 4256.89
c_2366_2382_i 2366 2366_2382 4.67522e-10
r_2926_2942_e 2926 2942 13758.3
r_2926_2942_i 2926_2942 2942 95645.6
c_2926_2942_i 2926 2926_2942 9.36084e-12
r_3486_3502_e 3486 3502 13758.3
r_3486_3502_i 3486_3502 3502 95645.6
c_3486_3502_i 3486 3486_3502 9.36084e-12
r_127_143_e 127 143 13376.4
r_127_143_i 127_143 143 93218.1
c_127_143_i 127 127_143 2.08965e-09
r_687_703_e 687 703 13376.4
r_687_703_i 687_703 703 93218.1
c_687_703_i 687 687_703 2.08965e-09
r_1247_1263_e 1247 1263 836.944
r_1247_1263_i 1247_1263 1263 4256.89
c_1247_1263_i 1247 1247_1263 4.67522e-10
r_1807_1823_e 1807 1823 836.944
r_1807_1823_i 1807_1823 1823 4256.89
c_1807_1823_i 1807 1807_1823 4.67522e-10
r_2367_2383_e 2367 2383 836.944
r_2367_2383_i 2367_2383 2383 4256.89
c_2367_2383_i 2367 2367_2383 4.67522e-10
r_2927_2943_e 2927 2943 13758.3
r_2927_2943_i 2927_2943 2943 95645.6
c_2927_2943_i 2927 2927_2943 9.36084e-12
r_3487_3503_e 3487 3503 13758.3
r_3487_3503_i 3487_3503 3503 95645.6
c_3487_3503_i 3487 3487_3503 9.36084e-12
r_128_144_e 128 144 13376.4
r_128_144_i 128_144 144 93218.1
c_128_144_i 128 128_144 2.08965e-09
r_688_704_e 688 704 13376.4
r_688_704_i 688_704 704 93218.1
c_688_704_i 688 688_704 2.08965e-09
r_1248_1264_e 1248 1264 836.944
r_1248_1264_i 1248_1264 1264 4256.89
c_1248_1264_i 1248 1248_1264 4.67522e-10
r_1808_1824_e 1808 1824 836.944
r_1808_1824_i 1808_1824 1824 4256.89
c_1808_1824_i 1808 1808_1824 4.67522e-10
r_2368_2384_e 2368 2384 836.944
r_2368_2384_i 2368_2384 2384 4256.89
c_2368_2384_i 2368 2368_2384 4.67522e-10
r_2928_2944_e 2928 2944 13758.3
r_2928_2944_i 2928_2944 2944 95645.6
c_2928_2944_i 2928 2928_2944 9.36084e-12
r_3488_3504_e 3488 3504 13758.3
r_3488_3504_i 3488_3504 3504 95645.6
c_3488_3504_i 3488 3488_3504 9.36084e-12
r_129_145_e 129 145 13376.4
r_129_145_i 129_145 145 93218.1
c_129_145_i 129 129_145 2.08965e-09
r_689_705_e 689 705 13376.4
r_689_705_i 689_705 705 93218.1
c_689_705_i 689 689_705 2.08965e-09
r_1249_1265_e 1249 1265 13376.4
r_1249_1265_i 1249_1265 1265 93218.1
c_1249_1265_i 1249 1249_1265 2.08965e-09
r_1809_1825_e 1809 1825 13376.4
r_1809_1825_i 1809_1825 1825 93218.1
c_1809_1825_i 1809 1809_1825 2.08965e-09
r_2369_2385_e 2369 2385 13376.4
r_2369_2385_i 2369_2385 2385 93218.1
c_2369_2385_i 2369 2369_2385 2.08965e-09
r_2929_2945_e 2929 2945 13376.4
r_2929_2945_i 2929_2945 2945 93218.1
c_2929_2945_i 2929 2929_2945 2.08965e-09
r_3489_3505_e 3489 3505 13376.4
r_3489_3505_i 3489_3505 3505 93218.1
c_3489_3505_i 3489 3489_3505 2.08965e-09
r_130_146_e 130 146 13376.4
r_130_146_i 130_146 146 93218.1
c_130_146_i 130 130_146 2.08965e-09
r_690_706_e 690 706 13376.4
r_690_706_i 690_706 706 93218.1
c_690_706_i 690 690_706 2.08965e-09
r_1250_1266_e 1250 1266 13376.4
r_1250_1266_i 1250_1266 1266 93218.1
c_1250_1266_i 1250 1250_1266 2.08965e-09
r_1810_1826_e 1810 1826 13376.4
r_1810_1826_i 1810_1826 1826 93218.1
c_1810_1826_i 1810 1810_1826 2.08965e-09
r_2370_2386_e 2370 2386 13376.4
r_2370_2386_i 2370_2386 2386 93218.1
c_2370_2386_i 2370 2370_2386 2.08965e-09
r_2930_2946_e 2930 2946 13376.4
r_2930_2946_i 2930_2946 2946 93218.1
c_2930_2946_i 2930 2930_2946 2.08965e-09
r_3490_3506_e 3490 3506 13376.4
r_3490_3506_i 3490_3506 3506 93218.1
c_3490_3506_i 3490 3490_3506 2.08965e-09
r_131_147_e 131 147 13376.4
r_131_147_i 131_147 147 93218.1
c_131_147_i 131 131_147 2.08965e-09
r_691_707_e 691 707 13376.4
r_691_707_i 691_707 707 93218.1
c_691_707_i 691 691_707 2.08965e-09
r_1251_1267_e 1251 1267 836.944
r_1251_1267_i 1251_1267 1267 4256.89
c_1251_1267_i 1251 1251_1267 4.67522e-10
r_1811_1827_e 1811 1827 836.944
r_1811_1827_i 1811_1827 1827 4256.89
c_1811_1827_i 1811 1811_1827 4.67522e-10
r_2371_2387_e 2371 2387 836.944
r_2371_2387_i 2371_2387 2387 4256.89
c_2371_2387_i 2371 2371_2387 4.67522e-10
r_2931_2947_e 2931 2947 836.944
r_2931_2947_i 2931_2947 2947 4256.89
c_2931_2947_i 2931 2931_2947 4.67522e-10
r_3491_3507_e 3491 3507 836.944
r_3491_3507_i 3491_3507 3507 4256.89
c_3491_3507_i 3491 3491_3507 4.67522e-10
r_132_148_e 132 148 13376.4
r_132_148_i 132_148 148 93218.1
c_132_148_i 132 132_148 2.08965e-09
r_692_708_e 692 708 13376.4
r_692_708_i 692_708 708 93218.1
c_692_708_i 692 692_708 2.08965e-09
r_1252_1268_e 1252 1268 836.944
r_1252_1268_i 1252_1268 1268 4256.89
c_1252_1268_i 1252 1252_1268 4.67522e-10
r_1812_1828_e 1812 1828 836.944
r_1812_1828_i 1812_1828 1828 4256.89
c_1812_1828_i 1812 1812_1828 4.67522e-10
r_2372_2388_e 2372 2388 836.944
r_2372_2388_i 2372_2388 2388 4256.89
c_2372_2388_i 2372 2372_2388 4.67522e-10
r_2932_2948_e 2932 2948 13758.3
r_2932_2948_i 2932_2948 2948 95645.6
c_2932_2948_i 2932 2932_2948 9.36084e-12
r_3492_3508_e 3492 3508 13758.3
r_3492_3508_i 3492_3508 3508 95645.6
c_3492_3508_i 3492 3492_3508 9.36084e-12
r_133_149_e 133 149 13376.4
r_133_149_i 133_149 149 93218.1
c_133_149_i 133 133_149 2.08965e-09
r_693_709_e 693 709 13376.4
r_693_709_i 693_709 709 93218.1
c_693_709_i 693 693_709 2.08965e-09
r_1253_1269_e 1253 1269 836.944
r_1253_1269_i 1253_1269 1269 4256.89
c_1253_1269_i 1253 1253_1269 4.67522e-10
r_1813_1829_e 1813 1829 836.944
r_1813_1829_i 1813_1829 1829 4256.89
c_1813_1829_i 1813 1813_1829 4.67522e-10
r_2373_2389_e 2373 2389 836.944
r_2373_2389_i 2373_2389 2389 4256.89
c_2373_2389_i 2373 2373_2389 4.67522e-10
r_2933_2949_e 2933 2949 13758.3
r_2933_2949_i 2933_2949 2949 95645.6
c_2933_2949_i 2933 2933_2949 9.36084e-12
r_3493_3509_e 3493 3509 13758.3
r_3493_3509_i 3493_3509 3509 95645.6
c_3493_3509_i 3493 3493_3509 9.36084e-12
r_134_150_e 134 150 13376.4
r_134_150_i 134_150 150 93218.1
c_134_150_i 134 134_150 2.08965e-09
r_694_710_e 694 710 13376.4
r_694_710_i 694_710 710 93218.1
c_694_710_i 694 694_710 2.08965e-09
r_1254_1270_e 1254 1270 836.944
r_1254_1270_i 1254_1270 1270 4256.89
c_1254_1270_i 1254 1254_1270 4.67522e-10
r_1814_1830_e 1814 1830 836.944
r_1814_1830_i 1814_1830 1830 4256.89
c_1814_1830_i 1814 1814_1830 4.67522e-10
r_2374_2390_e 2374 2390 836.944
r_2374_2390_i 2374_2390 2390 4256.89
c_2374_2390_i 2374 2374_2390 4.67522e-10
r_2934_2950_e 2934 2950 13758.3
r_2934_2950_i 2934_2950 2950 95645.6
c_2934_2950_i 2934 2934_2950 9.36084e-12
r_3494_3510_e 3494 3510 13758.3
r_3494_3510_i 3494_3510 3510 95645.6
c_3494_3510_i 3494 3494_3510 9.36084e-12
r_135_151_e 135 151 13376.4
r_135_151_i 135_151 151 93218.1
c_135_151_i 135 135_151 2.08965e-09
r_695_711_e 695 711 13376.4
r_695_711_i 695_711 711 93218.1
c_695_711_i 695 695_711 2.08965e-09
r_1255_1271_e 1255 1271 836.944
r_1255_1271_i 1255_1271 1271 4256.89
c_1255_1271_i 1255 1255_1271 4.67522e-10
r_1815_1831_e 1815 1831 836.944
r_1815_1831_i 1815_1831 1831 4256.89
c_1815_1831_i 1815 1815_1831 4.67522e-10
r_2375_2391_e 2375 2391 836.944
r_2375_2391_i 2375_2391 2391 4256.89
c_2375_2391_i 2375 2375_2391 4.67522e-10
r_2935_2951_e 2935 2951 13758.3
r_2935_2951_i 2935_2951 2951 95645.6
c_2935_2951_i 2935 2935_2951 9.36084e-12
r_3495_3511_e 3495 3511 13758.3
r_3495_3511_i 3495_3511 3511 95645.6
c_3495_3511_i 3495 3495_3511 9.36084e-12
r_136_152_e 136 152 13376.4
r_136_152_i 136_152 152 93218.1
c_136_152_i 136 136_152 2.08965e-09
r_696_712_e 696 712 13376.4
r_696_712_i 696_712 712 93218.1
c_696_712_i 696 696_712 2.08965e-09
r_1256_1272_e 1256 1272 836.944
r_1256_1272_i 1256_1272 1272 4256.89
c_1256_1272_i 1256 1256_1272 4.67522e-10
r_1816_1832_e 1816 1832 836.944
r_1816_1832_i 1816_1832 1832 4256.89
c_1816_1832_i 1816 1816_1832 4.67522e-10
r_2376_2392_e 2376 2392 836.944
r_2376_2392_i 2376_2392 2392 4256.89
c_2376_2392_i 2376 2376_2392 4.67522e-10
r_2936_2952_e 2936 2952 13758.3
r_2936_2952_i 2936_2952 2952 95645.6
c_2936_2952_i 2936 2936_2952 9.36084e-12
r_3496_3512_e 3496 3512 13758.3
r_3496_3512_i 3496_3512 3512 95645.6
c_3496_3512_i 3496 3496_3512 9.36084e-12
r_137_153_e 137 153 13376.4
r_137_153_i 137_153 153 93218.1
c_137_153_i 137 137_153 2.08965e-09
r_697_713_e 697 713 13376.4
r_697_713_i 697_713 713 93218.1
c_697_713_i 697 697_713 2.08965e-09
r_1257_1273_e 1257 1273 836.944
r_1257_1273_i 1257_1273 1273 4256.89
c_1257_1273_i 1257 1257_1273 4.67522e-10
r_1817_1833_e 1817 1833 836.944
r_1817_1833_i 1817_1833 1833 4256.89
c_1817_1833_i 1817 1817_1833 4.67522e-10
r_2377_2393_e 2377 2393 836.944
r_2377_2393_i 2377_2393 2393 4256.89
c_2377_2393_i 2377 2377_2393 4.67522e-10
r_2937_2953_e 2937 2953 13758.3
r_2937_2953_i 2937_2953 2953 95645.6
c_2937_2953_i 2937 2937_2953 9.36084e-12
r_3497_3513_e 3497 3513 13758.3
r_3497_3513_i 3497_3513 3513 95645.6
c_3497_3513_i 3497 3497_3513 9.36084e-12
r_138_154_e 138 154 13376.4
r_138_154_i 138_154 154 93218.1
c_138_154_i 138 138_154 2.08965e-09
r_698_714_e 698 714 13376.4
r_698_714_i 698_714 714 93218.1
c_698_714_i 698 698_714 2.08965e-09
r_1258_1274_e 1258 1274 836.944
r_1258_1274_i 1258_1274 1274 4256.89
c_1258_1274_i 1258 1258_1274 4.67522e-10
r_1818_1834_e 1818 1834 836.944
r_1818_1834_i 1818_1834 1834 4256.89
c_1818_1834_i 1818 1818_1834 4.67522e-10
r_2378_2394_e 2378 2394 836.944
r_2378_2394_i 2378_2394 2394 4256.89
c_2378_2394_i 2378 2378_2394 4.67522e-10
r_2938_2954_e 2938 2954 13758.3
r_2938_2954_i 2938_2954 2954 95645.6
c_2938_2954_i 2938 2938_2954 9.36084e-12
r_3498_3514_e 3498 3514 13758.3
r_3498_3514_i 3498_3514 3514 95645.6
c_3498_3514_i 3498 3498_3514 9.36084e-12
r_139_155_e 139 155 13376.4
r_139_155_i 139_155 155 93218.1
c_139_155_i 139 139_155 2.08965e-09
r_699_715_e 699 715 13376.4
r_699_715_i 699_715 715 93218.1
c_699_715_i 699 699_715 2.08965e-09
r_1259_1275_e 1259 1275 396.697
r_1259_1275_i 1259_1275 1275 1005.27
c_1259_1275_i 1259 1259_1275 1.65796e-10
r_1819_1835_e 1819 1835 396.697
r_1819_1835_i 1819_1835 1835 1005.27
c_1819_1835_i 1819 1819_1835 1.65796e-10
r_2379_2395_e 2379 2395 836.944
r_2379_2395_i 2379_2395 2395 4256.89
c_2379_2395_i 2379 2379_2395 4.67522e-10
r_2939_2955_e 2939 2955 13758.3
r_2939_2955_i 2939_2955 2955 95645.6
c_2939_2955_i 2939 2939_2955 9.36084e-12
r_3499_3515_e 3499 3515 13758.3
r_3499_3515_i 3499_3515 3515 95645.6
c_3499_3515_i 3499 3499_3515 9.36084e-12
r_140_156_e 140 156 13376.4
r_140_156_i 140_156 156 93218.1
c_140_156_i 140 140_156 2.08965e-09
r_700_716_e 700 716 13376.4
r_700_716_i 700_716 716 93218.1
c_700_716_i 700 700_716 2.08965e-09
r_1260_1276_e 1260 1276 396.697
r_1260_1276_i 1260_1276 1276 1005.27
c_1260_1276_i 1260 1260_1276 1.65796e-10
r_1820_1836_e 1820 1836 396.697
r_1820_1836_i 1820_1836 1836 1005.27
c_1820_1836_i 1820 1820_1836 1.65796e-10
r_2380_2396_e 2380 2396 836.944
r_2380_2396_i 2380_2396 2396 4256.89
c_2380_2396_i 2380 2380_2396 4.67522e-10
r_2940_2956_e 2940 2956 13758.3
r_2940_2956_i 2940_2956 2956 95645.6
c_2940_2956_i 2940 2940_2956 9.36084e-12
r_3500_3516_e 3500 3516 13758.3
r_3500_3516_i 3500_3516 3516 95645.6
c_3500_3516_i 3500 3500_3516 9.36084e-12
r_141_157_e 141 157 13376.4
r_141_157_i 141_157 157 93218.1
c_141_157_i 141 141_157 2.08965e-09
r_701_717_e 701 717 13376.4
r_701_717_i 701_717 717 93218.1
c_701_717_i 701 701_717 2.08965e-09
r_1261_1277_e 1261 1277 836.944
r_1261_1277_i 1261_1277 1277 4256.89
c_1261_1277_i 1261 1261_1277 4.67522e-10
r_1821_1837_e 1821 1837 836.944
r_1821_1837_i 1821_1837 1837 4256.89
c_1821_1837_i 1821 1821_1837 4.67522e-10
r_2381_2397_e 2381 2397 836.944
r_2381_2397_i 2381_2397 2397 4256.89
c_2381_2397_i 2381 2381_2397 4.67522e-10
r_2941_2957_e 2941 2957 13758.3
r_2941_2957_i 2941_2957 2957 95645.6
c_2941_2957_i 2941 2941_2957 9.36084e-12
r_3501_3517_e 3501 3517 13758.3
r_3501_3517_i 3501_3517 3517 95645.6
c_3501_3517_i 3501 3501_3517 9.36084e-12
r_142_158_e 142 158 13376.4
r_142_158_i 142_158 158 93218.1
c_142_158_i 142 142_158 2.08965e-09
r_702_718_e 702 718 13376.4
r_702_718_i 702_718 718 93218.1
c_702_718_i 702 702_718 2.08965e-09
r_1262_1278_e 1262 1278 836.944
r_1262_1278_i 1262_1278 1278 4256.89
c_1262_1278_i 1262 1262_1278 4.67522e-10
r_1822_1838_e 1822 1838 836.944
r_1822_1838_i 1822_1838 1838 4256.89
c_1822_1838_i 1822 1822_1838 4.67522e-10
r_2382_2398_e 2382 2398 836.944
r_2382_2398_i 2382_2398 2398 4256.89
c_2382_2398_i 2382 2382_2398 4.67522e-10
r_2942_2958_e 2942 2958 13758.3
r_2942_2958_i 2942_2958 2958 95645.6
c_2942_2958_i 2942 2942_2958 9.36084e-12
r_3502_3518_e 3502 3518 13758.3
r_3502_3518_i 3502_3518 3518 95645.6
c_3502_3518_i 3502 3502_3518 9.36084e-12
r_143_159_e 143 159 13376.4
r_143_159_i 143_159 159 93218.1
c_143_159_i 143 143_159 2.08965e-09
r_703_719_e 703 719 13376.4
r_703_719_i 703_719 719 93218.1
c_703_719_i 703 703_719 2.08965e-09
r_1263_1279_e 1263 1279 836.944
r_1263_1279_i 1263_1279 1279 4256.89
c_1263_1279_i 1263 1263_1279 4.67522e-10
r_1823_1839_e 1823 1839 836.944
r_1823_1839_i 1823_1839 1839 4256.89
c_1823_1839_i 1823 1823_1839 4.67522e-10
r_2383_2399_e 2383 2399 836.944
r_2383_2399_i 2383_2399 2399 4256.89
c_2383_2399_i 2383 2383_2399 4.67522e-10
r_2943_2959_e 2943 2959 13758.3
r_2943_2959_i 2943_2959 2959 95645.6
c_2943_2959_i 2943 2943_2959 9.36084e-12
r_3503_3519_e 3503 3519 13758.3
r_3503_3519_i 3503_3519 3519 95645.6
c_3503_3519_i 3503 3503_3519 9.36084e-12
r_144_160_e 144 160 13376.4
r_144_160_i 144_160 160 93218.1
c_144_160_i 144 144_160 2.08965e-09
r_704_720_e 704 720 13376.4
r_704_720_i 704_720 720 93218.1
c_704_720_i 704 704_720 2.08965e-09
r_1264_1280_e 1264 1280 836.944
r_1264_1280_i 1264_1280 1280 4256.89
c_1264_1280_i 1264 1264_1280 4.67522e-10
r_1824_1840_e 1824 1840 836.944
r_1824_1840_i 1824_1840 1840 4256.89
c_1824_1840_i 1824 1824_1840 4.67522e-10
r_2384_2400_e 2384 2400 836.944
r_2384_2400_i 2384_2400 2400 4256.89
c_2384_2400_i 2384 2384_2400 4.67522e-10
r_2944_2960_e 2944 2960 13758.3
r_2944_2960_i 2944_2960 2960 95645.6
c_2944_2960_i 2944 2944_2960 9.36084e-12
r_3504_3520_e 3504 3520 13758.3
r_3504_3520_i 3504_3520 3520 95645.6
c_3504_3520_i 3504 3504_3520 9.36084e-12
r_145_161_e 145 161 13376.4
r_145_161_i 145_161 161 93218.1
c_145_161_i 145 145_161 2.08965e-09
r_705_721_e 705 721 13376.4
r_705_721_i 705_721 721 93218.1
c_705_721_i 705 705_721 2.08965e-09
r_1265_1281_e 1265 1281 13376.4
r_1265_1281_i 1265_1281 1281 93218.1
c_1265_1281_i 1265 1265_1281 2.08965e-09
r_1825_1841_e 1825 1841 13376.4
r_1825_1841_i 1825_1841 1841 93218.1
c_1825_1841_i 1825 1825_1841 2.08965e-09
r_2385_2401_e 2385 2401 13376.4
r_2385_2401_i 2385_2401 2401 93218.1
c_2385_2401_i 2385 2385_2401 2.08965e-09
r_2945_2961_e 2945 2961 13376.4
r_2945_2961_i 2945_2961 2961 93218.1
c_2945_2961_i 2945 2945_2961 2.08965e-09
r_3505_3521_e 3505 3521 13376.4
r_3505_3521_i 3505_3521 3521 93218.1
c_3505_3521_i 3505 3505_3521 2.08965e-09
r_146_162_e 146 162 13376.4
r_146_162_i 146_162 162 93218.1
c_146_162_i 146 146_162 2.08965e-09
r_706_722_e 706 722 13376.4
r_706_722_i 706_722 722 93218.1
c_706_722_i 706 706_722 2.08965e-09
r_1266_1282_e 1266 1282 13376.4
r_1266_1282_i 1266_1282 1282 93218.1
c_1266_1282_i 1266 1266_1282 2.08965e-09
r_1826_1842_e 1826 1842 13376.4
r_1826_1842_i 1826_1842 1842 93218.1
c_1826_1842_i 1826 1826_1842 2.08965e-09
r_2386_2402_e 2386 2402 13376.4
r_2386_2402_i 2386_2402 2402 93218.1
c_2386_2402_i 2386 2386_2402 2.08965e-09
r_2946_2962_e 2946 2962 13376.4
r_2946_2962_i 2946_2962 2962 93218.1
c_2946_2962_i 2946 2946_2962 2.08965e-09
r_3506_3522_e 3506 3522 13376.4
r_3506_3522_i 3506_3522 3522 93218.1
c_3506_3522_i 3506 3506_3522 2.08965e-09
r_147_163_e 147 163 13376.4
r_147_163_i 147_163 163 93218.1
c_147_163_i 147 147_163 2.08965e-09
r_707_723_e 707 723 13376.4
r_707_723_i 707_723 723 93218.1
c_707_723_i 707 707_723 2.08965e-09
r_1267_1283_e 1267 1283 836.944
r_1267_1283_i 1267_1283 1283 4256.89
c_1267_1283_i 1267 1267_1283 4.67522e-10
r_1827_1843_e 1827 1843 836.944
r_1827_1843_i 1827_1843 1843 4256.89
c_1827_1843_i 1827 1827_1843 4.67522e-10
r_2387_2403_e 2387 2403 836.944
r_2387_2403_i 2387_2403 2403 4256.89
c_2387_2403_i 2387 2387_2403 4.67522e-10
r_2947_2963_e 2947 2963 836.944
r_2947_2963_i 2947_2963 2963 4256.89
c_2947_2963_i 2947 2947_2963 4.67522e-10
r_3507_3523_e 3507 3523 836.944
r_3507_3523_i 3507_3523 3523 4256.89
c_3507_3523_i 3507 3507_3523 4.67522e-10
r_148_164_e 148 164 13376.4
r_148_164_i 148_164 164 93218.1
c_148_164_i 148 148_164 2.08965e-09
r_708_724_e 708 724 13376.4
r_708_724_i 708_724 724 93218.1
c_708_724_i 708 708_724 2.08965e-09
r_1268_1284_e 1268 1284 836.944
r_1268_1284_i 1268_1284 1284 4256.89
c_1268_1284_i 1268 1268_1284 4.67522e-10
r_1828_1844_e 1828 1844 836.944
r_1828_1844_i 1828_1844 1844 4256.89
c_1828_1844_i 1828 1828_1844 4.67522e-10
r_2388_2404_e 2388 2404 836.944
r_2388_2404_i 2388_2404 2404 4256.89
c_2388_2404_i 2388 2388_2404 4.67522e-10
r_2948_2964_e 2948 2964 13758.3
r_2948_2964_i 2948_2964 2964 95645.6
c_2948_2964_i 2948 2948_2964 9.36084e-12
r_3508_3524_e 3508 3524 13758.3
r_3508_3524_i 3508_3524 3524 95645.6
c_3508_3524_i 3508 3508_3524 9.36084e-12
r_149_165_e 149 165 13376.4
r_149_165_i 149_165 165 93218.1
c_149_165_i 149 149_165 2.08965e-09
r_709_725_e 709 725 13376.4
r_709_725_i 709_725 725 93218.1
c_709_725_i 709 709_725 2.08965e-09
r_1269_1285_e 1269 1285 836.944
r_1269_1285_i 1269_1285 1285 4256.89
c_1269_1285_i 1269 1269_1285 4.67522e-10
r_1829_1845_e 1829 1845 836.944
r_1829_1845_i 1829_1845 1845 4256.89
c_1829_1845_i 1829 1829_1845 4.67522e-10
r_2389_2405_e 2389 2405 836.944
r_2389_2405_i 2389_2405 2405 4256.89
c_2389_2405_i 2389 2389_2405 4.67522e-10
r_2949_2965_e 2949 2965 13758.3
r_2949_2965_i 2949_2965 2965 95645.6
c_2949_2965_i 2949 2949_2965 9.36084e-12
r_3509_3525_e 3509 3525 13758.3
r_3509_3525_i 3509_3525 3525 95645.6
c_3509_3525_i 3509 3509_3525 9.36084e-12
r_150_166_e 150 166 13376.4
r_150_166_i 150_166 166 93218.1
c_150_166_i 150 150_166 2.08965e-09
r_710_726_e 710 726 13376.4
r_710_726_i 710_726 726 93218.1
c_710_726_i 710 710_726 2.08965e-09
r_1270_1286_e 1270 1286 836.944
r_1270_1286_i 1270_1286 1286 4256.89
c_1270_1286_i 1270 1270_1286 4.67522e-10
r_1830_1846_e 1830 1846 836.944
r_1830_1846_i 1830_1846 1846 4256.89
c_1830_1846_i 1830 1830_1846 4.67522e-10
r_2390_2406_e 2390 2406 836.944
r_2390_2406_i 2390_2406 2406 4256.89
c_2390_2406_i 2390 2390_2406 4.67522e-10
r_2950_2966_e 2950 2966 13758.3
r_2950_2966_i 2950_2966 2966 95645.6
c_2950_2966_i 2950 2950_2966 9.36084e-12
r_3510_3526_e 3510 3526 13758.3
r_3510_3526_i 3510_3526 3526 95645.6
c_3510_3526_i 3510 3510_3526 9.36084e-12
r_151_167_e 151 167 13376.4
r_151_167_i 151_167 167 93218.1
c_151_167_i 151 151_167 2.08965e-09
r_711_727_e 711 727 13376.4
r_711_727_i 711_727 727 93218.1
c_711_727_i 711 711_727 2.08965e-09
r_1271_1287_e 1271 1287 836.944
r_1271_1287_i 1271_1287 1287 4256.89
c_1271_1287_i 1271 1271_1287 4.67522e-10
r_1831_1847_e 1831 1847 836.944
r_1831_1847_i 1831_1847 1847 4256.89
c_1831_1847_i 1831 1831_1847 4.67522e-10
r_2391_2407_e 2391 2407 836.944
r_2391_2407_i 2391_2407 2407 4256.89
c_2391_2407_i 2391 2391_2407 4.67522e-10
r_2951_2967_e 2951 2967 13758.3
r_2951_2967_i 2951_2967 2967 95645.6
c_2951_2967_i 2951 2951_2967 9.36084e-12
r_3511_3527_e 3511 3527 13758.3
r_3511_3527_i 3511_3527 3527 95645.6
c_3511_3527_i 3511 3511_3527 9.36084e-12
r_152_168_e 152 168 13376.4
r_152_168_i 152_168 168 93218.1
c_152_168_i 152 152_168 2.08965e-09
r_712_728_e 712 728 13376.4
r_712_728_i 712_728 728 93218.1
c_712_728_i 712 712_728 2.08965e-09
r_1272_1288_e 1272 1288 836.944
r_1272_1288_i 1272_1288 1288 4256.89
c_1272_1288_i 1272 1272_1288 4.67522e-10
r_1832_1848_e 1832 1848 836.944
r_1832_1848_i 1832_1848 1848 4256.89
c_1832_1848_i 1832 1832_1848 4.67522e-10
r_2392_2408_e 2392 2408 836.944
r_2392_2408_i 2392_2408 2408 4256.89
c_2392_2408_i 2392 2392_2408 4.67522e-10
r_2952_2968_e 2952 2968 13758.3
r_2952_2968_i 2952_2968 2968 95645.6
c_2952_2968_i 2952 2952_2968 9.36084e-12
r_3512_3528_e 3512 3528 13758.3
r_3512_3528_i 3512_3528 3528 95645.6
c_3512_3528_i 3512 3512_3528 9.36084e-12
r_153_169_e 153 169 13376.4
r_153_169_i 153_169 169 93218.1
c_153_169_i 153 153_169 2.08965e-09
r_713_729_e 713 729 13376.4
r_713_729_i 713_729 729 93218.1
c_713_729_i 713 713_729 2.08965e-09
r_1273_1289_e 1273 1289 836.944
r_1273_1289_i 1273_1289 1289 4256.89
c_1273_1289_i 1273 1273_1289 4.67522e-10
r_1833_1849_e 1833 1849 836.944
r_1833_1849_i 1833_1849 1849 4256.89
c_1833_1849_i 1833 1833_1849 4.67522e-10
r_2393_2409_e 2393 2409 836.944
r_2393_2409_i 2393_2409 2409 4256.89
c_2393_2409_i 2393 2393_2409 4.67522e-10
r_2953_2969_e 2953 2969 13758.3
r_2953_2969_i 2953_2969 2969 95645.6
c_2953_2969_i 2953 2953_2969 9.36084e-12
r_3513_3529_e 3513 3529 13758.3
r_3513_3529_i 3513_3529 3529 95645.6
c_3513_3529_i 3513 3513_3529 9.36084e-12
r_154_170_e 154 170 13376.4
r_154_170_i 154_170 170 93218.1
c_154_170_i 154 154_170 2.08965e-09
r_714_730_e 714 730 13376.4
r_714_730_i 714_730 730 93218.1
c_714_730_i 714 714_730 2.08965e-09
r_1274_1290_e 1274 1290 836.944
r_1274_1290_i 1274_1290 1290 4256.89
c_1274_1290_i 1274 1274_1290 4.67522e-10
r_1834_1850_e 1834 1850 836.944
r_1834_1850_i 1834_1850 1850 4256.89
c_1834_1850_i 1834 1834_1850 4.67522e-10
r_2394_2410_e 2394 2410 836.944
r_2394_2410_i 2394_2410 2410 4256.89
c_2394_2410_i 2394 2394_2410 4.67522e-10
r_2954_2970_e 2954 2970 13758.3
r_2954_2970_i 2954_2970 2970 95645.6
c_2954_2970_i 2954 2954_2970 9.36084e-12
r_3514_3530_e 3514 3530 13758.3
r_3514_3530_i 3514_3530 3530 95645.6
c_3514_3530_i 3514 3514_3530 9.36084e-12
r_155_171_e 155 171 13376.4
r_155_171_i 155_171 171 93218.1
c_155_171_i 155 155_171 2.08965e-09
r_715_731_e 715 731 13376.4
r_715_731_i 715_731 731 93218.1
c_715_731_i 715 715_731 2.08965e-09
r_1275_1291_e 1275 1291 396.689
r_1275_1291_i 1275_1291 1291 1005.25
c_1275_1291_i 1275 1275_1291 1.65799e-10
r_1835_1851_e 1835 1851 396.689
r_1835_1851_i 1835_1851 1851 1005.25
c_1835_1851_i 1835 1835_1851 1.65799e-10
r_2395_2411_e 2395 2411 836.944
r_2395_2411_i 2395_2411 2411 4256.89
c_2395_2411_i 2395 2395_2411 4.67522e-10
r_2955_2971_e 2955 2971 13758.3
r_2955_2971_i 2955_2971 2971 95645.6
c_2955_2971_i 2955 2955_2971 9.36084e-12
r_3515_3531_e 3515 3531 13758.3
r_3515_3531_i 3515_3531 3531 95645.6
c_3515_3531_i 3515 3515_3531 9.36084e-12
r_156_172_e 156 172 13376.4
r_156_172_i 156_172 172 93218.1
c_156_172_i 156 156_172 2.08965e-09
r_716_732_e 716 732 13376.4
r_716_732_i 716_732 732 93218.1
c_716_732_i 716 716_732 2.08965e-09
r_1276_1292_e 1276 1292 396.689
r_1276_1292_i 1276_1292 1292 1005.25
c_1276_1292_i 1276 1276_1292 1.65799e-10
r_1836_1852_e 1836 1852 396.689
r_1836_1852_i 1836_1852 1852 1005.25
c_1836_1852_i 1836 1836_1852 1.65799e-10
r_2396_2412_e 2396 2412 836.944
r_2396_2412_i 2396_2412 2412 4256.89
c_2396_2412_i 2396 2396_2412 4.67522e-10
r_2956_2972_e 2956 2972 13758.3
r_2956_2972_i 2956_2972 2972 95645.6
c_2956_2972_i 2956 2956_2972 9.36084e-12
r_3516_3532_e 3516 3532 13758.3
r_3516_3532_i 3516_3532 3532 95645.6
c_3516_3532_i 3516 3516_3532 9.36084e-12
r_157_173_e 157 173 13376.4
r_157_173_i 157_173 173 93218.1
c_157_173_i 157 157_173 2.08965e-09
r_717_733_e 717 733 13376.4
r_717_733_i 717_733 733 93218.1
c_717_733_i 717 717_733 2.08965e-09
r_1277_1293_e 1277 1293 836.944
r_1277_1293_i 1277_1293 1293 4256.89
c_1277_1293_i 1277 1277_1293 4.67522e-10
r_1837_1853_e 1837 1853 836.944
r_1837_1853_i 1837_1853 1853 4256.89
c_1837_1853_i 1837 1837_1853 4.67522e-10
r_2397_2413_e 2397 2413 836.944
r_2397_2413_i 2397_2413 2413 4256.89
c_2397_2413_i 2397 2397_2413 4.67522e-10
r_2957_2973_e 2957 2973 13758.3
r_2957_2973_i 2957_2973 2973 95645.6
c_2957_2973_i 2957 2957_2973 9.36084e-12
r_3517_3533_e 3517 3533 13758.3
r_3517_3533_i 3517_3533 3533 95645.6
c_3517_3533_i 3517 3517_3533 9.36084e-12
r_158_174_e 158 174 13376.4
r_158_174_i 158_174 174 93218.1
c_158_174_i 158 158_174 2.08965e-09
r_718_734_e 718 734 13376.4
r_718_734_i 718_734 734 93218.1
c_718_734_i 718 718_734 2.08965e-09
r_1278_1294_e 1278 1294 836.944
r_1278_1294_i 1278_1294 1294 4256.89
c_1278_1294_i 1278 1278_1294 4.67522e-10
r_1838_1854_e 1838 1854 836.944
r_1838_1854_i 1838_1854 1854 4256.89
c_1838_1854_i 1838 1838_1854 4.67522e-10
r_2398_2414_e 2398 2414 836.944
r_2398_2414_i 2398_2414 2414 4256.89
c_2398_2414_i 2398 2398_2414 4.67522e-10
r_2958_2974_e 2958 2974 13758.3
r_2958_2974_i 2958_2974 2974 95645.6
c_2958_2974_i 2958 2958_2974 9.36084e-12
r_3518_3534_e 3518 3534 13758.3
r_3518_3534_i 3518_3534 3534 95645.6
c_3518_3534_i 3518 3518_3534 9.36084e-12
r_159_175_e 159 175 13376.4
r_159_175_i 159_175 175 93218.1
c_159_175_i 159 159_175 2.08965e-09
r_719_735_e 719 735 13376.4
r_719_735_i 719_735 735 93218.1
c_719_735_i 719 719_735 2.08965e-09
r_1279_1295_e 1279 1295 836.944
r_1279_1295_i 1279_1295 1295 4256.89
c_1279_1295_i 1279 1279_1295 4.67522e-10
r_1839_1855_e 1839 1855 836.944
r_1839_1855_i 1839_1855 1855 4256.89
c_1839_1855_i 1839 1839_1855 4.67522e-10
r_2399_2415_e 2399 2415 836.944
r_2399_2415_i 2399_2415 2415 4256.89
c_2399_2415_i 2399 2399_2415 4.67522e-10
r_2959_2975_e 2959 2975 13758.3
r_2959_2975_i 2959_2975 2975 95645.6
c_2959_2975_i 2959 2959_2975 9.36084e-12
r_3519_3535_e 3519 3535 13758.3
r_3519_3535_i 3519_3535 3535 95645.6
c_3519_3535_i 3519 3519_3535 9.36084e-12
r_160_176_e 160 176 13376.4
r_160_176_i 160_176 176 93218.1
c_160_176_i 160 160_176 2.08965e-09
r_720_736_e 720 736 13376.4
r_720_736_i 720_736 736 93218.1
c_720_736_i 720 720_736 2.08965e-09
r_1280_1296_e 1280 1296 836.944
r_1280_1296_i 1280_1296 1296 4256.89
c_1280_1296_i 1280 1280_1296 4.67522e-10
r_1840_1856_e 1840 1856 836.944
r_1840_1856_i 1840_1856 1856 4256.89
c_1840_1856_i 1840 1840_1856 4.67522e-10
r_2400_2416_e 2400 2416 836.944
r_2400_2416_i 2400_2416 2416 4256.89
c_2400_2416_i 2400 2400_2416 4.67522e-10
r_2960_2976_e 2960 2976 13758.3
r_2960_2976_i 2960_2976 2976 95645.6
c_2960_2976_i 2960 2960_2976 9.36084e-12
r_3520_3536_e 3520 3536 13758.3
r_3520_3536_i 3520_3536 3536 95645.6
c_3520_3536_i 3520 3520_3536 9.36084e-12
r_161_177_e 161 177 13376.4
r_161_177_i 161_177 177 93218.1
c_161_177_i 161 161_177 2.08965e-09
r_721_737_e 721 737 13376.4
r_721_737_i 721_737 737 93218.1
c_721_737_i 721 721_737 2.08965e-09
r_1281_1297_e 1281 1297 13376.4
r_1281_1297_i 1281_1297 1297 93218.1
c_1281_1297_i 1281 1281_1297 2.08965e-09
r_1841_1857_e 1841 1857 13376.4
r_1841_1857_i 1841_1857 1857 93218.1
c_1841_1857_i 1841 1841_1857 2.08965e-09
r_2401_2417_e 2401 2417 13376.4
r_2401_2417_i 2401_2417 2417 93218.1
c_2401_2417_i 2401 2401_2417 2.08965e-09
r_2961_2977_e 2961 2977 13376.4
r_2961_2977_i 2961_2977 2977 93218.1
c_2961_2977_i 2961 2961_2977 2.08965e-09
r_3521_3537_e 3521 3537 13376.4
r_3521_3537_i 3521_3537 3537 93218.1
c_3521_3537_i 3521 3521_3537 2.08965e-09
r_162_178_e 162 178 13376.4
r_162_178_i 162_178 178 93218.1
c_162_178_i 162 162_178 2.08965e-09
r_722_738_e 722 738 13376.4
r_722_738_i 722_738 738 93218.1
c_722_738_i 722 722_738 2.08965e-09
r_1282_1298_e 1282 1298 13376.4
r_1282_1298_i 1282_1298 1298 93218.1
c_1282_1298_i 1282 1282_1298 2.08965e-09
r_1842_1858_e 1842 1858 13376.4
r_1842_1858_i 1842_1858 1858 93218.1
c_1842_1858_i 1842 1842_1858 2.08965e-09
r_2402_2418_e 2402 2418 13376.4
r_2402_2418_i 2402_2418 2418 93218.1
c_2402_2418_i 2402 2402_2418 2.08965e-09
r_2962_2978_e 2962 2978 13376.4
r_2962_2978_i 2962_2978 2978 93218.1
c_2962_2978_i 2962 2962_2978 2.08965e-09
r_3522_3538_e 3522 3538 13376.4
r_3522_3538_i 3522_3538 3538 93218.1
c_3522_3538_i 3522 3522_3538 2.08965e-09
r_163_179_e 163 179 13376.4
r_163_179_i 163_179 179 93218.1
c_163_179_i 163 163_179 2.08965e-09
r_723_739_e 723 739 13376.4
r_723_739_i 723_739 739 93218.1
c_723_739_i 723 723_739 2.08965e-09
r_1283_1299_e 1283 1299 836.944
r_1283_1299_i 1283_1299 1299 4256.89
c_1283_1299_i 1283 1283_1299 4.67522e-10
r_1843_1859_e 1843 1859 836.944
r_1843_1859_i 1843_1859 1859 4256.89
c_1843_1859_i 1843 1843_1859 4.67522e-10
r_2403_2419_e 2403 2419 836.944
r_2403_2419_i 2403_2419 2419 4256.89
c_2403_2419_i 2403 2403_2419 4.67522e-10
r_2963_2979_e 2963 2979 836.944
r_2963_2979_i 2963_2979 2979 4256.89
c_2963_2979_i 2963 2963_2979 4.67522e-10
r_3523_3539_e 3523 3539 836.944
r_3523_3539_i 3523_3539 3539 4256.89
c_3523_3539_i 3523 3523_3539 4.67522e-10
r_164_180_e 164 180 13376.4
r_164_180_i 164_180 180 93218.1
c_164_180_i 164 164_180 2.08965e-09
r_724_740_e 724 740 13376.4
r_724_740_i 724_740 740 93218.1
c_724_740_i 724 724_740 2.08965e-09
r_1284_1300_e 1284 1300 836.944
r_1284_1300_i 1284_1300 1300 4256.89
c_1284_1300_i 1284 1284_1300 4.67522e-10
r_1844_1860_e 1844 1860 836.944
r_1844_1860_i 1844_1860 1860 4256.89
c_1844_1860_i 1844 1844_1860 4.67522e-10
r_2404_2420_e 2404 2420 836.944
r_2404_2420_i 2404_2420 2420 4256.89
c_2404_2420_i 2404 2404_2420 4.67522e-10
r_2964_2980_e 2964 2980 13758.3
r_2964_2980_i 2964_2980 2980 95645.6
c_2964_2980_i 2964 2964_2980 9.36084e-12
r_3524_3540_e 3524 3540 13758.3
r_3524_3540_i 3524_3540 3540 95645.6
c_3524_3540_i 3524 3524_3540 9.36084e-12
r_165_181_e 165 181 13376.4
r_165_181_i 165_181 181 93218.1
c_165_181_i 165 165_181 2.08965e-09
r_725_741_e 725 741 13376.4
r_725_741_i 725_741 741 93218.1
c_725_741_i 725 725_741 2.08965e-09
r_1285_1301_e 1285 1301 836.944
r_1285_1301_i 1285_1301 1301 4256.89
c_1285_1301_i 1285 1285_1301 4.67522e-10
r_1845_1861_e 1845 1861 836.944
r_1845_1861_i 1845_1861 1861 4256.89
c_1845_1861_i 1845 1845_1861 4.67522e-10
r_2405_2421_e 2405 2421 836.944
r_2405_2421_i 2405_2421 2421 4256.89
c_2405_2421_i 2405 2405_2421 4.67522e-10
r_2965_2981_e 2965 2981 13758.3
r_2965_2981_i 2965_2981 2981 95645.6
c_2965_2981_i 2965 2965_2981 9.36084e-12
r_3525_3541_e 3525 3541 13758.3
r_3525_3541_i 3525_3541 3541 95645.6
c_3525_3541_i 3525 3525_3541 9.36084e-12
r_166_182_e 166 182 13376.4
r_166_182_i 166_182 182 93218.1
c_166_182_i 166 166_182 2.08965e-09
r_726_742_e 726 742 13376.4
r_726_742_i 726_742 742 93218.1
c_726_742_i 726 726_742 2.08965e-09
r_1286_1302_e 1286 1302 836.944
r_1286_1302_i 1286_1302 1302 4256.89
c_1286_1302_i 1286 1286_1302 4.67522e-10
r_1846_1862_e 1846 1862 836.944
r_1846_1862_i 1846_1862 1862 4256.89
c_1846_1862_i 1846 1846_1862 4.67522e-10
r_2406_2422_e 2406 2422 836.944
r_2406_2422_i 2406_2422 2422 4256.89
c_2406_2422_i 2406 2406_2422 4.67522e-10
r_2966_2982_e 2966 2982 13758.3
r_2966_2982_i 2966_2982 2982 95645.6
c_2966_2982_i 2966 2966_2982 9.36084e-12
r_3526_3542_e 3526 3542 13758.3
r_3526_3542_i 3526_3542 3542 95645.6
c_3526_3542_i 3526 3526_3542 9.36084e-12
r_167_183_e 167 183 13376.4
r_167_183_i 167_183 183 93218.1
c_167_183_i 167 167_183 2.08965e-09
r_727_743_e 727 743 13376.4
r_727_743_i 727_743 743 93218.1
c_727_743_i 727 727_743 2.08965e-09
r_1287_1303_e 1287 1303 836.944
r_1287_1303_i 1287_1303 1303 4256.89
c_1287_1303_i 1287 1287_1303 4.67522e-10
r_1847_1863_e 1847 1863 836.944
r_1847_1863_i 1847_1863 1863 4256.89
c_1847_1863_i 1847 1847_1863 4.67522e-10
r_2407_2423_e 2407 2423 836.944
r_2407_2423_i 2407_2423 2423 4256.89
c_2407_2423_i 2407 2407_2423 4.67522e-10
r_2967_2983_e 2967 2983 13758.3
r_2967_2983_i 2967_2983 2983 95645.6
c_2967_2983_i 2967 2967_2983 9.36084e-12
r_3527_3543_e 3527 3543 13758.3
r_3527_3543_i 3527_3543 3543 95645.6
c_3527_3543_i 3527 3527_3543 9.36084e-12
r_168_184_e 168 184 13376.4
r_168_184_i 168_184 184 93218.1
c_168_184_i 168 168_184 2.08965e-09
r_728_744_e 728 744 13376.4
r_728_744_i 728_744 744 93218.1
c_728_744_i 728 728_744 2.08965e-09
r_1288_1304_e 1288 1304 836.944
r_1288_1304_i 1288_1304 1304 4256.89
c_1288_1304_i 1288 1288_1304 4.67522e-10
r_1848_1864_e 1848 1864 836.944
r_1848_1864_i 1848_1864 1864 4256.89
c_1848_1864_i 1848 1848_1864 4.67522e-10
r_2408_2424_e 2408 2424 836.944
r_2408_2424_i 2408_2424 2424 4256.89
c_2408_2424_i 2408 2408_2424 4.67522e-10
r_2968_2984_e 2968 2984 13758.3
r_2968_2984_i 2968_2984 2984 95645.6
c_2968_2984_i 2968 2968_2984 9.36084e-12
r_3528_3544_e 3528 3544 13758.3
r_3528_3544_i 3528_3544 3544 95645.6
c_3528_3544_i 3528 3528_3544 9.36084e-12
r_169_185_e 169 185 13376.4
r_169_185_i 169_185 185 93218.1
c_169_185_i 169 169_185 2.08965e-09
r_729_745_e 729 745 13376.4
r_729_745_i 729_745 745 93218.1
c_729_745_i 729 729_745 2.08965e-09
r_1289_1305_e 1289 1305 836.944
r_1289_1305_i 1289_1305 1305 4256.89
c_1289_1305_i 1289 1289_1305 4.67522e-10
r_1849_1865_e 1849 1865 836.944
r_1849_1865_i 1849_1865 1865 4256.89
c_1849_1865_i 1849 1849_1865 4.67522e-10
r_2409_2425_e 2409 2425 836.944
r_2409_2425_i 2409_2425 2425 4256.89
c_2409_2425_i 2409 2409_2425 4.67522e-10
r_2969_2985_e 2969 2985 13758.3
r_2969_2985_i 2969_2985 2985 95645.6
c_2969_2985_i 2969 2969_2985 9.36084e-12
r_3529_3545_e 3529 3545 13758.3
r_3529_3545_i 3529_3545 3545 95645.6
c_3529_3545_i 3529 3529_3545 9.36084e-12
r_170_186_e 170 186 13376.4
r_170_186_i 170_186 186 93218.1
c_170_186_i 170 170_186 2.08965e-09
r_730_746_e 730 746 13376.4
r_730_746_i 730_746 746 93218.1
c_730_746_i 730 730_746 2.08965e-09
r_1290_1306_e 1290 1306 836.944
r_1290_1306_i 1290_1306 1306 4256.89
c_1290_1306_i 1290 1290_1306 4.67522e-10
r_1850_1866_e 1850 1866 836.944
r_1850_1866_i 1850_1866 1866 4256.89
c_1850_1866_i 1850 1850_1866 4.67522e-10
r_2410_2426_e 2410 2426 836.944
r_2410_2426_i 2410_2426 2426 4256.89
c_2410_2426_i 2410 2410_2426 4.67522e-10
r_2970_2986_e 2970 2986 13758.3
r_2970_2986_i 2970_2986 2986 95645.6
c_2970_2986_i 2970 2970_2986 9.36084e-12
r_3530_3546_e 3530 3546 13758.3
r_3530_3546_i 3530_3546 3546 95645.6
c_3530_3546_i 3530 3530_3546 9.36084e-12
r_171_187_e 171 187 13376.4
r_171_187_i 171_187 187 93218.1
c_171_187_i 171 171_187 2.08965e-09
r_731_747_e 731 747 13376.4
r_731_747_i 731_747 747 93218.1
c_731_747_i 731 731_747 2.08965e-09
r_1291_1307_e 1291 1307 396.68
r_1291_1307_i 1291_1307 1307 1005.22
c_1291_1307_i 1291 1291_1307 1.65803e-10
r_1851_1867_e 1851 1867 396.68
r_1851_1867_i 1851_1867 1867 1005.22
c_1851_1867_i 1851 1851_1867 1.65803e-10
r_2411_2427_e 2411 2427 836.944
r_2411_2427_i 2411_2427 2427 4256.89
c_2411_2427_i 2411 2411_2427 4.67522e-10
r_2971_2987_e 2971 2987 13758.3
r_2971_2987_i 2971_2987 2987 95645.6
c_2971_2987_i 2971 2971_2987 9.36084e-12
r_3531_3547_e 3531 3547 13758.3
r_3531_3547_i 3531_3547 3547 95645.6
c_3531_3547_i 3531 3531_3547 9.36084e-12
r_172_188_e 172 188 13376.4
r_172_188_i 172_188 188 93218.1
c_172_188_i 172 172_188 2.08965e-09
r_732_748_e 732 748 13376.4
r_732_748_i 732_748 748 93218.1
c_732_748_i 732 732_748 2.08965e-09
r_1292_1308_e 1292 1308 396.68
r_1292_1308_i 1292_1308 1308 1005.22
c_1292_1308_i 1292 1292_1308 1.65803e-10
r_1852_1868_e 1852 1868 396.68
r_1852_1868_i 1852_1868 1868 1005.22
c_1852_1868_i 1852 1852_1868 1.65803e-10
r_2412_2428_e 2412 2428 836.944
r_2412_2428_i 2412_2428 2428 4256.89
c_2412_2428_i 2412 2412_2428 4.67522e-10
r_2972_2988_e 2972 2988 13758.3
r_2972_2988_i 2972_2988 2988 95645.6
c_2972_2988_i 2972 2972_2988 9.36084e-12
r_3532_3548_e 3532 3548 13758.3
r_3532_3548_i 3532_3548 3548 95645.6
c_3532_3548_i 3532 3532_3548 9.36084e-12
r_173_189_e 173 189 13376.4
r_173_189_i 173_189 189 93218.1
c_173_189_i 173 173_189 2.08965e-09
r_733_749_e 733 749 13376.4
r_733_749_i 733_749 749 93218.1
c_733_749_i 733 733_749 2.08965e-09
r_1293_1309_e 1293 1309 836.944
r_1293_1309_i 1293_1309 1309 4256.89
c_1293_1309_i 1293 1293_1309 4.67522e-10
r_1853_1869_e 1853 1869 836.944
r_1853_1869_i 1853_1869 1869 4256.89
c_1853_1869_i 1853 1853_1869 4.67522e-10
r_2413_2429_e 2413 2429 836.944
r_2413_2429_i 2413_2429 2429 4256.89
c_2413_2429_i 2413 2413_2429 4.67522e-10
r_2973_2989_e 2973 2989 13758.3
r_2973_2989_i 2973_2989 2989 95645.6
c_2973_2989_i 2973 2973_2989 9.36084e-12
r_3533_3549_e 3533 3549 13758.3
r_3533_3549_i 3533_3549 3549 95645.6
c_3533_3549_i 3533 3533_3549 9.36084e-12
r_174_190_e 174 190 13376.4
r_174_190_i 174_190 190 93218.1
c_174_190_i 174 174_190 2.08965e-09
r_734_750_e 734 750 13376.4
r_734_750_i 734_750 750 93218.1
c_734_750_i 734 734_750 2.08965e-09
r_1294_1310_e 1294 1310 836.944
r_1294_1310_i 1294_1310 1310 4256.89
c_1294_1310_i 1294 1294_1310 4.67522e-10
r_1854_1870_e 1854 1870 836.944
r_1854_1870_i 1854_1870 1870 4256.89
c_1854_1870_i 1854 1854_1870 4.67522e-10
r_2414_2430_e 2414 2430 836.944
r_2414_2430_i 2414_2430 2430 4256.89
c_2414_2430_i 2414 2414_2430 4.67522e-10
r_2974_2990_e 2974 2990 13758.3
r_2974_2990_i 2974_2990 2990 95645.6
c_2974_2990_i 2974 2974_2990 9.36084e-12
r_3534_3550_e 3534 3550 13758.3
r_3534_3550_i 3534_3550 3550 95645.6
c_3534_3550_i 3534 3534_3550 9.36084e-12
r_175_191_e 175 191 13376.4
r_175_191_i 175_191 191 93218.1
c_175_191_i 175 175_191 2.08965e-09
r_735_751_e 735 751 13376.4
r_735_751_i 735_751 751 93218.1
c_735_751_i 735 735_751 2.08965e-09
r_1295_1311_e 1295 1311 836.944
r_1295_1311_i 1295_1311 1311 4256.89
c_1295_1311_i 1295 1295_1311 4.67522e-10
r_1855_1871_e 1855 1871 836.944
r_1855_1871_i 1855_1871 1871 4256.89
c_1855_1871_i 1855 1855_1871 4.67522e-10
r_2415_2431_e 2415 2431 836.944
r_2415_2431_i 2415_2431 2431 4256.89
c_2415_2431_i 2415 2415_2431 4.67522e-10
r_2975_2991_e 2975 2991 13758.3
r_2975_2991_i 2975_2991 2991 95645.6
c_2975_2991_i 2975 2975_2991 9.36084e-12
r_3535_3551_e 3535 3551 13758.3
r_3535_3551_i 3535_3551 3551 95645.6
c_3535_3551_i 3535 3535_3551 9.36084e-12
r_176_192_e 176 192 13376.4
r_176_192_i 176_192 192 93218.1
c_176_192_i 176 176_192 2.08965e-09
r_736_752_e 736 752 13376.4
r_736_752_i 736_752 752 93218.1
c_736_752_i 736 736_752 2.08965e-09
r_1296_1312_e 1296 1312 836.944
r_1296_1312_i 1296_1312 1312 4256.89
c_1296_1312_i 1296 1296_1312 4.67522e-10
r_1856_1872_e 1856 1872 836.944
r_1856_1872_i 1856_1872 1872 4256.89
c_1856_1872_i 1856 1856_1872 4.67522e-10
r_2416_2432_e 2416 2432 836.944
r_2416_2432_i 2416_2432 2432 4256.89
c_2416_2432_i 2416 2416_2432 4.67522e-10
r_2976_2992_e 2976 2992 13758.3
r_2976_2992_i 2976_2992 2992 95645.6
c_2976_2992_i 2976 2976_2992 9.36084e-12
r_3536_3552_e 3536 3552 13758.3
r_3536_3552_i 3536_3552 3552 95645.6
c_3536_3552_i 3536 3536_3552 9.36084e-12
r_177_193_e 177 193 13376.4
r_177_193_i 177_193 193 93218.1
c_177_193_i 177 177_193 2.08965e-09
r_737_753_e 737 753 13376.4
r_737_753_i 737_753 753 93218.1
c_737_753_i 737 737_753 2.08965e-09
r_1297_1313_e 1297 1313 13376.4
r_1297_1313_i 1297_1313 1313 93218.1
c_1297_1313_i 1297 1297_1313 2.08965e-09
r_1857_1873_e 1857 1873 13376.4
r_1857_1873_i 1857_1873 1873 93218.1
c_1857_1873_i 1857 1857_1873 2.08965e-09
r_2417_2433_e 2417 2433 13376.4
r_2417_2433_i 2417_2433 2433 93218.1
c_2417_2433_i 2417 2417_2433 2.08965e-09
r_2977_2993_e 2977 2993 13376.4
r_2977_2993_i 2977_2993 2993 93218.1
c_2977_2993_i 2977 2977_2993 2.08965e-09
r_3537_3553_e 3537 3553 13376.4
r_3537_3553_i 3537_3553 3553 93218.1
c_3537_3553_i 3537 3537_3553 2.08965e-09
r_178_194_e 178 194 13376.4
r_178_194_i 178_194 194 93218.1
c_178_194_i 178 178_194 2.08965e-09
r_738_754_e 738 754 13376.4
r_738_754_i 738_754 754 93218.1
c_738_754_i 738 738_754 2.08965e-09
r_1298_1314_e 1298 1314 13376.4
r_1298_1314_i 1298_1314 1314 93218.1
c_1298_1314_i 1298 1298_1314 2.08965e-09
r_1858_1874_e 1858 1874 13376.4
r_1858_1874_i 1858_1874 1874 93218.1
c_1858_1874_i 1858 1858_1874 2.08965e-09
r_2418_2434_e 2418 2434 13376.4
r_2418_2434_i 2418_2434 2434 93218.1
c_2418_2434_i 2418 2418_2434 2.08965e-09
r_2978_2994_e 2978 2994 13376.4
r_2978_2994_i 2978_2994 2994 93218.1
c_2978_2994_i 2978 2978_2994 2.08965e-09
r_3538_3554_e 3538 3554 13376.4
r_3538_3554_i 3538_3554 3554 93218.1
c_3538_3554_i 3538 3538_3554 2.08965e-09
r_179_195_e 179 195 13376.4
r_179_195_i 179_195 195 93218.1
c_179_195_i 179 179_195 2.08965e-09
r_739_755_e 739 755 13376.4
r_739_755_i 739_755 755 93218.1
c_739_755_i 739 739_755 2.08965e-09
r_1299_1315_e 1299 1315 836.944
r_1299_1315_i 1299_1315 1315 4256.89
c_1299_1315_i 1299 1299_1315 4.67522e-10
r_1859_1875_e 1859 1875 836.944
r_1859_1875_i 1859_1875 1875 4256.89
c_1859_1875_i 1859 1859_1875 4.67522e-10
r_2419_2435_e 2419 2435 836.944
r_2419_2435_i 2419_2435 2435 4256.89
c_2419_2435_i 2419 2419_2435 4.67522e-10
r_2979_2995_e 2979 2995 836.944
r_2979_2995_i 2979_2995 2995 4256.89
c_2979_2995_i 2979 2979_2995 4.67522e-10
r_3539_3555_e 3539 3555 836.944
r_3539_3555_i 3539_3555 3555 4256.89
c_3539_3555_i 3539 3539_3555 4.67522e-10
r_180_196_e 180 196 13376.4
r_180_196_i 180_196 196 93218.1
c_180_196_i 180 180_196 2.08965e-09
r_740_756_e 740 756 13376.4
r_740_756_i 740_756 756 93218.1
c_740_756_i 740 740_756 2.08965e-09
r_1300_1316_e 1300 1316 836.944
r_1300_1316_i 1300_1316 1316 4256.89
c_1300_1316_i 1300 1300_1316 4.67522e-10
r_1860_1876_e 1860 1876 836.944
r_1860_1876_i 1860_1876 1876 4256.89
c_1860_1876_i 1860 1860_1876 4.67522e-10
r_2420_2436_e 2420 2436 836.944
r_2420_2436_i 2420_2436 2436 4256.89
c_2420_2436_i 2420 2420_2436 4.67522e-10
r_2980_2996_e 2980 2996 13758.3
r_2980_2996_i 2980_2996 2996 95645.6
c_2980_2996_i 2980 2980_2996 9.36084e-12
r_3540_3556_e 3540 3556 13758.3
r_3540_3556_i 3540_3556 3556 95645.6
c_3540_3556_i 3540 3540_3556 9.36084e-12
r_181_197_e 181 197 13376.4
r_181_197_i 181_197 197 93218.1
c_181_197_i 181 181_197 2.08965e-09
r_741_757_e 741 757 13376.4
r_741_757_i 741_757 757 93218.1
c_741_757_i 741 741_757 2.08965e-09
r_1301_1317_e 1301 1317 836.944
r_1301_1317_i 1301_1317 1317 4256.89
c_1301_1317_i 1301 1301_1317 4.67522e-10
r_1861_1877_e 1861 1877 836.944
r_1861_1877_i 1861_1877 1877 4256.89
c_1861_1877_i 1861 1861_1877 4.67522e-10
r_2421_2437_e 2421 2437 836.944
r_2421_2437_i 2421_2437 2437 4256.89
c_2421_2437_i 2421 2421_2437 4.67522e-10
r_2981_2997_e 2981 2997 13758.3
r_2981_2997_i 2981_2997 2997 95645.6
c_2981_2997_i 2981 2981_2997 9.36084e-12
r_3541_3557_e 3541 3557 13758.3
r_3541_3557_i 3541_3557 3557 95645.6
c_3541_3557_i 3541 3541_3557 9.36084e-12
r_182_198_e 182 198 13376.4
r_182_198_i 182_198 198 93218.1
c_182_198_i 182 182_198 2.08965e-09
r_742_758_e 742 758 13376.4
r_742_758_i 742_758 758 93218.1
c_742_758_i 742 742_758 2.08965e-09
r_1302_1318_e 1302 1318 836.944
r_1302_1318_i 1302_1318 1318 4256.89
c_1302_1318_i 1302 1302_1318 4.67522e-10
r_1862_1878_e 1862 1878 836.944
r_1862_1878_i 1862_1878 1878 4256.89
c_1862_1878_i 1862 1862_1878 4.67522e-10
r_2422_2438_e 2422 2438 836.944
r_2422_2438_i 2422_2438 2438 4256.89
c_2422_2438_i 2422 2422_2438 4.67522e-10
r_2982_2998_e 2982 2998 13758.3
r_2982_2998_i 2982_2998 2998 95645.6
c_2982_2998_i 2982 2982_2998 9.36084e-12
r_3542_3558_e 3542 3558 13758.3
r_3542_3558_i 3542_3558 3558 95645.6
c_3542_3558_i 3542 3542_3558 9.36084e-12
r_183_199_e 183 199 13376.4
r_183_199_i 183_199 199 93218.1
c_183_199_i 183 183_199 2.08965e-09
r_743_759_e 743 759 13376.4
r_743_759_i 743_759 759 93218.1
c_743_759_i 743 743_759 2.08965e-09
r_1303_1319_e 1303 1319 836.944
r_1303_1319_i 1303_1319 1319 4256.89
c_1303_1319_i 1303 1303_1319 4.67522e-10
r_1863_1879_e 1863 1879 836.944
r_1863_1879_i 1863_1879 1879 4256.89
c_1863_1879_i 1863 1863_1879 4.67522e-10
r_2423_2439_e 2423 2439 836.944
r_2423_2439_i 2423_2439 2439 4256.89
c_2423_2439_i 2423 2423_2439 4.67522e-10
r_2983_2999_e 2983 2999 13758.3
r_2983_2999_i 2983_2999 2999 95645.6
c_2983_2999_i 2983 2983_2999 9.36084e-12
r_3543_3559_e 3543 3559 13758.3
r_3543_3559_i 3543_3559 3559 95645.6
c_3543_3559_i 3543 3543_3559 9.36084e-12
r_184_200_e 184 200 13376.4
r_184_200_i 184_200 200 93218.1
c_184_200_i 184 184_200 2.08965e-09
r_744_760_e 744 760 13376.4
r_744_760_i 744_760 760 93218.1
c_744_760_i 744 744_760 2.08965e-09
r_1304_1320_e 1304 1320 836.944
r_1304_1320_i 1304_1320 1320 4256.89
c_1304_1320_i 1304 1304_1320 4.67522e-10
r_1864_1880_e 1864 1880 836.944
r_1864_1880_i 1864_1880 1880 4256.89
c_1864_1880_i 1864 1864_1880 4.67522e-10
r_2424_2440_e 2424 2440 836.944
r_2424_2440_i 2424_2440 2440 4256.89
c_2424_2440_i 2424 2424_2440 4.67522e-10
r_2984_3000_e 2984 3000 13758.3
r_2984_3000_i 2984_3000 3000 95645.6
c_2984_3000_i 2984 2984_3000 9.36084e-12
r_3544_3560_e 3544 3560 13758.3
r_3544_3560_i 3544_3560 3560 95645.6
c_3544_3560_i 3544 3544_3560 9.36084e-12
r_185_201_e 185 201 13376.4
r_185_201_i 185_201 201 93218.1
c_185_201_i 185 185_201 2.08965e-09
r_745_761_e 745 761 13376.4
r_745_761_i 745_761 761 93218.1
c_745_761_i 745 745_761 2.08965e-09
r_1305_1321_e 1305 1321 836.944
r_1305_1321_i 1305_1321 1321 4256.89
c_1305_1321_i 1305 1305_1321 4.67522e-10
r_1865_1881_e 1865 1881 836.944
r_1865_1881_i 1865_1881 1881 4256.89
c_1865_1881_i 1865 1865_1881 4.67522e-10
r_2425_2441_e 2425 2441 836.944
r_2425_2441_i 2425_2441 2441 4256.89
c_2425_2441_i 2425 2425_2441 4.67522e-10
r_2985_3001_e 2985 3001 13758.3
r_2985_3001_i 2985_3001 3001 95645.6
c_2985_3001_i 2985 2985_3001 9.36084e-12
r_3545_3561_e 3545 3561 13758.3
r_3545_3561_i 3545_3561 3561 95645.6
c_3545_3561_i 3545 3545_3561 9.36084e-12
r_186_202_e 186 202 13376.4
r_186_202_i 186_202 202 93218.1
c_186_202_i 186 186_202 2.08965e-09
r_746_762_e 746 762 13376.4
r_746_762_i 746_762 762 93218.1
c_746_762_i 746 746_762 2.08965e-09
r_1306_1322_e 1306 1322 836.944
r_1306_1322_i 1306_1322 1322 4256.89
c_1306_1322_i 1306 1306_1322 4.67522e-10
r_1866_1882_e 1866 1882 836.944
r_1866_1882_i 1866_1882 1882 4256.89
c_1866_1882_i 1866 1866_1882 4.67522e-10
r_2426_2442_e 2426 2442 836.944
r_2426_2442_i 2426_2442 2442 4256.89
c_2426_2442_i 2426 2426_2442 4.67522e-10
r_2986_3002_e 2986 3002 13758.3
r_2986_3002_i 2986_3002 3002 95645.6
c_2986_3002_i 2986 2986_3002 9.36084e-12
r_3546_3562_e 3546 3562 13758.3
r_3546_3562_i 3546_3562 3562 95645.6
c_3546_3562_i 3546 3546_3562 9.36084e-12
r_187_203_e 187 203 13376.4
r_187_203_i 187_203 203 93218.1
c_187_203_i 187 187_203 2.08965e-09
r_747_763_e 747 763 13376.4
r_747_763_i 747_763 763 93218.1
c_747_763_i 747 747_763 2.08965e-09
r_1307_1323_e 1307 1323 396.671
r_1307_1323_i 1307_1323 1323 1005.2
c_1307_1323_i 1307 1307_1323 1.65806e-10
r_1867_1883_e 1867 1883 396.671
r_1867_1883_i 1867_1883 1883 1005.2
c_1867_1883_i 1867 1867_1883 1.65806e-10
r_2427_2443_e 2427 2443 836.944
r_2427_2443_i 2427_2443 2443 4256.89
c_2427_2443_i 2427 2427_2443 4.67522e-10
r_2987_3003_e 2987 3003 13758.3
r_2987_3003_i 2987_3003 3003 95645.6
c_2987_3003_i 2987 2987_3003 9.36084e-12
r_3547_3563_e 3547 3563 13758.3
r_3547_3563_i 3547_3563 3563 95645.6
c_3547_3563_i 3547 3547_3563 9.36084e-12
r_188_204_e 188 204 13376.4
r_188_204_i 188_204 204 93218.1
c_188_204_i 188 188_204 2.08965e-09
r_748_764_e 748 764 13376.4
r_748_764_i 748_764 764 93218.1
c_748_764_i 748 748_764 2.08965e-09
r_1308_1324_e 1308 1324 396.671
r_1308_1324_i 1308_1324 1324 1005.2
c_1308_1324_i 1308 1308_1324 1.65806e-10
r_1868_1884_e 1868 1884 396.671
r_1868_1884_i 1868_1884 1884 1005.2
c_1868_1884_i 1868 1868_1884 1.65806e-10
r_2428_2444_e 2428 2444 836.944
r_2428_2444_i 2428_2444 2444 4256.89
c_2428_2444_i 2428 2428_2444 4.67522e-10
r_2988_3004_e 2988 3004 13758.3
r_2988_3004_i 2988_3004 3004 95645.6
c_2988_3004_i 2988 2988_3004 9.36084e-12
r_3548_3564_e 3548 3564 13758.3
r_3548_3564_i 3548_3564 3564 95645.6
c_3548_3564_i 3548 3548_3564 9.36084e-12
r_189_205_e 189 205 13376.4
r_189_205_i 189_205 205 93218.1
c_189_205_i 189 189_205 2.08965e-09
r_749_765_e 749 765 13376.4
r_749_765_i 749_765 765 93218.1
c_749_765_i 749 749_765 2.08965e-09
r_1309_1325_e 1309 1325 836.944
r_1309_1325_i 1309_1325 1325 4256.89
c_1309_1325_i 1309 1309_1325 4.67522e-10
r_1869_1885_e 1869 1885 836.944
r_1869_1885_i 1869_1885 1885 4256.89
c_1869_1885_i 1869 1869_1885 4.67522e-10
r_2429_2445_e 2429 2445 836.944
r_2429_2445_i 2429_2445 2445 4256.89
c_2429_2445_i 2429 2429_2445 4.67522e-10
r_2989_3005_e 2989 3005 13758.3
r_2989_3005_i 2989_3005 3005 95645.6
c_2989_3005_i 2989 2989_3005 9.36084e-12
r_3549_3565_e 3549 3565 13758.3
r_3549_3565_i 3549_3565 3565 95645.6
c_3549_3565_i 3549 3549_3565 9.36084e-12
r_190_206_e 190 206 13376.4
r_190_206_i 190_206 206 93218.1
c_190_206_i 190 190_206 2.08965e-09
r_750_766_e 750 766 13376.4
r_750_766_i 750_766 766 93218.1
c_750_766_i 750 750_766 2.08965e-09
r_1310_1326_e 1310 1326 836.944
r_1310_1326_i 1310_1326 1326 4256.89
c_1310_1326_i 1310 1310_1326 4.67522e-10
r_1870_1886_e 1870 1886 836.944
r_1870_1886_i 1870_1886 1886 4256.89
c_1870_1886_i 1870 1870_1886 4.67522e-10
r_2430_2446_e 2430 2446 836.944
r_2430_2446_i 2430_2446 2446 4256.89
c_2430_2446_i 2430 2430_2446 4.67522e-10
r_2990_3006_e 2990 3006 13758.3
r_2990_3006_i 2990_3006 3006 95645.6
c_2990_3006_i 2990 2990_3006 9.36084e-12
r_3550_3566_e 3550 3566 13758.3
r_3550_3566_i 3550_3566 3566 95645.6
c_3550_3566_i 3550 3550_3566 9.36084e-12
r_191_207_e 191 207 13376.4
r_191_207_i 191_207 207 93218.1
c_191_207_i 191 191_207 2.08965e-09
r_751_767_e 751 767 13376.4
r_751_767_i 751_767 767 93218.1
c_751_767_i 751 751_767 2.08965e-09
r_1311_1327_e 1311 1327 836.944
r_1311_1327_i 1311_1327 1327 4256.89
c_1311_1327_i 1311 1311_1327 4.67522e-10
r_1871_1887_e 1871 1887 836.944
r_1871_1887_i 1871_1887 1887 4256.89
c_1871_1887_i 1871 1871_1887 4.67522e-10
r_2431_2447_e 2431 2447 836.944
r_2431_2447_i 2431_2447 2447 4256.89
c_2431_2447_i 2431 2431_2447 4.67522e-10
r_2991_3007_e 2991 3007 13758.3
r_2991_3007_i 2991_3007 3007 95645.6
c_2991_3007_i 2991 2991_3007 9.36084e-12
r_3551_3567_e 3551 3567 13758.3
r_3551_3567_i 3551_3567 3567 95645.6
c_3551_3567_i 3551 3551_3567 9.36084e-12
r_192_208_e 192 208 13376.4
r_192_208_i 192_208 208 93218.1
c_192_208_i 192 192_208 2.08965e-09
r_752_768_e 752 768 13376.4
r_752_768_i 752_768 768 93218.1
c_752_768_i 752 752_768 2.08965e-09
r_1312_1328_e 1312 1328 836.944
r_1312_1328_i 1312_1328 1328 4256.89
c_1312_1328_i 1312 1312_1328 4.67522e-10
r_1872_1888_e 1872 1888 836.944
r_1872_1888_i 1872_1888 1888 4256.89
c_1872_1888_i 1872 1872_1888 4.67522e-10
r_2432_2448_e 2432 2448 836.944
r_2432_2448_i 2432_2448 2448 4256.89
c_2432_2448_i 2432 2432_2448 4.67522e-10
r_2992_3008_e 2992 3008 13758.3
r_2992_3008_i 2992_3008 3008 95645.6
c_2992_3008_i 2992 2992_3008 9.36084e-12
r_3552_3568_e 3552 3568 13758.3
r_3552_3568_i 3552_3568 3568 95645.6
c_3552_3568_i 3552 3552_3568 9.36084e-12
r_193_209_e 193 209 13376.4
r_193_209_i 193_209 209 93218.1
c_193_209_i 193 193_209 2.08965e-09
r_753_769_e 753 769 13376.4
r_753_769_i 753_769 769 93218.1
c_753_769_i 753 753_769 2.08965e-09
r_1313_1329_e 1313 1329 13376.4
r_1313_1329_i 1313_1329 1329 93218.1
c_1313_1329_i 1313 1313_1329 2.08965e-09
r_1873_1889_e 1873 1889 13376.4
r_1873_1889_i 1873_1889 1889 93218.1
c_1873_1889_i 1873 1873_1889 2.08965e-09
r_2433_2449_e 2433 2449 13376.4
r_2433_2449_i 2433_2449 2449 93218.1
c_2433_2449_i 2433 2433_2449 2.08965e-09
r_2993_3009_e 2993 3009 13376.4
r_2993_3009_i 2993_3009 3009 93218.1
c_2993_3009_i 2993 2993_3009 2.08965e-09
r_3553_3569_e 3553 3569 13376.4
r_3553_3569_i 3553_3569 3569 93218.1
c_3553_3569_i 3553 3553_3569 2.08965e-09
r_194_210_e 194 210 13376.4
r_194_210_i 194_210 210 93218.1
c_194_210_i 194 194_210 2.08965e-09
r_754_770_e 754 770 13376.4
r_754_770_i 754_770 770 93218.1
c_754_770_i 754 754_770 2.08965e-09
r_1314_1330_e 1314 1330 13376.4
r_1314_1330_i 1314_1330 1330 93218.1
c_1314_1330_i 1314 1314_1330 2.08965e-09
r_1874_1890_e 1874 1890 13376.4
r_1874_1890_i 1874_1890 1890 93218.1
c_1874_1890_i 1874 1874_1890 2.08965e-09
r_2434_2450_e 2434 2450 13376.4
r_2434_2450_i 2434_2450 2450 93218.1
c_2434_2450_i 2434 2434_2450 2.08965e-09
r_2994_3010_e 2994 3010 13376.4
r_2994_3010_i 2994_3010 3010 93218.1
c_2994_3010_i 2994 2994_3010 2.08965e-09
r_3554_3570_e 3554 3570 13376.4
r_3554_3570_i 3554_3570 3570 93218.1
c_3554_3570_i 3554 3554_3570 2.08965e-09
r_195_211_e 195 211 13376.4
r_195_211_i 195_211 211 93218.1
c_195_211_i 195 195_211 2.08965e-09
r_755_771_e 755 771 13376.4
r_755_771_i 755_771 771 93218.1
c_755_771_i 755 755_771 2.08965e-09
r_1315_1331_e 1315 1331 836.944
r_1315_1331_i 1315_1331 1331 4256.89
c_1315_1331_i 1315 1315_1331 4.67522e-10
r_1875_1891_e 1875 1891 836.944
r_1875_1891_i 1875_1891 1891 4256.89
c_1875_1891_i 1875 1875_1891 4.67522e-10
r_2435_2451_e 2435 2451 836.944
r_2435_2451_i 2435_2451 2451 4256.89
c_2435_2451_i 2435 2435_2451 4.67522e-10
r_2995_3011_e 2995 3011 836.944
r_2995_3011_i 2995_3011 3011 4256.89
c_2995_3011_i 2995 2995_3011 4.67522e-10
r_3555_3571_e 3555 3571 836.944
r_3555_3571_i 3555_3571 3571 4256.89
c_3555_3571_i 3555 3555_3571 4.67522e-10
r_196_212_e 196 212 13376.4
r_196_212_i 196_212 212 93218.1
c_196_212_i 196 196_212 2.08965e-09
r_756_772_e 756 772 13376.4
r_756_772_i 756_772 772 93218.1
c_756_772_i 756 756_772 2.08965e-09
r_1316_1332_e 1316 1332 836.944
r_1316_1332_i 1316_1332 1332 4256.89
c_1316_1332_i 1316 1316_1332 4.67522e-10
r_1876_1892_e 1876 1892 836.944
r_1876_1892_i 1876_1892 1892 4256.89
c_1876_1892_i 1876 1876_1892 4.67522e-10
r_2436_2452_e 2436 2452 836.944
r_2436_2452_i 2436_2452 2452 4256.89
c_2436_2452_i 2436 2436_2452 4.67522e-10
r_2996_3012_e 2996 3012 13758.3
r_2996_3012_i 2996_3012 3012 95645.6
c_2996_3012_i 2996 2996_3012 9.36084e-12
r_3556_3572_e 3556 3572 13758.3
r_3556_3572_i 3556_3572 3572 95645.6
c_3556_3572_i 3556 3556_3572 9.36084e-12
r_197_213_e 197 213 13376.4
r_197_213_i 197_213 213 93218.1
c_197_213_i 197 197_213 2.08965e-09
r_757_773_e 757 773 13376.4
r_757_773_i 757_773 773 93218.1
c_757_773_i 757 757_773 2.08965e-09
r_1317_1333_e 1317 1333 836.944
r_1317_1333_i 1317_1333 1333 4256.89
c_1317_1333_i 1317 1317_1333 4.67522e-10
r_1877_1893_e 1877 1893 836.944
r_1877_1893_i 1877_1893 1893 4256.89
c_1877_1893_i 1877 1877_1893 4.67522e-10
r_2437_2453_e 2437 2453 836.944
r_2437_2453_i 2437_2453 2453 4256.89
c_2437_2453_i 2437 2437_2453 4.67522e-10
r_2997_3013_e 2997 3013 13758.3
r_2997_3013_i 2997_3013 3013 95645.6
c_2997_3013_i 2997 2997_3013 9.36084e-12
r_3557_3573_e 3557 3573 13758.3
r_3557_3573_i 3557_3573 3573 95645.6
c_3557_3573_i 3557 3557_3573 9.36084e-12
r_198_214_e 198 214 13376.4
r_198_214_i 198_214 214 93218.1
c_198_214_i 198 198_214 2.08965e-09
r_758_774_e 758 774 13376.4
r_758_774_i 758_774 774 93218.1
c_758_774_i 758 758_774 2.08965e-09
r_1318_1334_e 1318 1334 836.944
r_1318_1334_i 1318_1334 1334 4256.89
c_1318_1334_i 1318 1318_1334 4.67522e-10
r_1878_1894_e 1878 1894 836.944
r_1878_1894_i 1878_1894 1894 4256.89
c_1878_1894_i 1878 1878_1894 4.67522e-10
r_2438_2454_e 2438 2454 836.944
r_2438_2454_i 2438_2454 2454 4256.89
c_2438_2454_i 2438 2438_2454 4.67522e-10
r_2998_3014_e 2998 3014 13758.3
r_2998_3014_i 2998_3014 3014 95645.6
c_2998_3014_i 2998 2998_3014 9.36084e-12
r_3558_3574_e 3558 3574 13758.3
r_3558_3574_i 3558_3574 3574 95645.6
c_3558_3574_i 3558 3558_3574 9.36084e-12
r_199_215_e 199 215 13376.4
r_199_215_i 199_215 215 93218.1
c_199_215_i 199 199_215 2.08965e-09
r_759_775_e 759 775 13376.4
r_759_775_i 759_775 775 93218.1
c_759_775_i 759 759_775 2.08965e-09
r_1319_1335_e 1319 1335 836.944
r_1319_1335_i 1319_1335 1335 4256.89
c_1319_1335_i 1319 1319_1335 4.67522e-10
r_1879_1895_e 1879 1895 836.944
r_1879_1895_i 1879_1895 1895 4256.89
c_1879_1895_i 1879 1879_1895 4.67522e-10
r_2439_2455_e 2439 2455 836.944
r_2439_2455_i 2439_2455 2455 4256.89
c_2439_2455_i 2439 2439_2455 4.67522e-10
r_2999_3015_e 2999 3015 13758.3
r_2999_3015_i 2999_3015 3015 95645.6
c_2999_3015_i 2999 2999_3015 9.36084e-12
r_3559_3575_e 3559 3575 13758.3
r_3559_3575_i 3559_3575 3575 95645.6
c_3559_3575_i 3559 3559_3575 9.36084e-12
r_200_216_e 200 216 13376.4
r_200_216_i 200_216 216 93218.1
c_200_216_i 200 200_216 2.08965e-09
r_760_776_e 760 776 13376.4
r_760_776_i 760_776 776 93218.1
c_760_776_i 760 760_776 2.08965e-09
r_1320_1336_e 1320 1336 836.944
r_1320_1336_i 1320_1336 1336 4256.89
c_1320_1336_i 1320 1320_1336 4.67522e-10
r_1880_1896_e 1880 1896 836.944
r_1880_1896_i 1880_1896 1896 4256.89
c_1880_1896_i 1880 1880_1896 4.67522e-10
r_2440_2456_e 2440 2456 836.944
r_2440_2456_i 2440_2456 2456 4256.89
c_2440_2456_i 2440 2440_2456 4.67522e-10
r_3000_3016_e 3000 3016 13758.3
r_3000_3016_i 3000_3016 3016 95645.6
c_3000_3016_i 3000 3000_3016 9.36084e-12
r_3560_3576_e 3560 3576 13758.3
r_3560_3576_i 3560_3576 3576 95645.6
c_3560_3576_i 3560 3560_3576 9.36084e-12
r_201_217_e 201 217 13376.4
r_201_217_i 201_217 217 93218.1
c_201_217_i 201 201_217 2.08965e-09
r_761_777_e 761 777 13376.4
r_761_777_i 761_777 777 93218.1
c_761_777_i 761 761_777 2.08965e-09
r_1321_1337_e 1321 1337 836.944
r_1321_1337_i 1321_1337 1337 4256.89
c_1321_1337_i 1321 1321_1337 4.67522e-10
r_1881_1897_e 1881 1897 836.944
r_1881_1897_i 1881_1897 1897 4256.89
c_1881_1897_i 1881 1881_1897 4.67522e-10
r_2441_2457_e 2441 2457 836.944
r_2441_2457_i 2441_2457 2457 4256.89
c_2441_2457_i 2441 2441_2457 4.67522e-10
r_3001_3017_e 3001 3017 13758.3
r_3001_3017_i 3001_3017 3017 95645.6
c_3001_3017_i 3001 3001_3017 9.36084e-12
r_3561_3577_e 3561 3577 13758.3
r_3561_3577_i 3561_3577 3577 95645.6
c_3561_3577_i 3561 3561_3577 9.36084e-12
r_202_218_e 202 218 13376.4
r_202_218_i 202_218 218 93218.1
c_202_218_i 202 202_218 2.08965e-09
r_762_778_e 762 778 13376.4
r_762_778_i 762_778 778 93218.1
c_762_778_i 762 762_778 2.08965e-09
r_1322_1338_e 1322 1338 836.944
r_1322_1338_i 1322_1338 1338 4256.89
c_1322_1338_i 1322 1322_1338 4.67522e-10
r_1882_1898_e 1882 1898 836.944
r_1882_1898_i 1882_1898 1898 4256.89
c_1882_1898_i 1882 1882_1898 4.67522e-10
r_2442_2458_e 2442 2458 836.944
r_2442_2458_i 2442_2458 2458 4256.89
c_2442_2458_i 2442 2442_2458 4.67522e-10
r_3002_3018_e 3002 3018 13758.3
r_3002_3018_i 3002_3018 3018 95645.6
c_3002_3018_i 3002 3002_3018 9.36084e-12
r_3562_3578_e 3562 3578 13758.3
r_3562_3578_i 3562_3578 3578 95645.6
c_3562_3578_i 3562 3562_3578 9.36084e-12
r_203_219_e 203 219 13376.4
r_203_219_i 203_219 219 93218.1
c_203_219_i 203 203_219 2.08965e-09
r_763_779_e 763 779 13376.4
r_763_779_i 763_779 779 93218.1
c_763_779_i 763 763_779 2.08965e-09
r_1323_1339_e 1323 1339 396.662
r_1323_1339_i 1323_1339 1339 1005.18
c_1323_1339_i 1323 1323_1339 1.6581e-10
r_1883_1899_e 1883 1899 396.662
r_1883_1899_i 1883_1899 1899 1005.18
c_1883_1899_i 1883 1883_1899 1.6581e-10
r_2443_2459_e 2443 2459 836.944
r_2443_2459_i 2443_2459 2459 4256.89
c_2443_2459_i 2443 2443_2459 4.67522e-10
r_3003_3019_e 3003 3019 13758.3
r_3003_3019_i 3003_3019 3019 95645.6
c_3003_3019_i 3003 3003_3019 9.36084e-12
r_3563_3579_e 3563 3579 13758.3
r_3563_3579_i 3563_3579 3579 95645.6
c_3563_3579_i 3563 3563_3579 9.36084e-12
r_204_220_e 204 220 13376.4
r_204_220_i 204_220 220 93218.1
c_204_220_i 204 204_220 2.08965e-09
r_764_780_e 764 780 13376.4
r_764_780_i 764_780 780 93218.1
c_764_780_i 764 764_780 2.08965e-09
r_1324_1340_e 1324 1340 396.662
r_1324_1340_i 1324_1340 1340 1005.18
c_1324_1340_i 1324 1324_1340 1.6581e-10
r_1884_1900_e 1884 1900 396.662
r_1884_1900_i 1884_1900 1900 1005.18
c_1884_1900_i 1884 1884_1900 1.6581e-10
r_2444_2460_e 2444 2460 836.944
r_2444_2460_i 2444_2460 2460 4256.89
c_2444_2460_i 2444 2444_2460 4.67522e-10
r_3004_3020_e 3004 3020 13758.3
r_3004_3020_i 3004_3020 3020 95645.6
c_3004_3020_i 3004 3004_3020 9.36084e-12
r_3564_3580_e 3564 3580 13758.3
r_3564_3580_i 3564_3580 3580 95645.6
c_3564_3580_i 3564 3564_3580 9.36084e-12
r_205_221_e 205 221 13376.4
r_205_221_i 205_221 221 93218.1
c_205_221_i 205 205_221 2.08965e-09
r_765_781_e 765 781 13376.4
r_765_781_i 765_781 781 93218.1
c_765_781_i 765 765_781 2.08965e-09
r_1325_1341_e 1325 1341 836.944
r_1325_1341_i 1325_1341 1341 4256.89
c_1325_1341_i 1325 1325_1341 4.67522e-10
r_1885_1901_e 1885 1901 836.944
r_1885_1901_i 1885_1901 1901 4256.89
c_1885_1901_i 1885 1885_1901 4.67522e-10
r_2445_2461_e 2445 2461 836.944
r_2445_2461_i 2445_2461 2461 4256.89
c_2445_2461_i 2445 2445_2461 4.67522e-10
r_3005_3021_e 3005 3021 13758.3
r_3005_3021_i 3005_3021 3021 95645.6
c_3005_3021_i 3005 3005_3021 9.36084e-12
r_3565_3581_e 3565 3581 13758.3
r_3565_3581_i 3565_3581 3581 95645.6
c_3565_3581_i 3565 3565_3581 9.36084e-12
r_206_222_e 206 222 13376.4
r_206_222_i 206_222 222 93218.1
c_206_222_i 206 206_222 2.08965e-09
r_766_782_e 766 782 13376.4
r_766_782_i 766_782 782 93218.1
c_766_782_i 766 766_782 2.08965e-09
r_1326_1342_e 1326 1342 836.944
r_1326_1342_i 1326_1342 1342 4256.89
c_1326_1342_i 1326 1326_1342 4.67522e-10
r_1886_1902_e 1886 1902 836.944
r_1886_1902_i 1886_1902 1902 4256.89
c_1886_1902_i 1886 1886_1902 4.67522e-10
r_2446_2462_e 2446 2462 836.944
r_2446_2462_i 2446_2462 2462 4256.89
c_2446_2462_i 2446 2446_2462 4.67522e-10
r_3006_3022_e 3006 3022 13758.3
r_3006_3022_i 3006_3022 3022 95645.6
c_3006_3022_i 3006 3006_3022 9.36084e-12
r_3566_3582_e 3566 3582 13758.3
r_3566_3582_i 3566_3582 3582 95645.6
c_3566_3582_i 3566 3566_3582 9.36084e-12
r_207_223_e 207 223 13376.4
r_207_223_i 207_223 223 93218.1
c_207_223_i 207 207_223 2.08965e-09
r_767_783_e 767 783 13376.4
r_767_783_i 767_783 783 93218.1
c_767_783_i 767 767_783 2.08965e-09
r_1327_1343_e 1327 1343 836.944
r_1327_1343_i 1327_1343 1343 4256.89
c_1327_1343_i 1327 1327_1343 4.67522e-10
r_1887_1903_e 1887 1903 836.944
r_1887_1903_i 1887_1903 1903 4256.89
c_1887_1903_i 1887 1887_1903 4.67522e-10
r_2447_2463_e 2447 2463 836.944
r_2447_2463_i 2447_2463 2463 4256.89
c_2447_2463_i 2447 2447_2463 4.67522e-10
r_3007_3023_e 3007 3023 13758.3
r_3007_3023_i 3007_3023 3023 95645.6
c_3007_3023_i 3007 3007_3023 9.36084e-12
r_3567_3583_e 3567 3583 13758.3
r_3567_3583_i 3567_3583 3583 95645.6
c_3567_3583_i 3567 3567_3583 9.36084e-12
r_208_224_e 208 224 13376.4
r_208_224_i 208_224 224 93218.1
c_208_224_i 208 208_224 2.08965e-09
r_768_784_e 768 784 13376.4
r_768_784_i 768_784 784 93218.1
c_768_784_i 768 768_784 2.08965e-09
r_1328_1344_e 1328 1344 836.944
r_1328_1344_i 1328_1344 1344 4256.89
c_1328_1344_i 1328 1328_1344 4.67522e-10
r_1888_1904_e 1888 1904 836.944
r_1888_1904_i 1888_1904 1904 4256.89
c_1888_1904_i 1888 1888_1904 4.67522e-10
r_2448_2464_e 2448 2464 836.944
r_2448_2464_i 2448_2464 2464 4256.89
c_2448_2464_i 2448 2448_2464 4.67522e-10
r_3008_3024_e 3008 3024 13758.3
r_3008_3024_i 3008_3024 3024 95645.6
c_3008_3024_i 3008 3008_3024 9.36084e-12
r_3568_3584_e 3568 3584 13758.3
r_3568_3584_i 3568_3584 3584 95645.6
c_3568_3584_i 3568 3568_3584 9.36084e-12
r_209_225_e 209 225 13376.4
r_209_225_i 209_225 225 93218.1
c_209_225_i 209 209_225 2.08965e-09
r_769_785_e 769 785 13376.4
r_769_785_i 769_785 785 93218.1
c_769_785_i 769 769_785 2.08965e-09
r_1329_1345_e 1329 1345 13376.4
r_1329_1345_i 1329_1345 1345 93218.1
c_1329_1345_i 1329 1329_1345 2.08965e-09
r_1889_1905_e 1889 1905 13376.4
r_1889_1905_i 1889_1905 1905 93218.1
c_1889_1905_i 1889 1889_1905 2.08965e-09
r_2449_2465_e 2449 2465 13376.4
r_2449_2465_i 2449_2465 2465 93218.1
c_2449_2465_i 2449 2449_2465 2.08965e-09
r_3009_3025_e 3009 3025 13376.4
r_3009_3025_i 3009_3025 3025 93218.1
c_3009_3025_i 3009 3009_3025 2.08965e-09
r_3569_3585_e 3569 3585 13376.4
r_3569_3585_i 3569_3585 3585 93218.1
c_3569_3585_i 3569 3569_3585 2.08965e-09
r_210_226_e 210 226 13376.4
r_210_226_i 210_226 226 93218.1
c_210_226_i 210 210_226 2.08965e-09
r_770_786_e 770 786 13376.4
r_770_786_i 770_786 786 93218.1
c_770_786_i 770 770_786 2.08965e-09
r_1330_1346_e 1330 1346 13376.4
r_1330_1346_i 1330_1346 1346 93218.1
c_1330_1346_i 1330 1330_1346 2.08965e-09
r_1890_1906_e 1890 1906 13376.4
r_1890_1906_i 1890_1906 1906 93218.1
c_1890_1906_i 1890 1890_1906 2.08965e-09
r_2450_2466_e 2450 2466 13376.4
r_2450_2466_i 2450_2466 2466 93218.1
c_2450_2466_i 2450 2450_2466 2.08965e-09
r_3010_3026_e 3010 3026 13376.4
r_3010_3026_i 3010_3026 3026 93218.1
c_3010_3026_i 3010 3010_3026 2.08965e-09
r_3570_3586_e 3570 3586 13376.4
r_3570_3586_i 3570_3586 3586 93218.1
c_3570_3586_i 3570 3570_3586 2.08965e-09
r_211_227_e 211 227 13376.4
r_211_227_i 211_227 227 93218.1
c_211_227_i 211 211_227 2.08965e-09
r_771_787_e 771 787 13376.4
r_771_787_i 771_787 787 93218.1
c_771_787_i 771 771_787 2.08965e-09
r_1331_1347_e 1331 1347 836.944
r_1331_1347_i 1331_1347 1347 4256.89
c_1331_1347_i 1331 1331_1347 4.67522e-10
r_1891_1907_e 1891 1907 836.944
r_1891_1907_i 1891_1907 1907 4256.89
c_1891_1907_i 1891 1891_1907 4.67522e-10
r_2451_2467_e 2451 2467 836.944
r_2451_2467_i 2451_2467 2467 4256.89
c_2451_2467_i 2451 2451_2467 4.67522e-10
r_3011_3027_e 3011 3027 836.944
r_3011_3027_i 3011_3027 3027 4256.89
c_3011_3027_i 3011 3011_3027 4.67522e-10
r_3571_3587_e 3571 3587 836.944
r_3571_3587_i 3571_3587 3587 4256.89
c_3571_3587_i 3571 3571_3587 4.67522e-10
r_212_228_e 212 228 13376.4
r_212_228_i 212_228 228 93218.1
c_212_228_i 212 212_228 2.08965e-09
r_772_788_e 772 788 13376.4
r_772_788_i 772_788 788 93218.1
c_772_788_i 772 772_788 2.08965e-09
r_1332_1348_e 1332 1348 836.944
r_1332_1348_i 1332_1348 1348 4256.89
c_1332_1348_i 1332 1332_1348 4.67522e-10
r_1892_1908_e 1892 1908 836.944
r_1892_1908_i 1892_1908 1908 4256.89
c_1892_1908_i 1892 1892_1908 4.67522e-10
r_2452_2468_e 2452 2468 836.944
r_2452_2468_i 2452_2468 2468 4256.89
c_2452_2468_i 2452 2452_2468 4.67522e-10
r_3012_3028_e 3012 3028 13758.3
r_3012_3028_i 3012_3028 3028 95645.6
c_3012_3028_i 3012 3012_3028 9.36084e-12
r_3572_3588_e 3572 3588 13758.3
r_3572_3588_i 3572_3588 3588 95645.6
c_3572_3588_i 3572 3572_3588 9.36084e-12
r_213_229_e 213 229 13376.4
r_213_229_i 213_229 229 93218.1
c_213_229_i 213 213_229 2.08965e-09
r_773_789_e 773 789 13376.4
r_773_789_i 773_789 789 93218.1
c_773_789_i 773 773_789 2.08965e-09
r_1333_1349_e 1333 1349 836.944
r_1333_1349_i 1333_1349 1349 4256.89
c_1333_1349_i 1333 1333_1349 4.67522e-10
r_1893_1909_e 1893 1909 836.944
r_1893_1909_i 1893_1909 1909 4256.89
c_1893_1909_i 1893 1893_1909 4.67522e-10
r_2453_2469_e 2453 2469 836.944
r_2453_2469_i 2453_2469 2469 4256.89
c_2453_2469_i 2453 2453_2469 4.67522e-10
r_3013_3029_e 3013 3029 13758.3
r_3013_3029_i 3013_3029 3029 95645.6
c_3013_3029_i 3013 3013_3029 9.36084e-12
r_3573_3589_e 3573 3589 13758.3
r_3573_3589_i 3573_3589 3589 95645.6
c_3573_3589_i 3573 3573_3589 9.36084e-12
r_214_230_e 214 230 13376.4
r_214_230_i 214_230 230 93218.1
c_214_230_i 214 214_230 2.08965e-09
r_774_790_e 774 790 13376.4
r_774_790_i 774_790 790 93218.1
c_774_790_i 774 774_790 2.08965e-09
r_1334_1350_e 1334 1350 836.944
r_1334_1350_i 1334_1350 1350 4256.89
c_1334_1350_i 1334 1334_1350 4.67522e-10
r_1894_1910_e 1894 1910 836.944
r_1894_1910_i 1894_1910 1910 4256.89
c_1894_1910_i 1894 1894_1910 4.67522e-10
r_2454_2470_e 2454 2470 836.944
r_2454_2470_i 2454_2470 2470 4256.89
c_2454_2470_i 2454 2454_2470 4.67522e-10
r_3014_3030_e 3014 3030 13758.3
r_3014_3030_i 3014_3030 3030 95645.6
c_3014_3030_i 3014 3014_3030 9.36084e-12
r_3574_3590_e 3574 3590 13758.3
r_3574_3590_i 3574_3590 3590 95645.6
c_3574_3590_i 3574 3574_3590 9.36084e-12
r_215_231_e 215 231 13376.4
r_215_231_i 215_231 231 93218.1
c_215_231_i 215 215_231 2.08965e-09
r_775_791_e 775 791 13376.4
r_775_791_i 775_791 791 93218.1
c_775_791_i 775 775_791 2.08965e-09
r_1335_1351_e 1335 1351 836.944
r_1335_1351_i 1335_1351 1351 4256.89
c_1335_1351_i 1335 1335_1351 4.67522e-10
r_1895_1911_e 1895 1911 836.944
r_1895_1911_i 1895_1911 1911 4256.89
c_1895_1911_i 1895 1895_1911 4.67522e-10
r_2455_2471_e 2455 2471 836.944
r_2455_2471_i 2455_2471 2471 4256.89
c_2455_2471_i 2455 2455_2471 4.67522e-10
r_3015_3031_e 3015 3031 13758.3
r_3015_3031_i 3015_3031 3031 95645.6
c_3015_3031_i 3015 3015_3031 9.36084e-12
r_3575_3591_e 3575 3591 13758.3
r_3575_3591_i 3575_3591 3591 95645.6
c_3575_3591_i 3575 3575_3591 9.36084e-12
r_216_232_e 216 232 13376.4
r_216_232_i 216_232 232 93218.1
c_216_232_i 216 216_232 2.08965e-09
r_776_792_e 776 792 13376.4
r_776_792_i 776_792 792 93218.1
c_776_792_i 776 776_792 2.08965e-09
r_1336_1352_e 1336 1352 836.944
r_1336_1352_i 1336_1352 1352 4256.89
c_1336_1352_i 1336 1336_1352 4.67522e-10
r_1896_1912_e 1896 1912 836.944
r_1896_1912_i 1896_1912 1912 4256.89
c_1896_1912_i 1896 1896_1912 4.67522e-10
r_2456_2472_e 2456 2472 836.944
r_2456_2472_i 2456_2472 2472 4256.89
c_2456_2472_i 2456 2456_2472 4.67522e-10
r_3016_3032_e 3016 3032 13758.3
r_3016_3032_i 3016_3032 3032 95645.6
c_3016_3032_i 3016 3016_3032 9.36084e-12
r_3576_3592_e 3576 3592 13758.3
r_3576_3592_i 3576_3592 3592 95645.6
c_3576_3592_i 3576 3576_3592 9.36084e-12
r_217_233_e 217 233 13376.4
r_217_233_i 217_233 233 93218.1
c_217_233_i 217 217_233 2.08965e-09
r_777_793_e 777 793 13376.4
r_777_793_i 777_793 793 93218.1
c_777_793_i 777 777_793 2.08965e-09
r_1337_1353_e 1337 1353 836.944
r_1337_1353_i 1337_1353 1353 4256.89
c_1337_1353_i 1337 1337_1353 4.67522e-10
r_1897_1913_e 1897 1913 836.944
r_1897_1913_i 1897_1913 1913 4256.89
c_1897_1913_i 1897 1897_1913 4.67522e-10
r_2457_2473_e 2457 2473 836.944
r_2457_2473_i 2457_2473 2473 4256.89
c_2457_2473_i 2457 2457_2473 4.67522e-10
r_3017_3033_e 3017 3033 13758.3
r_3017_3033_i 3017_3033 3033 95645.6
c_3017_3033_i 3017 3017_3033 9.36084e-12
r_3577_3593_e 3577 3593 13758.3
r_3577_3593_i 3577_3593 3593 95645.6
c_3577_3593_i 3577 3577_3593 9.36084e-12
r_218_234_e 218 234 13376.4
r_218_234_i 218_234 234 93218.1
c_218_234_i 218 218_234 2.08965e-09
r_778_794_e 778 794 13376.4
r_778_794_i 778_794 794 93218.1
c_778_794_i 778 778_794 2.08965e-09
r_1338_1354_e 1338 1354 836.944
r_1338_1354_i 1338_1354 1354 4256.89
c_1338_1354_i 1338 1338_1354 4.67522e-10
r_1898_1914_e 1898 1914 836.944
r_1898_1914_i 1898_1914 1914 4256.89
c_1898_1914_i 1898 1898_1914 4.67522e-10
r_2458_2474_e 2458 2474 836.944
r_2458_2474_i 2458_2474 2474 4256.89
c_2458_2474_i 2458 2458_2474 4.67522e-10
r_3018_3034_e 3018 3034 13758.3
r_3018_3034_i 3018_3034 3034 95645.6
c_3018_3034_i 3018 3018_3034 9.36084e-12
r_3578_3594_e 3578 3594 13758.3
r_3578_3594_i 3578_3594 3594 95645.6
c_3578_3594_i 3578 3578_3594 9.36084e-12
r_219_235_e 219 235 13376.4
r_219_235_i 219_235 235 93218.1
c_219_235_i 219 219_235 2.08965e-09
r_779_795_e 779 795 13376.4
r_779_795_i 779_795 795 93218.1
c_779_795_i 779 779_795 2.08965e-09
r_1339_1355_e 1339 1355 396.654
r_1339_1355_i 1339_1355 1355 1005.16
c_1339_1355_i 1339 1339_1355 1.65814e-10
r_1899_1915_e 1899 1915 396.654
r_1899_1915_i 1899_1915 1915 1005.16
c_1899_1915_i 1899 1899_1915 1.65814e-10
r_2459_2475_e 2459 2475 836.944
r_2459_2475_i 2459_2475 2475 4256.89
c_2459_2475_i 2459 2459_2475 4.67522e-10
r_3019_3035_e 3019 3035 13758.3
r_3019_3035_i 3019_3035 3035 95645.6
c_3019_3035_i 3019 3019_3035 9.36084e-12
r_3579_3595_e 3579 3595 13758.3
r_3579_3595_i 3579_3595 3595 95645.6
c_3579_3595_i 3579 3579_3595 9.36084e-12
r_220_236_e 220 236 13376.4
r_220_236_i 220_236 236 93218.1
c_220_236_i 220 220_236 2.08965e-09
r_780_796_e 780 796 13376.4
r_780_796_i 780_796 796 93218.1
c_780_796_i 780 780_796 2.08965e-09
r_1340_1356_e 1340 1356 396.654
r_1340_1356_i 1340_1356 1356 1005.16
c_1340_1356_i 1340 1340_1356 1.65814e-10
r_1900_1916_e 1900 1916 396.654
r_1900_1916_i 1900_1916 1916 1005.16
c_1900_1916_i 1900 1900_1916 1.65814e-10
r_2460_2476_e 2460 2476 836.944
r_2460_2476_i 2460_2476 2476 4256.89
c_2460_2476_i 2460 2460_2476 4.67522e-10
r_3020_3036_e 3020 3036 13758.3
r_3020_3036_i 3020_3036 3036 95645.6
c_3020_3036_i 3020 3020_3036 9.36084e-12
r_3580_3596_e 3580 3596 13758.3
r_3580_3596_i 3580_3596 3596 95645.6
c_3580_3596_i 3580 3580_3596 9.36084e-12
r_221_237_e 221 237 13376.4
r_221_237_i 221_237 237 93218.1
c_221_237_i 221 221_237 2.08965e-09
r_781_797_e 781 797 13376.4
r_781_797_i 781_797 797 93218.1
c_781_797_i 781 781_797 2.08965e-09
r_1341_1357_e 1341 1357 836.944
r_1341_1357_i 1341_1357 1357 4256.89
c_1341_1357_i 1341 1341_1357 4.67522e-10
r_1901_1917_e 1901 1917 836.944
r_1901_1917_i 1901_1917 1917 4256.89
c_1901_1917_i 1901 1901_1917 4.67522e-10
r_2461_2477_e 2461 2477 836.944
r_2461_2477_i 2461_2477 2477 4256.89
c_2461_2477_i 2461 2461_2477 4.67522e-10
r_3021_3037_e 3021 3037 13758.3
r_3021_3037_i 3021_3037 3037 95645.6
c_3021_3037_i 3021 3021_3037 9.36084e-12
r_3581_3597_e 3581 3597 13758.3
r_3581_3597_i 3581_3597 3597 95645.6
c_3581_3597_i 3581 3581_3597 9.36084e-12
r_222_238_e 222 238 13376.4
r_222_238_i 222_238 238 93218.1
c_222_238_i 222 222_238 2.08965e-09
r_782_798_e 782 798 13376.4
r_782_798_i 782_798 798 93218.1
c_782_798_i 782 782_798 2.08965e-09
r_1342_1358_e 1342 1358 836.944
r_1342_1358_i 1342_1358 1358 4256.89
c_1342_1358_i 1342 1342_1358 4.67522e-10
r_1902_1918_e 1902 1918 836.944
r_1902_1918_i 1902_1918 1918 4256.89
c_1902_1918_i 1902 1902_1918 4.67522e-10
r_2462_2478_e 2462 2478 836.944
r_2462_2478_i 2462_2478 2478 4256.89
c_2462_2478_i 2462 2462_2478 4.67522e-10
r_3022_3038_e 3022 3038 13758.3
r_3022_3038_i 3022_3038 3038 95645.6
c_3022_3038_i 3022 3022_3038 9.36084e-12
r_3582_3598_e 3582 3598 13758.3
r_3582_3598_i 3582_3598 3598 95645.6
c_3582_3598_i 3582 3582_3598 9.36084e-12
r_223_239_e 223 239 13376.4
r_223_239_i 223_239 239 93218.1
c_223_239_i 223 223_239 2.08965e-09
r_783_799_e 783 799 13376.4
r_783_799_i 783_799 799 93218.1
c_783_799_i 783 783_799 2.08965e-09
r_1343_1359_e 1343 1359 836.944
r_1343_1359_i 1343_1359 1359 4256.89
c_1343_1359_i 1343 1343_1359 4.67522e-10
r_1903_1919_e 1903 1919 836.944
r_1903_1919_i 1903_1919 1919 4256.89
c_1903_1919_i 1903 1903_1919 4.67522e-10
r_2463_2479_e 2463 2479 836.944
r_2463_2479_i 2463_2479 2479 4256.89
c_2463_2479_i 2463 2463_2479 4.67522e-10
r_3023_3039_e 3023 3039 13758.3
r_3023_3039_i 3023_3039 3039 95645.6
c_3023_3039_i 3023 3023_3039 9.36084e-12
r_3583_3599_e 3583 3599 13758.3
r_3583_3599_i 3583_3599 3599 95645.6
c_3583_3599_i 3583 3583_3599 9.36084e-12
r_224_240_e 224 240 13376.4
r_224_240_i 224_240 240 93218.1
c_224_240_i 224 224_240 2.08965e-09
r_784_800_e 784 800 13376.4
r_784_800_i 784_800 800 93218.1
c_784_800_i 784 784_800 2.08965e-09
r_1344_1360_e 1344 1360 836.944
r_1344_1360_i 1344_1360 1360 4256.89
c_1344_1360_i 1344 1344_1360 4.67522e-10
r_1904_1920_e 1904 1920 836.944
r_1904_1920_i 1904_1920 1920 4256.89
c_1904_1920_i 1904 1904_1920 4.67522e-10
r_2464_2480_e 2464 2480 836.944
r_2464_2480_i 2464_2480 2480 4256.89
c_2464_2480_i 2464 2464_2480 4.67522e-10
r_3024_3040_e 3024 3040 13758.3
r_3024_3040_i 3024_3040 3040 95645.6
c_3024_3040_i 3024 3024_3040 9.36084e-12
r_3584_3600_e 3584 3600 13758.3
r_3584_3600_i 3584_3600 3600 95645.6
c_3584_3600_i 3584 3584_3600 9.36084e-12
r_225_241_e 225 241 13376.4
r_225_241_i 225_241 241 93218.1
c_225_241_i 225 225_241 2.08965e-09
r_785_801_e 785 801 13376.4
r_785_801_i 785_801 801 93218.1
c_785_801_i 785 785_801 2.08965e-09
r_1345_1361_e 1345 1361 13376.4
r_1345_1361_i 1345_1361 1361 93218.1
c_1345_1361_i 1345 1345_1361 2.08965e-09
r_1905_1921_e 1905 1921 13376.4
r_1905_1921_i 1905_1921 1921 93218.1
c_1905_1921_i 1905 1905_1921 2.08965e-09
r_2465_2481_e 2465 2481 13376.4
r_2465_2481_i 2465_2481 2481 93218.1
c_2465_2481_i 2465 2465_2481 2.08965e-09
r_3025_3041_e 3025 3041 13376.4
r_3025_3041_i 3025_3041 3041 93218.1
c_3025_3041_i 3025 3025_3041 2.08965e-09
r_3585_3601_e 3585 3601 13376.4
r_3585_3601_i 3585_3601 3601 93218.1
c_3585_3601_i 3585 3585_3601 2.08965e-09
r_226_242_e 226 242 13376.4
r_226_242_i 226_242 242 93218.1
c_226_242_i 226 226_242 2.08965e-09
r_786_802_e 786 802 13376.4
r_786_802_i 786_802 802 93218.1
c_786_802_i 786 786_802 2.08965e-09
r_1346_1362_e 1346 1362 13376.4
r_1346_1362_i 1346_1362 1362 93218.1
c_1346_1362_i 1346 1346_1362 2.08965e-09
r_1906_1922_e 1906 1922 13376.4
r_1906_1922_i 1906_1922 1922 93218.1
c_1906_1922_i 1906 1906_1922 2.08965e-09
r_2466_2482_e 2466 2482 13376.4
r_2466_2482_i 2466_2482 2482 93218.1
c_2466_2482_i 2466 2466_2482 2.08965e-09
r_3026_3042_e 3026 3042 13376.4
r_3026_3042_i 3026_3042 3042 93218.1
c_3026_3042_i 3026 3026_3042 2.08965e-09
r_3586_3602_e 3586 3602 13376.4
r_3586_3602_i 3586_3602 3602 93218.1
c_3586_3602_i 3586 3586_3602 2.08965e-09
r_227_243_e 227 243 13376.4
r_227_243_i 227_243 243 93218.1
c_227_243_i 227 227_243 2.08965e-09
r_787_803_e 787 803 13376.4
r_787_803_i 787_803 803 93218.1
c_787_803_i 787 787_803 2.08965e-09
r_1347_1363_e 1347 1363 836.944
r_1347_1363_i 1347_1363 1363 4256.89
c_1347_1363_i 1347 1347_1363 4.67522e-10
r_1907_1923_e 1907 1923 836.944
r_1907_1923_i 1907_1923 1923 4256.89
c_1907_1923_i 1907 1907_1923 4.67522e-10
r_2467_2483_e 2467 2483 836.944
r_2467_2483_i 2467_2483 2483 4256.89
c_2467_2483_i 2467 2467_2483 4.67522e-10
r_3027_3043_e 3027 3043 836.944
r_3027_3043_i 3027_3043 3043 4256.89
c_3027_3043_i 3027 3027_3043 4.67522e-10
r_3587_3603_e 3587 3603 836.944
r_3587_3603_i 3587_3603 3603 4256.89
c_3587_3603_i 3587 3587_3603 4.67522e-10
r_228_244_e 228 244 13376.4
r_228_244_i 228_244 244 93218.1
c_228_244_i 228 228_244 2.08965e-09
r_788_804_e 788 804 13376.4
r_788_804_i 788_804 804 93218.1
c_788_804_i 788 788_804 2.08965e-09
r_1348_1364_e 1348 1364 836.944
r_1348_1364_i 1348_1364 1364 4256.89
c_1348_1364_i 1348 1348_1364 4.67522e-10
r_1908_1924_e 1908 1924 836.944
r_1908_1924_i 1908_1924 1924 4256.89
c_1908_1924_i 1908 1908_1924 4.67522e-10
r_2468_2484_e 2468 2484 836.944
r_2468_2484_i 2468_2484 2484 4256.89
c_2468_2484_i 2468 2468_2484 4.67522e-10
r_3028_3044_e 3028 3044 13758.3
r_3028_3044_i 3028_3044 3044 95645.6
c_3028_3044_i 3028 3028_3044 9.36084e-12
r_3588_3604_e 3588 3604 13758.3
r_3588_3604_i 3588_3604 3604 95645.6
c_3588_3604_i 3588 3588_3604 9.36084e-12
r_229_245_e 229 245 13376.4
r_229_245_i 229_245 245 93218.1
c_229_245_i 229 229_245 2.08965e-09
r_789_805_e 789 805 13376.4
r_789_805_i 789_805 805 93218.1
c_789_805_i 789 789_805 2.08965e-09
r_1349_1365_e 1349 1365 836.944
r_1349_1365_i 1349_1365 1365 4256.89
c_1349_1365_i 1349 1349_1365 4.67522e-10
r_1909_1925_e 1909 1925 836.944
r_1909_1925_i 1909_1925 1925 4256.89
c_1909_1925_i 1909 1909_1925 4.67522e-10
r_2469_2485_e 2469 2485 836.944
r_2469_2485_i 2469_2485 2485 4256.89
c_2469_2485_i 2469 2469_2485 4.67522e-10
r_3029_3045_e 3029 3045 13758.3
r_3029_3045_i 3029_3045 3045 95645.6
c_3029_3045_i 3029 3029_3045 9.36084e-12
r_3589_3605_e 3589 3605 13758.3
r_3589_3605_i 3589_3605 3605 95645.6
c_3589_3605_i 3589 3589_3605 9.36084e-12
r_230_246_e 230 246 13376.4
r_230_246_i 230_246 246 93218.1
c_230_246_i 230 230_246 2.08965e-09
r_790_806_e 790 806 13376.4
r_790_806_i 790_806 806 93218.1
c_790_806_i 790 790_806 2.08965e-09
r_1350_1366_e 1350 1366 836.944
r_1350_1366_i 1350_1366 1366 4256.89
c_1350_1366_i 1350 1350_1366 4.67522e-10
r_1910_1926_e 1910 1926 836.944
r_1910_1926_i 1910_1926 1926 4256.89
c_1910_1926_i 1910 1910_1926 4.67522e-10
r_2470_2486_e 2470 2486 836.944
r_2470_2486_i 2470_2486 2486 4256.89
c_2470_2486_i 2470 2470_2486 4.67522e-10
r_3030_3046_e 3030 3046 13758.3
r_3030_3046_i 3030_3046 3046 95645.6
c_3030_3046_i 3030 3030_3046 9.36084e-12
r_3590_3606_e 3590 3606 13758.3
r_3590_3606_i 3590_3606 3606 95645.6
c_3590_3606_i 3590 3590_3606 9.36084e-12
r_231_247_e 231 247 13376.4
r_231_247_i 231_247 247 93218.1
c_231_247_i 231 231_247 2.08965e-09
r_791_807_e 791 807 13376.4
r_791_807_i 791_807 807 93218.1
c_791_807_i 791 791_807 2.08965e-09
r_1351_1367_e 1351 1367 836.944
r_1351_1367_i 1351_1367 1367 4256.89
c_1351_1367_i 1351 1351_1367 4.67522e-10
r_1911_1927_e 1911 1927 836.944
r_1911_1927_i 1911_1927 1927 4256.89
c_1911_1927_i 1911 1911_1927 4.67522e-10
r_2471_2487_e 2471 2487 836.944
r_2471_2487_i 2471_2487 2487 4256.89
c_2471_2487_i 2471 2471_2487 4.67522e-10
r_3031_3047_e 3031 3047 13758.3
r_3031_3047_i 3031_3047 3047 95645.6
c_3031_3047_i 3031 3031_3047 9.36084e-12
r_3591_3607_e 3591 3607 13758.3
r_3591_3607_i 3591_3607 3607 95645.6
c_3591_3607_i 3591 3591_3607 9.36084e-12
r_232_248_e 232 248 13376.4
r_232_248_i 232_248 248 93218.1
c_232_248_i 232 232_248 2.08965e-09
r_792_808_e 792 808 13376.4
r_792_808_i 792_808 808 93218.1
c_792_808_i 792 792_808 2.08965e-09
r_1352_1368_e 1352 1368 836.944
r_1352_1368_i 1352_1368 1368 4256.89
c_1352_1368_i 1352 1352_1368 4.67522e-10
r_1912_1928_e 1912 1928 836.944
r_1912_1928_i 1912_1928 1928 4256.89
c_1912_1928_i 1912 1912_1928 4.67522e-10
r_2472_2488_e 2472 2488 836.944
r_2472_2488_i 2472_2488 2488 4256.89
c_2472_2488_i 2472 2472_2488 4.67522e-10
r_3032_3048_e 3032 3048 13758.3
r_3032_3048_i 3032_3048 3048 95645.6
c_3032_3048_i 3032 3032_3048 9.36084e-12
r_3592_3608_e 3592 3608 13758.3
r_3592_3608_i 3592_3608 3608 95645.6
c_3592_3608_i 3592 3592_3608 9.36084e-12
r_233_249_e 233 249 13376.4
r_233_249_i 233_249 249 93218.1
c_233_249_i 233 233_249 2.08965e-09
r_793_809_e 793 809 13376.4
r_793_809_i 793_809 809 93218.1
c_793_809_i 793 793_809 2.08965e-09
r_1353_1369_e 1353 1369 836.944
r_1353_1369_i 1353_1369 1369 4256.89
c_1353_1369_i 1353 1353_1369 4.67522e-10
r_1913_1929_e 1913 1929 836.944
r_1913_1929_i 1913_1929 1929 4256.89
c_1913_1929_i 1913 1913_1929 4.67522e-10
r_2473_2489_e 2473 2489 836.944
r_2473_2489_i 2473_2489 2489 4256.89
c_2473_2489_i 2473 2473_2489 4.67522e-10
r_3033_3049_e 3033 3049 13758.3
r_3033_3049_i 3033_3049 3049 95645.6
c_3033_3049_i 3033 3033_3049 9.36084e-12
r_3593_3609_e 3593 3609 13758.3
r_3593_3609_i 3593_3609 3609 95645.6
c_3593_3609_i 3593 3593_3609 9.36084e-12
r_234_250_e 234 250 13376.4
r_234_250_i 234_250 250 93218.1
c_234_250_i 234 234_250 2.08965e-09
r_794_810_e 794 810 13376.4
r_794_810_i 794_810 810 93218.1
c_794_810_i 794 794_810 2.08965e-09
r_1354_1370_e 1354 1370 836.944
r_1354_1370_i 1354_1370 1370 4256.89
c_1354_1370_i 1354 1354_1370 4.67522e-10
r_1914_1930_e 1914 1930 836.944
r_1914_1930_i 1914_1930 1930 4256.89
c_1914_1930_i 1914 1914_1930 4.67522e-10
r_2474_2490_e 2474 2490 836.944
r_2474_2490_i 2474_2490 2490 4256.89
c_2474_2490_i 2474 2474_2490 4.67522e-10
r_3034_3050_e 3034 3050 13758.3
r_3034_3050_i 3034_3050 3050 95645.6
c_3034_3050_i 3034 3034_3050 9.36084e-12
r_3594_3610_e 3594 3610 13758.3
r_3594_3610_i 3594_3610 3610 95645.6
c_3594_3610_i 3594 3594_3610 9.36084e-12
r_235_251_e 235 251 13376.4
r_235_251_i 235_251 251 93218.1
c_235_251_i 235 235_251 2.08965e-09
r_795_811_e 795 811 13376.4
r_795_811_i 795_811 811 93218.1
c_795_811_i 795 795_811 2.08965e-09
r_1355_1371_e 1355 1371 396.645
r_1355_1371_i 1355_1371 1371 1005.14
c_1355_1371_i 1355 1355_1371 1.65817e-10
r_1915_1931_e 1915 1931 396.645
r_1915_1931_i 1915_1931 1931 1005.14
c_1915_1931_i 1915 1915_1931 1.65817e-10
r_2475_2491_e 2475 2491 836.944
r_2475_2491_i 2475_2491 2491 4256.89
c_2475_2491_i 2475 2475_2491 4.67522e-10
r_3035_3051_e 3035 3051 13758.3
r_3035_3051_i 3035_3051 3051 95645.6
c_3035_3051_i 3035 3035_3051 9.36084e-12
r_3595_3611_e 3595 3611 13758.3
r_3595_3611_i 3595_3611 3611 95645.6
c_3595_3611_i 3595 3595_3611 9.36084e-12
r_236_252_e 236 252 13376.4
r_236_252_i 236_252 252 93218.1
c_236_252_i 236 236_252 2.08965e-09
r_796_812_e 796 812 13376.4
r_796_812_i 796_812 812 93218.1
c_796_812_i 796 796_812 2.08965e-09
r_1356_1372_e 1356 1372 396.645
r_1356_1372_i 1356_1372 1372 1005.14
c_1356_1372_i 1356 1356_1372 1.65817e-10
r_1916_1932_e 1916 1932 396.645
r_1916_1932_i 1916_1932 1932 1005.14
c_1916_1932_i 1916 1916_1932 1.65817e-10
r_2476_2492_e 2476 2492 836.944
r_2476_2492_i 2476_2492 2492 4256.89
c_2476_2492_i 2476 2476_2492 4.67522e-10
r_3036_3052_e 3036 3052 13758.3
r_3036_3052_i 3036_3052 3052 95645.6
c_3036_3052_i 3036 3036_3052 9.36084e-12
r_3596_3612_e 3596 3612 13758.3
r_3596_3612_i 3596_3612 3612 95645.6
c_3596_3612_i 3596 3596_3612 9.36084e-12
r_237_253_e 237 253 13376.4
r_237_253_i 237_253 253 93218.1
c_237_253_i 237 237_253 2.08965e-09
r_797_813_e 797 813 13376.4
r_797_813_i 797_813 813 93218.1
c_797_813_i 797 797_813 2.08965e-09
r_1357_1373_e 1357 1373 836.944
r_1357_1373_i 1357_1373 1373 4256.89
c_1357_1373_i 1357 1357_1373 4.67522e-10
r_1917_1933_e 1917 1933 836.944
r_1917_1933_i 1917_1933 1933 4256.89
c_1917_1933_i 1917 1917_1933 4.67522e-10
r_2477_2493_e 2477 2493 836.944
r_2477_2493_i 2477_2493 2493 4256.89
c_2477_2493_i 2477 2477_2493 4.67522e-10
r_3037_3053_e 3037 3053 13758.3
r_3037_3053_i 3037_3053 3053 95645.6
c_3037_3053_i 3037 3037_3053 9.36084e-12
r_3597_3613_e 3597 3613 13758.3
r_3597_3613_i 3597_3613 3613 95645.6
c_3597_3613_i 3597 3597_3613 9.36084e-12
r_238_254_e 238 254 13376.4
r_238_254_i 238_254 254 93218.1
c_238_254_i 238 238_254 2.08965e-09
r_798_814_e 798 814 13376.4
r_798_814_i 798_814 814 93218.1
c_798_814_i 798 798_814 2.08965e-09
r_1358_1374_e 1358 1374 836.944
r_1358_1374_i 1358_1374 1374 4256.89
c_1358_1374_i 1358 1358_1374 4.67522e-10
r_1918_1934_e 1918 1934 836.944
r_1918_1934_i 1918_1934 1934 4256.89
c_1918_1934_i 1918 1918_1934 4.67522e-10
r_2478_2494_e 2478 2494 836.944
r_2478_2494_i 2478_2494 2494 4256.89
c_2478_2494_i 2478 2478_2494 4.67522e-10
r_3038_3054_e 3038 3054 13758.3
r_3038_3054_i 3038_3054 3054 95645.6
c_3038_3054_i 3038 3038_3054 9.36084e-12
r_3598_3614_e 3598 3614 13758.3
r_3598_3614_i 3598_3614 3614 95645.6
c_3598_3614_i 3598 3598_3614 9.36084e-12
r_239_255_e 239 255 13376.4
r_239_255_i 239_255 255 93218.1
c_239_255_i 239 239_255 2.08965e-09
r_799_815_e 799 815 13376.4
r_799_815_i 799_815 815 93218.1
c_799_815_i 799 799_815 2.08965e-09
r_1359_1375_e 1359 1375 836.944
r_1359_1375_i 1359_1375 1375 4256.89
c_1359_1375_i 1359 1359_1375 4.67522e-10
r_1919_1935_e 1919 1935 836.944
r_1919_1935_i 1919_1935 1935 4256.89
c_1919_1935_i 1919 1919_1935 4.67522e-10
r_2479_2495_e 2479 2495 836.944
r_2479_2495_i 2479_2495 2495 4256.89
c_2479_2495_i 2479 2479_2495 4.67522e-10
r_3039_3055_e 3039 3055 13758.3
r_3039_3055_i 3039_3055 3055 95645.6
c_3039_3055_i 3039 3039_3055 9.36084e-12
r_3599_3615_e 3599 3615 13758.3
r_3599_3615_i 3599_3615 3615 95645.6
c_3599_3615_i 3599 3599_3615 9.36084e-12
r_240_256_e 240 256 13376.4
r_240_256_i 240_256 256 93218.1
c_240_256_i 240 240_256 2.08965e-09
r_800_816_e 800 816 13376.4
r_800_816_i 800_816 816 93218.1
c_800_816_i 800 800_816 2.08965e-09
r_1360_1376_e 1360 1376 836.944
r_1360_1376_i 1360_1376 1376 4256.89
c_1360_1376_i 1360 1360_1376 4.67522e-10
r_1920_1936_e 1920 1936 836.944
r_1920_1936_i 1920_1936 1936 4256.89
c_1920_1936_i 1920 1920_1936 4.67522e-10
r_2480_2496_e 2480 2496 836.944
r_2480_2496_i 2480_2496 2496 4256.89
c_2480_2496_i 2480 2480_2496 4.67522e-10
r_3040_3056_e 3040 3056 13758.3
r_3040_3056_i 3040_3056 3056 95645.6
c_3040_3056_i 3040 3040_3056 9.36084e-12
r_3600_3616_e 3600 3616 13758.3
r_3600_3616_i 3600_3616 3616 95645.6
c_3600_3616_i 3600 3600_3616 9.36084e-12
r_241_257_e 241 257 13376.4
r_241_257_i 241_257 257 93218.1
c_241_257_i 241 241_257 2.08965e-09
r_801_817_e 801 817 13376.4
r_801_817_i 801_817 817 93218.1
c_801_817_i 801 801_817 2.08965e-09
r_1361_1377_e 1361 1377 13376.4
r_1361_1377_i 1361_1377 1377 93218.1
c_1361_1377_i 1361 1361_1377 2.08965e-09
r_1921_1937_e 1921 1937 13376.4
r_1921_1937_i 1921_1937 1937 93218.1
c_1921_1937_i 1921 1921_1937 2.08965e-09
r_2481_2497_e 2481 2497 13376.4
r_2481_2497_i 2481_2497 2497 93218.1
c_2481_2497_i 2481 2481_2497 2.08965e-09
r_3041_3057_e 3041 3057 13376.4
r_3041_3057_i 3041_3057 3057 93218.1
c_3041_3057_i 3041 3041_3057 2.08965e-09
r_3601_3617_e 3601 3617 13376.4
r_3601_3617_i 3601_3617 3617 93218.1
c_3601_3617_i 3601 3601_3617 2.08965e-09
r_242_258_e 242 258 13376.4
r_242_258_i 242_258 258 93218.1
c_242_258_i 242 242_258 2.08965e-09
r_802_818_e 802 818 13376.4
r_802_818_i 802_818 818 93218.1
c_802_818_i 802 802_818 2.08965e-09
r_1362_1378_e 1362 1378 13376.4
r_1362_1378_i 1362_1378 1378 93218.1
c_1362_1378_i 1362 1362_1378 2.08965e-09
r_1922_1938_e 1922 1938 13376.4
r_1922_1938_i 1922_1938 1938 93218.1
c_1922_1938_i 1922 1922_1938 2.08965e-09
r_2482_2498_e 2482 2498 13376.4
r_2482_2498_i 2482_2498 2498 93218.1
c_2482_2498_i 2482 2482_2498 2.08965e-09
r_3042_3058_e 3042 3058 13376.4
r_3042_3058_i 3042_3058 3058 93218.1
c_3042_3058_i 3042 3042_3058 2.08965e-09
r_3602_3618_e 3602 3618 13376.4
r_3602_3618_i 3602_3618 3618 93218.1
c_3602_3618_i 3602 3602_3618 2.08965e-09
r_243_259_e 243 259 13376.4
r_243_259_i 243_259 259 93218.1
c_243_259_i 243 243_259 2.08965e-09
r_803_819_e 803 819 13376.4
r_803_819_i 803_819 819 93218.1
c_803_819_i 803 803_819 2.08965e-09
r_1363_1379_e 1363 1379 836.944
r_1363_1379_i 1363_1379 1379 4256.89
c_1363_1379_i 1363 1363_1379 4.67522e-10
r_1923_1939_e 1923 1939 836.944
r_1923_1939_i 1923_1939 1939 4256.89
c_1923_1939_i 1923 1923_1939 4.67522e-10
r_2483_2499_e 2483 2499 836.944
r_2483_2499_i 2483_2499 2499 4256.89
c_2483_2499_i 2483 2483_2499 4.67522e-10
r_3043_3059_e 3043 3059 836.944
r_3043_3059_i 3043_3059 3059 4256.89
c_3043_3059_i 3043 3043_3059 4.67522e-10
r_3603_3619_e 3603 3619 836.944
r_3603_3619_i 3603_3619 3619 4256.89
c_3603_3619_i 3603 3603_3619 4.67522e-10
r_244_260_e 244 260 13376.4
r_244_260_i 244_260 260 93218.1
c_244_260_i 244 244_260 2.08965e-09
r_804_820_e 804 820 13376.4
r_804_820_i 804_820 820 93218.1
c_804_820_i 804 804_820 2.08965e-09
r_1364_1380_e 1364 1380 836.944
r_1364_1380_i 1364_1380 1380 4256.89
c_1364_1380_i 1364 1364_1380 4.67522e-10
r_1924_1940_e 1924 1940 836.944
r_1924_1940_i 1924_1940 1940 4256.89
c_1924_1940_i 1924 1924_1940 4.67522e-10
r_2484_2500_e 2484 2500 836.944
r_2484_2500_i 2484_2500 2500 4256.89
c_2484_2500_i 2484 2484_2500 4.67522e-10
r_3044_3060_e 3044 3060 13758.3
r_3044_3060_i 3044_3060 3060 95645.6
c_3044_3060_i 3044 3044_3060 9.36084e-12
r_3604_3620_e 3604 3620 13758.3
r_3604_3620_i 3604_3620 3620 95645.6
c_3604_3620_i 3604 3604_3620 9.36084e-12
r_245_261_e 245 261 13376.4
r_245_261_i 245_261 261 93218.1
c_245_261_i 245 245_261 2.08965e-09
r_805_821_e 805 821 13376.4
r_805_821_i 805_821 821 93218.1
c_805_821_i 805 805_821 2.08965e-09
r_1365_1381_e 1365 1381 836.944
r_1365_1381_i 1365_1381 1381 4256.89
c_1365_1381_i 1365 1365_1381 4.67522e-10
r_1925_1941_e 1925 1941 836.944
r_1925_1941_i 1925_1941 1941 4256.89
c_1925_1941_i 1925 1925_1941 4.67522e-10
r_2485_2501_e 2485 2501 836.944
r_2485_2501_i 2485_2501 2501 4256.89
c_2485_2501_i 2485 2485_2501 4.67522e-10
r_3045_3061_e 3045 3061 13758.3
r_3045_3061_i 3045_3061 3061 95645.6
c_3045_3061_i 3045 3045_3061 9.36084e-12
r_3605_3621_e 3605 3621 13758.3
r_3605_3621_i 3605_3621 3621 95645.6
c_3605_3621_i 3605 3605_3621 9.36084e-12
r_246_262_e 246 262 13376.4
r_246_262_i 246_262 262 93218.1
c_246_262_i 246 246_262 2.08965e-09
r_806_822_e 806 822 13376.4
r_806_822_i 806_822 822 93218.1
c_806_822_i 806 806_822 2.08965e-09
r_1366_1382_e 1366 1382 836.944
r_1366_1382_i 1366_1382 1382 4256.89
c_1366_1382_i 1366 1366_1382 4.67522e-10
r_1926_1942_e 1926 1942 836.944
r_1926_1942_i 1926_1942 1942 4256.89
c_1926_1942_i 1926 1926_1942 4.67522e-10
r_2486_2502_e 2486 2502 836.944
r_2486_2502_i 2486_2502 2502 4256.89
c_2486_2502_i 2486 2486_2502 4.67522e-10
r_3046_3062_e 3046 3062 13758.3
r_3046_3062_i 3046_3062 3062 95645.6
c_3046_3062_i 3046 3046_3062 9.36084e-12
r_3606_3622_e 3606 3622 13758.3
r_3606_3622_i 3606_3622 3622 95645.6
c_3606_3622_i 3606 3606_3622 9.36084e-12
r_247_263_e 247 263 13376.4
r_247_263_i 247_263 263 93218.1
c_247_263_i 247 247_263 2.08965e-09
r_807_823_e 807 823 13376.4
r_807_823_i 807_823 823 93218.1
c_807_823_i 807 807_823 2.08965e-09
r_1367_1383_e 1367 1383 836.944
r_1367_1383_i 1367_1383 1383 4256.89
c_1367_1383_i 1367 1367_1383 4.67522e-10
r_1927_1943_e 1927 1943 836.944
r_1927_1943_i 1927_1943 1943 4256.89
c_1927_1943_i 1927 1927_1943 4.67522e-10
r_2487_2503_e 2487 2503 836.944
r_2487_2503_i 2487_2503 2503 4256.89
c_2487_2503_i 2487 2487_2503 4.67522e-10
r_3047_3063_e 3047 3063 13758.3
r_3047_3063_i 3047_3063 3063 95645.6
c_3047_3063_i 3047 3047_3063 9.36084e-12
r_3607_3623_e 3607 3623 13758.3
r_3607_3623_i 3607_3623 3623 95645.6
c_3607_3623_i 3607 3607_3623 9.36084e-12
r_248_264_e 248 264 13376.4
r_248_264_i 248_264 264 93218.1
c_248_264_i 248 248_264 2.08965e-09
r_808_824_e 808 824 13376.4
r_808_824_i 808_824 824 93218.1
c_808_824_i 808 808_824 2.08965e-09
r_1368_1384_e 1368 1384 836.944
r_1368_1384_i 1368_1384 1384 4256.89
c_1368_1384_i 1368 1368_1384 4.67522e-10
r_1928_1944_e 1928 1944 836.944
r_1928_1944_i 1928_1944 1944 4256.89
c_1928_1944_i 1928 1928_1944 4.67522e-10
r_2488_2504_e 2488 2504 836.944
r_2488_2504_i 2488_2504 2504 4256.89
c_2488_2504_i 2488 2488_2504 4.67522e-10
r_3048_3064_e 3048 3064 13758.3
r_3048_3064_i 3048_3064 3064 95645.6
c_3048_3064_i 3048 3048_3064 9.36084e-12
r_3608_3624_e 3608 3624 13758.3
r_3608_3624_i 3608_3624 3624 95645.6
c_3608_3624_i 3608 3608_3624 9.36084e-12
r_249_265_e 249 265 13376.4
r_249_265_i 249_265 265 93218.1
c_249_265_i 249 249_265 2.08965e-09
r_809_825_e 809 825 13376.4
r_809_825_i 809_825 825 93218.1
c_809_825_i 809 809_825 2.08965e-09
r_1369_1385_e 1369 1385 836.944
r_1369_1385_i 1369_1385 1385 4256.89
c_1369_1385_i 1369 1369_1385 4.67522e-10
r_1929_1945_e 1929 1945 836.944
r_1929_1945_i 1929_1945 1945 4256.89
c_1929_1945_i 1929 1929_1945 4.67522e-10
r_2489_2505_e 2489 2505 836.944
r_2489_2505_i 2489_2505 2505 4256.89
c_2489_2505_i 2489 2489_2505 4.67522e-10
r_3049_3065_e 3049 3065 13758.3
r_3049_3065_i 3049_3065 3065 95645.6
c_3049_3065_i 3049 3049_3065 9.36084e-12
r_3609_3625_e 3609 3625 13758.3
r_3609_3625_i 3609_3625 3625 95645.6
c_3609_3625_i 3609 3609_3625 9.36084e-12
r_250_266_e 250 266 13376.4
r_250_266_i 250_266 266 93218.1
c_250_266_i 250 250_266 2.08965e-09
r_810_826_e 810 826 13376.4
r_810_826_i 810_826 826 93218.1
c_810_826_i 810 810_826 2.08965e-09
r_1370_1386_e 1370 1386 836.944
r_1370_1386_i 1370_1386 1386 4256.89
c_1370_1386_i 1370 1370_1386 4.67522e-10
r_1930_1946_e 1930 1946 836.944
r_1930_1946_i 1930_1946 1946 4256.89
c_1930_1946_i 1930 1930_1946 4.67522e-10
r_2490_2506_e 2490 2506 836.944
r_2490_2506_i 2490_2506 2506 4256.89
c_2490_2506_i 2490 2490_2506 4.67522e-10
r_3050_3066_e 3050 3066 13758.3
r_3050_3066_i 3050_3066 3066 95645.6
c_3050_3066_i 3050 3050_3066 9.36084e-12
r_3610_3626_e 3610 3626 13758.3
r_3610_3626_i 3610_3626 3626 95645.6
c_3610_3626_i 3610 3610_3626 9.36084e-12
r_251_267_e 251 267 13376.4
r_251_267_i 251_267 267 93218.1
c_251_267_i 251 251_267 2.08965e-09
r_811_827_e 811 827 13376.4
r_811_827_i 811_827 827 93218.1
c_811_827_i 811 811_827 2.08965e-09
r_1371_1387_e 1371 1387 396.636
r_1371_1387_i 1371_1387 1387 1005.11
c_1371_1387_i 1371 1371_1387 1.65821e-10
r_1931_1947_e 1931 1947 396.636
r_1931_1947_i 1931_1947 1947 1005.11
c_1931_1947_i 1931 1931_1947 1.65821e-10
r_2491_2507_e 2491 2507 836.944
r_2491_2507_i 2491_2507 2507 4256.89
c_2491_2507_i 2491 2491_2507 4.67522e-10
r_3051_3067_e 3051 3067 13758.3
r_3051_3067_i 3051_3067 3067 95645.6
c_3051_3067_i 3051 3051_3067 9.36084e-12
r_3611_3627_e 3611 3627 13758.3
r_3611_3627_i 3611_3627 3627 95645.6
c_3611_3627_i 3611 3611_3627 9.36084e-12
r_252_268_e 252 268 13376.4
r_252_268_i 252_268 268 93218.1
c_252_268_i 252 252_268 2.08965e-09
r_812_828_e 812 828 13376.4
r_812_828_i 812_828 828 93218.1
c_812_828_i 812 812_828 2.08965e-09
r_1372_1388_e 1372 1388 396.636
r_1372_1388_i 1372_1388 1388 1005.11
c_1372_1388_i 1372 1372_1388 1.65821e-10
r_1932_1948_e 1932 1948 396.636
r_1932_1948_i 1932_1948 1948 1005.11
c_1932_1948_i 1932 1932_1948 1.65821e-10
r_2492_2508_e 2492 2508 836.944
r_2492_2508_i 2492_2508 2508 4256.89
c_2492_2508_i 2492 2492_2508 4.67522e-10
r_3052_3068_e 3052 3068 13758.3
r_3052_3068_i 3052_3068 3068 95645.6
c_3052_3068_i 3052 3052_3068 9.36084e-12
r_3612_3628_e 3612 3628 13758.3
r_3612_3628_i 3612_3628 3628 95645.6
c_3612_3628_i 3612 3612_3628 9.36084e-12
r_253_269_e 253 269 13376.4
r_253_269_i 253_269 269 93218.1
c_253_269_i 253 253_269 2.08965e-09
r_813_829_e 813 829 13376.4
r_813_829_i 813_829 829 93218.1
c_813_829_i 813 813_829 2.08965e-09
r_1373_1389_e 1373 1389 836.944
r_1373_1389_i 1373_1389 1389 4256.89
c_1373_1389_i 1373 1373_1389 4.67522e-10
r_1933_1949_e 1933 1949 836.944
r_1933_1949_i 1933_1949 1949 4256.89
c_1933_1949_i 1933 1933_1949 4.67522e-10
r_2493_2509_e 2493 2509 836.944
r_2493_2509_i 2493_2509 2509 4256.89
c_2493_2509_i 2493 2493_2509 4.67522e-10
r_3053_3069_e 3053 3069 13758.3
r_3053_3069_i 3053_3069 3069 95645.6
c_3053_3069_i 3053 3053_3069 9.36084e-12
r_3613_3629_e 3613 3629 13758.3
r_3613_3629_i 3613_3629 3629 95645.6
c_3613_3629_i 3613 3613_3629 9.36084e-12
r_254_270_e 254 270 13376.4
r_254_270_i 254_270 270 93218.1
c_254_270_i 254 254_270 2.08965e-09
r_814_830_e 814 830 13376.4
r_814_830_i 814_830 830 93218.1
c_814_830_i 814 814_830 2.08965e-09
r_1374_1390_e 1374 1390 836.944
r_1374_1390_i 1374_1390 1390 4256.89
c_1374_1390_i 1374 1374_1390 4.67522e-10
r_1934_1950_e 1934 1950 836.944
r_1934_1950_i 1934_1950 1950 4256.89
c_1934_1950_i 1934 1934_1950 4.67522e-10
r_2494_2510_e 2494 2510 836.944
r_2494_2510_i 2494_2510 2510 4256.89
c_2494_2510_i 2494 2494_2510 4.67522e-10
r_3054_3070_e 3054 3070 13758.3
r_3054_3070_i 3054_3070 3070 95645.6
c_3054_3070_i 3054 3054_3070 9.36084e-12
r_3614_3630_e 3614 3630 13758.3
r_3614_3630_i 3614_3630 3630 95645.6
c_3614_3630_i 3614 3614_3630 9.36084e-12
r_255_271_e 255 271 13376.4
r_255_271_i 255_271 271 93218.1
c_255_271_i 255 255_271 2.08965e-09
r_815_831_e 815 831 13376.4
r_815_831_i 815_831 831 93218.1
c_815_831_i 815 815_831 2.08965e-09
r_1375_1391_e 1375 1391 836.944
r_1375_1391_i 1375_1391 1391 4256.89
c_1375_1391_i 1375 1375_1391 4.67522e-10
r_1935_1951_e 1935 1951 836.944
r_1935_1951_i 1935_1951 1951 4256.89
c_1935_1951_i 1935 1935_1951 4.67522e-10
r_2495_2511_e 2495 2511 836.944
r_2495_2511_i 2495_2511 2511 4256.89
c_2495_2511_i 2495 2495_2511 4.67522e-10
r_3055_3071_e 3055 3071 13758.3
r_3055_3071_i 3055_3071 3071 95645.6
c_3055_3071_i 3055 3055_3071 9.36084e-12
r_3615_3631_e 3615 3631 13758.3
r_3615_3631_i 3615_3631 3631 95645.6
c_3615_3631_i 3615 3615_3631 9.36084e-12
r_256_272_e 256 272 13376.4
r_256_272_i 256_272 272 93218.1
c_256_272_i 256 256_272 2.08965e-09
r_816_832_e 816 832 13376.4
r_816_832_i 816_832 832 93218.1
c_816_832_i 816 816_832 2.08965e-09
r_1376_1392_e 1376 1392 836.944
r_1376_1392_i 1376_1392 1392 4256.89
c_1376_1392_i 1376 1376_1392 4.67522e-10
r_1936_1952_e 1936 1952 836.944
r_1936_1952_i 1936_1952 1952 4256.89
c_1936_1952_i 1936 1936_1952 4.67522e-10
r_2496_2512_e 2496 2512 836.944
r_2496_2512_i 2496_2512 2512 4256.89
c_2496_2512_i 2496 2496_2512 4.67522e-10
r_3056_3072_e 3056 3072 13758.3
r_3056_3072_i 3056_3072 3072 95645.6
c_3056_3072_i 3056 3056_3072 9.36084e-12
r_3616_3632_e 3616 3632 13758.3
r_3616_3632_i 3616_3632 3632 95645.6
c_3616_3632_i 3616 3616_3632 9.36084e-12
r_257_273_e 257 273 13376.4
r_257_273_i 257_273 273 93218.1
c_257_273_i 257 257_273 2.08965e-09
r_817_833_e 817 833 13376.4
r_817_833_i 817_833 833 93218.1
c_817_833_i 817 817_833 2.08965e-09
r_1377_1393_e 1377 1393 13376.4
r_1377_1393_i 1377_1393 1393 93218.1
c_1377_1393_i 1377 1377_1393 2.08965e-09
r_1937_1953_e 1937 1953 13376.4
r_1937_1953_i 1937_1953 1953 93218.1
c_1937_1953_i 1937 1937_1953 2.08965e-09
r_2497_2513_e 2497 2513 13376.4
r_2497_2513_i 2497_2513 2513 93218.1
c_2497_2513_i 2497 2497_2513 2.08965e-09
r_3057_3073_e 3057 3073 13376.4
r_3057_3073_i 3057_3073 3073 93218.1
c_3057_3073_i 3057 3057_3073 2.08965e-09
r_3617_3633_e 3617 3633 13376.4
r_3617_3633_i 3617_3633 3633 93218.1
c_3617_3633_i 3617 3617_3633 2.08965e-09
r_258_274_e 258 274 13376.4
r_258_274_i 258_274 274 93218.1
c_258_274_i 258 258_274 2.08965e-09
r_818_834_e 818 834 13376.4
r_818_834_i 818_834 834 93218.1
c_818_834_i 818 818_834 2.08965e-09
r_1378_1394_e 1378 1394 13376.4
r_1378_1394_i 1378_1394 1394 93218.1
c_1378_1394_i 1378 1378_1394 2.08965e-09
r_1938_1954_e 1938 1954 13376.4
r_1938_1954_i 1938_1954 1954 93218.1
c_1938_1954_i 1938 1938_1954 2.08965e-09
r_2498_2514_e 2498 2514 13376.4
r_2498_2514_i 2498_2514 2514 93218.1
c_2498_2514_i 2498 2498_2514 2.08965e-09
r_3058_3074_e 3058 3074 13376.4
r_3058_3074_i 3058_3074 3074 93218.1
c_3058_3074_i 3058 3058_3074 2.08965e-09
r_3618_3634_e 3618 3634 13376.4
r_3618_3634_i 3618_3634 3634 93218.1
c_3618_3634_i 3618 3618_3634 2.08965e-09
r_259_275_e 259 275 13376.4
r_259_275_i 259_275 275 93218.1
c_259_275_i 259 259_275 2.08965e-09
r_819_835_e 819 835 13376.4
r_819_835_i 819_835 835 93218.1
c_819_835_i 819 819_835 2.08965e-09
r_1379_1395_e 1379 1395 836.944
r_1379_1395_i 1379_1395 1395 4256.89
c_1379_1395_i 1379 1379_1395 4.67522e-10
r_1939_1955_e 1939 1955 836.944
r_1939_1955_i 1939_1955 1955 4256.89
c_1939_1955_i 1939 1939_1955 4.67522e-10
r_2499_2515_e 2499 2515 836.944
r_2499_2515_i 2499_2515 2515 4256.89
c_2499_2515_i 2499 2499_2515 4.67522e-10
r_3059_3075_e 3059 3075 836.944
r_3059_3075_i 3059_3075 3075 4256.89
c_3059_3075_i 3059 3059_3075 4.67522e-10
r_3619_3635_e 3619 3635 836.944
r_3619_3635_i 3619_3635 3635 4256.89
c_3619_3635_i 3619 3619_3635 4.67522e-10
r_260_276_e 260 276 13376.4
r_260_276_i 260_276 276 93218.1
c_260_276_i 260 260_276 2.08965e-09
r_820_836_e 820 836 13376.4
r_820_836_i 820_836 836 93218.1
c_820_836_i 820 820_836 2.08965e-09
r_1380_1396_e 1380 1396 836.944
r_1380_1396_i 1380_1396 1396 4256.89
c_1380_1396_i 1380 1380_1396 4.67522e-10
r_1940_1956_e 1940 1956 836.944
r_1940_1956_i 1940_1956 1956 4256.89
c_1940_1956_i 1940 1940_1956 4.67522e-10
r_2500_2516_e 2500 2516 836.944
r_2500_2516_i 2500_2516 2516 4256.89
c_2500_2516_i 2500 2500_2516 4.67522e-10
r_3060_3076_e 3060 3076 13758.3
r_3060_3076_i 3060_3076 3076 95645.6
c_3060_3076_i 3060 3060_3076 9.36084e-12
r_3620_3636_e 3620 3636 13758.3
r_3620_3636_i 3620_3636 3636 95645.6
c_3620_3636_i 3620 3620_3636 9.36084e-12
r_261_277_e 261 277 13376.4
r_261_277_i 261_277 277 93218.1
c_261_277_i 261 261_277 2.08965e-09
r_821_837_e 821 837 13376.4
r_821_837_i 821_837 837 93218.1
c_821_837_i 821 821_837 2.08965e-09
r_1381_1397_e 1381 1397 836.944
r_1381_1397_i 1381_1397 1397 4256.89
c_1381_1397_i 1381 1381_1397 4.67522e-10
r_1941_1957_e 1941 1957 836.944
r_1941_1957_i 1941_1957 1957 4256.89
c_1941_1957_i 1941 1941_1957 4.67522e-10
r_2501_2517_e 2501 2517 836.944
r_2501_2517_i 2501_2517 2517 4256.89
c_2501_2517_i 2501 2501_2517 4.67522e-10
r_3061_3077_e 3061 3077 13758.3
r_3061_3077_i 3061_3077 3077 95645.6
c_3061_3077_i 3061 3061_3077 9.36084e-12
r_3621_3637_e 3621 3637 13758.3
r_3621_3637_i 3621_3637 3637 95645.6
c_3621_3637_i 3621 3621_3637 9.36084e-12
r_262_278_e 262 278 13376.4
r_262_278_i 262_278 278 93218.1
c_262_278_i 262 262_278 2.08965e-09
r_822_838_e 822 838 13376.4
r_822_838_i 822_838 838 93218.1
c_822_838_i 822 822_838 2.08965e-09
r_1382_1398_e 1382 1398 836.944
r_1382_1398_i 1382_1398 1398 4256.89
c_1382_1398_i 1382 1382_1398 4.67522e-10
r_1942_1958_e 1942 1958 836.944
r_1942_1958_i 1942_1958 1958 4256.89
c_1942_1958_i 1942 1942_1958 4.67522e-10
r_2502_2518_e 2502 2518 836.944
r_2502_2518_i 2502_2518 2518 4256.89
c_2502_2518_i 2502 2502_2518 4.67522e-10
r_3062_3078_e 3062 3078 13758.3
r_3062_3078_i 3062_3078 3078 95645.6
c_3062_3078_i 3062 3062_3078 9.36084e-12
r_3622_3638_e 3622 3638 13758.3
r_3622_3638_i 3622_3638 3638 95645.6
c_3622_3638_i 3622 3622_3638 9.36084e-12
r_263_279_e 263 279 13376.4
r_263_279_i 263_279 279 93218.1
c_263_279_i 263 263_279 2.08965e-09
r_823_839_e 823 839 13376.4
r_823_839_i 823_839 839 93218.1
c_823_839_i 823 823_839 2.08965e-09
r_1383_1399_e 1383 1399 836.944
r_1383_1399_i 1383_1399 1399 4256.89
c_1383_1399_i 1383 1383_1399 4.67522e-10
r_1943_1959_e 1943 1959 836.944
r_1943_1959_i 1943_1959 1959 4256.89
c_1943_1959_i 1943 1943_1959 4.67522e-10
r_2503_2519_e 2503 2519 836.944
r_2503_2519_i 2503_2519 2519 4256.89
c_2503_2519_i 2503 2503_2519 4.67522e-10
r_3063_3079_e 3063 3079 13758.3
r_3063_3079_i 3063_3079 3079 95645.6
c_3063_3079_i 3063 3063_3079 9.36084e-12
r_3623_3639_e 3623 3639 13758.3
r_3623_3639_i 3623_3639 3639 95645.6
c_3623_3639_i 3623 3623_3639 9.36084e-12
r_264_280_e 264 280 13376.4
r_264_280_i 264_280 280 93218.1
c_264_280_i 264 264_280 2.08965e-09
r_824_840_e 824 840 13376.4
r_824_840_i 824_840 840 93218.1
c_824_840_i 824 824_840 2.08965e-09
r_1384_1400_e 1384 1400 836.944
r_1384_1400_i 1384_1400 1400 4256.89
c_1384_1400_i 1384 1384_1400 4.67522e-10
r_1944_1960_e 1944 1960 836.944
r_1944_1960_i 1944_1960 1960 4256.89
c_1944_1960_i 1944 1944_1960 4.67522e-10
r_2504_2520_e 2504 2520 836.944
r_2504_2520_i 2504_2520 2520 4256.89
c_2504_2520_i 2504 2504_2520 4.67522e-10
r_3064_3080_e 3064 3080 13758.3
r_3064_3080_i 3064_3080 3080 95645.6
c_3064_3080_i 3064 3064_3080 9.36084e-12
r_3624_3640_e 3624 3640 13758.3
r_3624_3640_i 3624_3640 3640 95645.6
c_3624_3640_i 3624 3624_3640 9.36084e-12
r_265_281_e 265 281 13376.4
r_265_281_i 265_281 281 93218.1
c_265_281_i 265 265_281 2.08965e-09
r_825_841_e 825 841 13376.4
r_825_841_i 825_841 841 93218.1
c_825_841_i 825 825_841 2.08965e-09
r_1385_1401_e 1385 1401 836.944
r_1385_1401_i 1385_1401 1401 4256.89
c_1385_1401_i 1385 1385_1401 4.67522e-10
r_1945_1961_e 1945 1961 836.944
r_1945_1961_i 1945_1961 1961 4256.89
c_1945_1961_i 1945 1945_1961 4.67522e-10
r_2505_2521_e 2505 2521 836.944
r_2505_2521_i 2505_2521 2521 4256.89
c_2505_2521_i 2505 2505_2521 4.67522e-10
r_3065_3081_e 3065 3081 13758.3
r_3065_3081_i 3065_3081 3081 95645.6
c_3065_3081_i 3065 3065_3081 9.36084e-12
r_3625_3641_e 3625 3641 13758.3
r_3625_3641_i 3625_3641 3641 95645.6
c_3625_3641_i 3625 3625_3641 9.36084e-12
r_266_282_e 266 282 13376.4
r_266_282_i 266_282 282 93218.1
c_266_282_i 266 266_282 2.08965e-09
r_826_842_e 826 842 13376.4
r_826_842_i 826_842 842 93218.1
c_826_842_i 826 826_842 2.08965e-09
r_1386_1402_e 1386 1402 836.944
r_1386_1402_i 1386_1402 1402 4256.89
c_1386_1402_i 1386 1386_1402 4.67522e-10
r_1946_1962_e 1946 1962 836.944
r_1946_1962_i 1946_1962 1962 4256.89
c_1946_1962_i 1946 1946_1962 4.67522e-10
r_2506_2522_e 2506 2522 836.944
r_2506_2522_i 2506_2522 2522 4256.89
c_2506_2522_i 2506 2506_2522 4.67522e-10
r_3066_3082_e 3066 3082 13758.3
r_3066_3082_i 3066_3082 3082 95645.6
c_3066_3082_i 3066 3066_3082 9.36084e-12
r_3626_3642_e 3626 3642 13758.3
r_3626_3642_i 3626_3642 3642 95645.6
c_3626_3642_i 3626 3626_3642 9.36084e-12
r_267_283_e 267 283 13376.4
r_267_283_i 267_283 283 93218.1
c_267_283_i 267 267_283 2.08965e-09
r_827_843_e 827 843 13376.4
r_827_843_i 827_843 843 93218.1
c_827_843_i 827 827_843 2.08965e-09
r_1387_1403_e 1387 1403 396.628
r_1387_1403_i 1387_1403 1403 1005.09
c_1387_1403_i 1387 1387_1403 1.65824e-10
r_1947_1963_e 1947 1963 396.628
r_1947_1963_i 1947_1963 1963 1005.09
c_1947_1963_i 1947 1947_1963 1.65824e-10
r_2507_2523_e 2507 2523 836.944
r_2507_2523_i 2507_2523 2523 4256.89
c_2507_2523_i 2507 2507_2523 4.67522e-10
r_3067_3083_e 3067 3083 13758.3
r_3067_3083_i 3067_3083 3083 95645.6
c_3067_3083_i 3067 3067_3083 9.36084e-12
r_3627_3643_e 3627 3643 13758.3
r_3627_3643_i 3627_3643 3643 95645.6
c_3627_3643_i 3627 3627_3643 9.36084e-12
r_268_284_e 268 284 13376.4
r_268_284_i 268_284 284 93218.1
c_268_284_i 268 268_284 2.08965e-09
r_828_844_e 828 844 13376.4
r_828_844_i 828_844 844 93218.1
c_828_844_i 828 828_844 2.08965e-09
r_1388_1404_e 1388 1404 396.628
r_1388_1404_i 1388_1404 1404 1005.09
c_1388_1404_i 1388 1388_1404 1.65824e-10
r_1948_1964_e 1948 1964 396.628
r_1948_1964_i 1948_1964 1964 1005.09
c_1948_1964_i 1948 1948_1964 1.65824e-10
r_2508_2524_e 2508 2524 836.944
r_2508_2524_i 2508_2524 2524 4256.89
c_2508_2524_i 2508 2508_2524 4.67522e-10
r_3068_3084_e 3068 3084 13758.3
r_3068_3084_i 3068_3084 3084 95645.6
c_3068_3084_i 3068 3068_3084 9.36084e-12
r_3628_3644_e 3628 3644 13758.3
r_3628_3644_i 3628_3644 3644 95645.6
c_3628_3644_i 3628 3628_3644 9.36084e-12
r_269_285_e 269 285 13376.4
r_269_285_i 269_285 285 93218.1
c_269_285_i 269 269_285 2.08965e-09
r_829_845_e 829 845 13376.4
r_829_845_i 829_845 845 93218.1
c_829_845_i 829 829_845 2.08965e-09
r_1389_1405_e 1389 1405 836.944
r_1389_1405_i 1389_1405 1405 4256.89
c_1389_1405_i 1389 1389_1405 4.67522e-10
r_1949_1965_e 1949 1965 836.944
r_1949_1965_i 1949_1965 1965 4256.89
c_1949_1965_i 1949 1949_1965 4.67522e-10
r_2509_2525_e 2509 2525 836.944
r_2509_2525_i 2509_2525 2525 4256.89
c_2509_2525_i 2509 2509_2525 4.67522e-10
r_3069_3085_e 3069 3085 13758.3
r_3069_3085_i 3069_3085 3085 95645.6
c_3069_3085_i 3069 3069_3085 9.36084e-12
r_3629_3645_e 3629 3645 13758.3
r_3629_3645_i 3629_3645 3645 95645.6
c_3629_3645_i 3629 3629_3645 9.36084e-12
r_270_286_e 270 286 13376.4
r_270_286_i 270_286 286 93218.1
c_270_286_i 270 270_286 2.08965e-09
r_830_846_e 830 846 13376.4
r_830_846_i 830_846 846 93218.1
c_830_846_i 830 830_846 2.08965e-09
r_1390_1406_e 1390 1406 836.944
r_1390_1406_i 1390_1406 1406 4256.89
c_1390_1406_i 1390 1390_1406 4.67522e-10
r_1950_1966_e 1950 1966 836.944
r_1950_1966_i 1950_1966 1966 4256.89
c_1950_1966_i 1950 1950_1966 4.67522e-10
r_2510_2526_e 2510 2526 836.944
r_2510_2526_i 2510_2526 2526 4256.89
c_2510_2526_i 2510 2510_2526 4.67522e-10
r_3070_3086_e 3070 3086 13758.3
r_3070_3086_i 3070_3086 3086 95645.6
c_3070_3086_i 3070 3070_3086 9.36084e-12
r_3630_3646_e 3630 3646 13758.3
r_3630_3646_i 3630_3646 3646 95645.6
c_3630_3646_i 3630 3630_3646 9.36084e-12
r_271_287_e 271 287 13376.4
r_271_287_i 271_287 287 93218.1
c_271_287_i 271 271_287 2.08965e-09
r_831_847_e 831 847 13376.4
r_831_847_i 831_847 847 93218.1
c_831_847_i 831 831_847 2.08965e-09
r_1391_1407_e 1391 1407 836.944
r_1391_1407_i 1391_1407 1407 4256.89
c_1391_1407_i 1391 1391_1407 4.67522e-10
r_1951_1967_e 1951 1967 836.944
r_1951_1967_i 1951_1967 1967 4256.89
c_1951_1967_i 1951 1951_1967 4.67522e-10
r_2511_2527_e 2511 2527 836.944
r_2511_2527_i 2511_2527 2527 4256.89
c_2511_2527_i 2511 2511_2527 4.67522e-10
r_3071_3087_e 3071 3087 13758.3
r_3071_3087_i 3071_3087 3087 95645.6
c_3071_3087_i 3071 3071_3087 9.36084e-12
r_3631_3647_e 3631 3647 13758.3
r_3631_3647_i 3631_3647 3647 95645.6
c_3631_3647_i 3631 3631_3647 9.36084e-12
r_272_288_e 272 288 13376.4
r_272_288_i 272_288 288 93218.1
c_272_288_i 272 272_288 2.08965e-09
r_832_848_e 832 848 13376.4
r_832_848_i 832_848 848 93218.1
c_832_848_i 832 832_848 2.08965e-09
r_1392_1408_e 1392 1408 836.944
r_1392_1408_i 1392_1408 1408 4256.89
c_1392_1408_i 1392 1392_1408 4.67522e-10
r_1952_1968_e 1952 1968 836.944
r_1952_1968_i 1952_1968 1968 4256.89
c_1952_1968_i 1952 1952_1968 4.67522e-10
r_2512_2528_e 2512 2528 836.944
r_2512_2528_i 2512_2528 2528 4256.89
c_2512_2528_i 2512 2512_2528 4.67522e-10
r_3072_3088_e 3072 3088 13758.3
r_3072_3088_i 3072_3088 3088 95645.6
c_3072_3088_i 3072 3072_3088 9.36084e-12
r_3632_3648_e 3632 3648 13758.3
r_3632_3648_i 3632_3648 3648 95645.6
c_3632_3648_i 3632 3632_3648 9.36084e-12
r_273_289_e 273 289 13376.4
r_273_289_i 273_289 289 93218.1
c_273_289_i 273 273_289 2.08965e-09
r_833_849_e 833 849 13376.4
r_833_849_i 833_849 849 93218.1
c_833_849_i 833 833_849 2.08965e-09
r_1393_1409_e 1393 1409 13376.4
r_1393_1409_i 1393_1409 1409 93218.1
c_1393_1409_i 1393 1393_1409 2.08965e-09
r_1953_1969_e 1953 1969 13376.4
r_1953_1969_i 1953_1969 1969 93218.1
c_1953_1969_i 1953 1953_1969 2.08965e-09
r_2513_2529_e 2513 2529 13376.4
r_2513_2529_i 2513_2529 2529 93218.1
c_2513_2529_i 2513 2513_2529 2.08965e-09
r_3073_3089_e 3073 3089 13376.4
r_3073_3089_i 3073_3089 3089 93218.1
c_3073_3089_i 3073 3073_3089 2.08965e-09
r_3633_3649_e 3633 3649 13376.4
r_3633_3649_i 3633_3649 3649 93218.1
c_3633_3649_i 3633 3633_3649 2.08965e-09
r_274_290_e 274 290 13376.4
r_274_290_i 274_290 290 93218.1
c_274_290_i 274 274_290 2.08965e-09
r_834_850_e 834 850 13376.4
r_834_850_i 834_850 850 93218.1
c_834_850_i 834 834_850 2.08965e-09
r_1394_1410_e 1394 1410 13376.4
r_1394_1410_i 1394_1410 1410 93218.1
c_1394_1410_i 1394 1394_1410 2.08965e-09
r_1954_1970_e 1954 1970 13376.4
r_1954_1970_i 1954_1970 1970 93218.1
c_1954_1970_i 1954 1954_1970 2.08965e-09
r_2514_2530_e 2514 2530 13376.4
r_2514_2530_i 2514_2530 2530 93218.1
c_2514_2530_i 2514 2514_2530 2.08965e-09
r_3074_3090_e 3074 3090 13376.4
r_3074_3090_i 3074_3090 3090 93218.1
c_3074_3090_i 3074 3074_3090 2.08965e-09
r_3634_3650_e 3634 3650 13376.4
r_3634_3650_i 3634_3650 3650 93218.1
c_3634_3650_i 3634 3634_3650 2.08965e-09
r_275_291_e 275 291 13376.4
r_275_291_i 275_291 291 93218.1
c_275_291_i 275 275_291 2.08965e-09
r_835_851_e 835 851 13376.4
r_835_851_i 835_851 851 93218.1
c_835_851_i 835 835_851 2.08965e-09
r_1395_1411_e 1395 1411 836.944
r_1395_1411_i 1395_1411 1411 4256.89
c_1395_1411_i 1395 1395_1411 4.67522e-10
r_1955_1971_e 1955 1971 836.944
r_1955_1971_i 1955_1971 1971 4256.89
c_1955_1971_i 1955 1955_1971 4.67522e-10
r_2515_2531_e 2515 2531 836.944
r_2515_2531_i 2515_2531 2531 4256.89
c_2515_2531_i 2515 2515_2531 4.67522e-10
r_3075_3091_e 3075 3091 836.944
r_3075_3091_i 3075_3091 3091 4256.89
c_3075_3091_i 3075 3075_3091 4.67522e-10
r_3635_3651_e 3635 3651 836.944
r_3635_3651_i 3635_3651 3651 4256.89
c_3635_3651_i 3635 3635_3651 4.67522e-10
r_276_292_e 276 292 13376.4
r_276_292_i 276_292 292 93218.1
c_276_292_i 276 276_292 2.08965e-09
r_836_852_e 836 852 13376.4
r_836_852_i 836_852 852 93218.1
c_836_852_i 836 836_852 2.08965e-09
r_1396_1412_e 1396 1412 836.944
r_1396_1412_i 1396_1412 1412 4256.89
c_1396_1412_i 1396 1396_1412 4.67522e-10
r_1956_1972_e 1956 1972 836.944
r_1956_1972_i 1956_1972 1972 4256.89
c_1956_1972_i 1956 1956_1972 4.67522e-10
r_2516_2532_e 2516 2532 836.944
r_2516_2532_i 2516_2532 2532 4256.89
c_2516_2532_i 2516 2516_2532 4.67522e-10
r_3076_3092_e 3076 3092 13758.3
r_3076_3092_i 3076_3092 3092 95645.6
c_3076_3092_i 3076 3076_3092 9.36084e-12
r_3636_3652_e 3636 3652 13758.3
r_3636_3652_i 3636_3652 3652 95645.6
c_3636_3652_i 3636 3636_3652 9.36084e-12
r_277_293_e 277 293 13376.4
r_277_293_i 277_293 293 93218.1
c_277_293_i 277 277_293 2.08965e-09
r_837_853_e 837 853 13376.4
r_837_853_i 837_853 853 93218.1
c_837_853_i 837 837_853 2.08965e-09
r_1397_1413_e 1397 1413 836.944
r_1397_1413_i 1397_1413 1413 4256.89
c_1397_1413_i 1397 1397_1413 4.67522e-10
r_1957_1973_e 1957 1973 836.944
r_1957_1973_i 1957_1973 1973 4256.89
c_1957_1973_i 1957 1957_1973 4.67522e-10
r_2517_2533_e 2517 2533 836.944
r_2517_2533_i 2517_2533 2533 4256.89
c_2517_2533_i 2517 2517_2533 4.67522e-10
r_3077_3093_e 3077 3093 13758.3
r_3077_3093_i 3077_3093 3093 95645.6
c_3077_3093_i 3077 3077_3093 9.36084e-12
r_3637_3653_e 3637 3653 13758.3
r_3637_3653_i 3637_3653 3653 95645.6
c_3637_3653_i 3637 3637_3653 9.36084e-12
r_278_294_e 278 294 13376.4
r_278_294_i 278_294 294 93218.1
c_278_294_i 278 278_294 2.08965e-09
r_838_854_e 838 854 13376.4
r_838_854_i 838_854 854 93218.1
c_838_854_i 838 838_854 2.08965e-09
r_1398_1414_e 1398 1414 836.944
r_1398_1414_i 1398_1414 1414 4256.89
c_1398_1414_i 1398 1398_1414 4.67522e-10
r_1958_1974_e 1958 1974 836.944
r_1958_1974_i 1958_1974 1974 4256.89
c_1958_1974_i 1958 1958_1974 4.67522e-10
r_2518_2534_e 2518 2534 836.944
r_2518_2534_i 2518_2534 2534 4256.89
c_2518_2534_i 2518 2518_2534 4.67522e-10
r_3078_3094_e 3078 3094 13758.3
r_3078_3094_i 3078_3094 3094 95645.6
c_3078_3094_i 3078 3078_3094 9.36084e-12
r_3638_3654_e 3638 3654 13758.3
r_3638_3654_i 3638_3654 3654 95645.6
c_3638_3654_i 3638 3638_3654 9.36084e-12
r_279_295_e 279 295 13376.4
r_279_295_i 279_295 295 93218.1
c_279_295_i 279 279_295 2.08965e-09
r_839_855_e 839 855 13376.4
r_839_855_i 839_855 855 93218.1
c_839_855_i 839 839_855 2.08965e-09
r_1399_1415_e 1399 1415 836.944
r_1399_1415_i 1399_1415 1415 4256.89
c_1399_1415_i 1399 1399_1415 4.67522e-10
r_1959_1975_e 1959 1975 836.944
r_1959_1975_i 1959_1975 1975 4256.89
c_1959_1975_i 1959 1959_1975 4.67522e-10
r_2519_2535_e 2519 2535 836.944
r_2519_2535_i 2519_2535 2535 4256.89
c_2519_2535_i 2519 2519_2535 4.67522e-10
r_3079_3095_e 3079 3095 13758.3
r_3079_3095_i 3079_3095 3095 95645.6
c_3079_3095_i 3079 3079_3095 9.36084e-12
r_3639_3655_e 3639 3655 13758.3
r_3639_3655_i 3639_3655 3655 95645.6
c_3639_3655_i 3639 3639_3655 9.36084e-12
r_280_296_e 280 296 13376.4
r_280_296_i 280_296 296 93218.1
c_280_296_i 280 280_296 2.08965e-09
r_840_856_e 840 856 13376.4
r_840_856_i 840_856 856 93218.1
c_840_856_i 840 840_856 2.08965e-09
r_1400_1416_e 1400 1416 836.944
r_1400_1416_i 1400_1416 1416 4256.89
c_1400_1416_i 1400 1400_1416 4.67522e-10
r_1960_1976_e 1960 1976 836.944
r_1960_1976_i 1960_1976 1976 4256.89
c_1960_1976_i 1960 1960_1976 4.67522e-10
r_2520_2536_e 2520 2536 836.944
r_2520_2536_i 2520_2536 2536 4256.89
c_2520_2536_i 2520 2520_2536 4.67522e-10
r_3080_3096_e 3080 3096 13758.3
r_3080_3096_i 3080_3096 3096 95645.6
c_3080_3096_i 3080 3080_3096 9.36084e-12
r_3640_3656_e 3640 3656 13758.3
r_3640_3656_i 3640_3656 3656 95645.6
c_3640_3656_i 3640 3640_3656 9.36084e-12
r_281_297_e 281 297 13376.4
r_281_297_i 281_297 297 93218.1
c_281_297_i 281 281_297 2.08965e-09
r_841_857_e 841 857 13376.4
r_841_857_i 841_857 857 93218.1
c_841_857_i 841 841_857 2.08965e-09
r_1401_1417_e 1401 1417 836.944
r_1401_1417_i 1401_1417 1417 4256.89
c_1401_1417_i 1401 1401_1417 4.67522e-10
r_1961_1977_e 1961 1977 836.944
r_1961_1977_i 1961_1977 1977 4256.89
c_1961_1977_i 1961 1961_1977 4.67522e-10
r_2521_2537_e 2521 2537 836.944
r_2521_2537_i 2521_2537 2537 4256.89
c_2521_2537_i 2521 2521_2537 4.67522e-10
r_3081_3097_e 3081 3097 13758.3
r_3081_3097_i 3081_3097 3097 95645.6
c_3081_3097_i 3081 3081_3097 9.36084e-12
r_3641_3657_e 3641 3657 13758.3
r_3641_3657_i 3641_3657 3657 95645.6
c_3641_3657_i 3641 3641_3657 9.36084e-12
r_282_298_e 282 298 13376.4
r_282_298_i 282_298 298 93218.1
c_282_298_i 282 282_298 2.08965e-09
r_842_858_e 842 858 13376.4
r_842_858_i 842_858 858 93218.1
c_842_858_i 842 842_858 2.08965e-09
r_1402_1418_e 1402 1418 836.944
r_1402_1418_i 1402_1418 1418 4256.89
c_1402_1418_i 1402 1402_1418 4.67522e-10
r_1962_1978_e 1962 1978 836.944
r_1962_1978_i 1962_1978 1978 4256.89
c_1962_1978_i 1962 1962_1978 4.67522e-10
r_2522_2538_e 2522 2538 836.944
r_2522_2538_i 2522_2538 2538 4256.89
c_2522_2538_i 2522 2522_2538 4.67522e-10
r_3082_3098_e 3082 3098 13758.3
r_3082_3098_i 3082_3098 3098 95645.6
c_3082_3098_i 3082 3082_3098 9.36084e-12
r_3642_3658_e 3642 3658 13758.3
r_3642_3658_i 3642_3658 3658 95645.6
c_3642_3658_i 3642 3642_3658 9.36084e-12
r_283_299_e 283 299 13376.4
r_283_299_i 283_299 299 93218.1
c_283_299_i 283 283_299 2.08965e-09
r_843_859_e 843 859 396.619
r_843_859_i 843_859 859 1005.07
c_843_859_i 843 843_859 1.65828e-10
r_1403_1419_e 1403 1419 396.619
r_1403_1419_i 1403_1419 1419 1005.07
c_1403_1419_i 1403 1403_1419 1.65828e-10
r_1963_1979_e 1963 1979 836.944
r_1963_1979_i 1963_1979 1979 4256.89
c_1963_1979_i 1963 1963_1979 4.67522e-10
r_2523_2539_e 2523 2539 836.944
r_2523_2539_i 2523_2539 2539 4256.89
c_2523_2539_i 2523 2523_2539 4.67522e-10
r_3083_3099_e 3083 3099 13758.3
r_3083_3099_i 3083_3099 3099 95645.6
c_3083_3099_i 3083 3083_3099 9.36084e-12
r_3643_3659_e 3643 3659 13758.3
r_3643_3659_i 3643_3659 3659 95645.6
c_3643_3659_i 3643 3643_3659 9.36084e-12
r_284_300_e 284 300 13376.4
r_284_300_i 284_300 300 93218.1
c_284_300_i 284 284_300 2.08965e-09
r_844_860_e 844 860 396.619
r_844_860_i 844_860 860 1005.07
c_844_860_i 844 844_860 1.65828e-10
r_1404_1420_e 1404 1420 396.619
r_1404_1420_i 1404_1420 1420 1005.07
c_1404_1420_i 1404 1404_1420 1.65828e-10
r_1964_1980_e 1964 1980 836.944
r_1964_1980_i 1964_1980 1980 4256.89
c_1964_1980_i 1964 1964_1980 4.67522e-10
r_2524_2540_e 2524 2540 836.944
r_2524_2540_i 2524_2540 2540 4256.89
c_2524_2540_i 2524 2524_2540 4.67522e-10
r_3084_3100_e 3084 3100 13758.3
r_3084_3100_i 3084_3100 3100 95645.6
c_3084_3100_i 3084 3084_3100 9.36084e-12
r_3644_3660_e 3644 3660 13758.3
r_3644_3660_i 3644_3660 3660 95645.6
c_3644_3660_i 3644 3644_3660 9.36084e-12
r_285_301_e 285 301 13376.4
r_285_301_i 285_301 301 93218.1
c_285_301_i 285 285_301 2.08965e-09
r_845_861_e 845 861 13376.4
r_845_861_i 845_861 861 93218.1
c_845_861_i 845 845_861 2.08965e-09
r_1405_1421_e 1405 1421 836.944
r_1405_1421_i 1405_1421 1421 4256.89
c_1405_1421_i 1405 1405_1421 4.67522e-10
r_1965_1981_e 1965 1981 836.944
r_1965_1981_i 1965_1981 1981 4256.89
c_1965_1981_i 1965 1965_1981 4.67522e-10
r_2525_2541_e 2525 2541 836.944
r_2525_2541_i 2525_2541 2541 4256.89
c_2525_2541_i 2525 2525_2541 4.67522e-10
r_3085_3101_e 3085 3101 13758.3
r_3085_3101_i 3085_3101 3101 95645.6
c_3085_3101_i 3085 3085_3101 9.36084e-12
r_3645_3661_e 3645 3661 13758.3
r_3645_3661_i 3645_3661 3661 95645.6
c_3645_3661_i 3645 3645_3661 9.36084e-12
r_286_302_e 286 302 13376.4
r_286_302_i 286_302 302 93218.1
c_286_302_i 286 286_302 2.08965e-09
r_846_862_e 846 862 13376.4
r_846_862_i 846_862 862 93218.1
c_846_862_i 846 846_862 2.08965e-09
r_1406_1422_e 1406 1422 836.944
r_1406_1422_i 1406_1422 1422 4256.89
c_1406_1422_i 1406 1406_1422 4.67522e-10
r_1966_1982_e 1966 1982 836.944
r_1966_1982_i 1966_1982 1982 4256.89
c_1966_1982_i 1966 1966_1982 4.67522e-10
r_2526_2542_e 2526 2542 836.944
r_2526_2542_i 2526_2542 2542 4256.89
c_2526_2542_i 2526 2526_2542 4.67522e-10
r_3086_3102_e 3086 3102 13758.3
r_3086_3102_i 3086_3102 3102 95645.6
c_3086_3102_i 3086 3086_3102 9.36084e-12
r_3646_3662_e 3646 3662 13758.3
r_3646_3662_i 3646_3662 3662 95645.6
c_3646_3662_i 3646 3646_3662 9.36084e-12
r_287_303_e 287 303 13376.4
r_287_303_i 287_303 303 93218.1
c_287_303_i 287 287_303 2.08965e-09
r_847_863_e 847 863 13376.4
r_847_863_i 847_863 863 93218.1
c_847_863_i 847 847_863 2.08965e-09
r_1407_1423_e 1407 1423 836.944
r_1407_1423_i 1407_1423 1423 4256.89
c_1407_1423_i 1407 1407_1423 4.67522e-10
r_1967_1983_e 1967 1983 836.944
r_1967_1983_i 1967_1983 1983 4256.89
c_1967_1983_i 1967 1967_1983 4.67522e-10
r_2527_2543_e 2527 2543 836.944
r_2527_2543_i 2527_2543 2543 4256.89
c_2527_2543_i 2527 2527_2543 4.67522e-10
r_3087_3103_e 3087 3103 13758.3
r_3087_3103_i 3087_3103 3103 95645.6
c_3087_3103_i 3087 3087_3103 9.36084e-12
r_3647_3663_e 3647 3663 13758.3
r_3647_3663_i 3647_3663 3663 95645.6
c_3647_3663_i 3647 3647_3663 9.36084e-12
r_288_304_e 288 304 13376.4
r_288_304_i 288_304 304 93218.1
c_288_304_i 288 288_304 2.08965e-09
r_848_864_e 848 864 13376.4
r_848_864_i 848_864 864 93218.1
c_848_864_i 848 848_864 2.08965e-09
r_1408_1424_e 1408 1424 836.944
r_1408_1424_i 1408_1424 1424 4256.89
c_1408_1424_i 1408 1408_1424 4.67522e-10
r_1968_1984_e 1968 1984 836.944
r_1968_1984_i 1968_1984 1984 4256.89
c_1968_1984_i 1968 1968_1984 4.67522e-10
r_2528_2544_e 2528 2544 836.944
r_2528_2544_i 2528_2544 2544 4256.89
c_2528_2544_i 2528 2528_2544 4.67522e-10
r_3088_3104_e 3088 3104 13758.3
r_3088_3104_i 3088_3104 3104 95645.6
c_3088_3104_i 3088 3088_3104 9.36084e-12
r_3648_3664_e 3648 3664 13758.3
r_3648_3664_i 3648_3664 3664 95645.6
c_3648_3664_i 3648 3648_3664 9.36084e-12
r_289_305_e 289 305 13376.4
r_289_305_i 289_305 305 93218.1
c_289_305_i 289 289_305 2.08965e-09
r_849_865_e 849 865 13376.4
r_849_865_i 849_865 865 93218.1
c_849_865_i 849 849_865 2.08965e-09
r_1409_1425_e 1409 1425 13376.4
r_1409_1425_i 1409_1425 1425 93218.1
c_1409_1425_i 1409 1409_1425 2.08965e-09
r_1969_1985_e 1969 1985 13376.4
r_1969_1985_i 1969_1985 1985 93218.1
c_1969_1985_i 1969 1969_1985 2.08965e-09
r_2529_2545_e 2529 2545 13376.4
r_2529_2545_i 2529_2545 2545 93218.1
c_2529_2545_i 2529 2529_2545 2.08965e-09
r_3089_3105_e 3089 3105 13376.4
r_3089_3105_i 3089_3105 3105 93218.1
c_3089_3105_i 3089 3089_3105 2.08965e-09
r_3649_3665_e 3649 3665 13376.4
r_3649_3665_i 3649_3665 3665 93218.1
c_3649_3665_i 3649 3649_3665 2.08965e-09
r_290_306_e 290 306 13376.4
r_290_306_i 290_306 306 93218.1
c_290_306_i 290 290_306 2.08965e-09
r_850_866_e 850 866 13376.4
r_850_866_i 850_866 866 93218.1
c_850_866_i 850 850_866 2.08965e-09
r_1410_1426_e 1410 1426 13376.4
r_1410_1426_i 1410_1426 1426 93218.1
c_1410_1426_i 1410 1410_1426 2.08965e-09
r_1970_1986_e 1970 1986 13376.4
r_1970_1986_i 1970_1986 1986 93218.1
c_1970_1986_i 1970 1970_1986 2.08965e-09
r_2530_2546_e 2530 2546 13376.4
r_2530_2546_i 2530_2546 2546 93218.1
c_2530_2546_i 2530 2530_2546 2.08965e-09
r_3090_3106_e 3090 3106 13376.4
r_3090_3106_i 3090_3106 3106 93218.1
c_3090_3106_i 3090 3090_3106 2.08965e-09
r_3650_3666_e 3650 3666 13376.4
r_3650_3666_i 3650_3666 3666 93218.1
c_3650_3666_i 3650 3650_3666 2.08965e-09
r_291_307_e 291 307 13376.4
r_291_307_i 291_307 307 93218.1
c_291_307_i 291 291_307 2.08965e-09
r_851_867_e 851 867 13376.4
r_851_867_i 851_867 867 93218.1
c_851_867_i 851 851_867 2.08965e-09
r_1411_1427_e 1411 1427 836.944
r_1411_1427_i 1411_1427 1427 4256.89
c_1411_1427_i 1411 1411_1427 4.67522e-10
r_1971_1987_e 1971 1987 836.944
r_1971_1987_i 1971_1987 1987 4256.89
c_1971_1987_i 1971 1971_1987 4.67522e-10
r_2531_2547_e 2531 2547 836.944
r_2531_2547_i 2531_2547 2547 4256.89
c_2531_2547_i 2531 2531_2547 4.67522e-10
r_3091_3107_e 3091 3107 836.944
r_3091_3107_i 3091_3107 3107 4256.89
c_3091_3107_i 3091 3091_3107 4.67522e-10
r_3651_3667_e 3651 3667 836.944
r_3651_3667_i 3651_3667 3667 4256.89
c_3651_3667_i 3651 3651_3667 4.67522e-10
r_292_308_e 292 308 13376.4
r_292_308_i 292_308 308 93218.1
c_292_308_i 292 292_308 2.08965e-09
r_852_868_e 852 868 13376.4
r_852_868_i 852_868 868 93218.1
c_852_868_i 852 852_868 2.08965e-09
r_1412_1428_e 1412 1428 836.944
r_1412_1428_i 1412_1428 1428 4256.89
c_1412_1428_i 1412 1412_1428 4.67522e-10
r_1972_1988_e 1972 1988 836.944
r_1972_1988_i 1972_1988 1988 4256.89
c_1972_1988_i 1972 1972_1988 4.67522e-10
r_2532_2548_e 2532 2548 836.944
r_2532_2548_i 2532_2548 2548 4256.89
c_2532_2548_i 2532 2532_2548 4.67522e-10
r_3092_3108_e 3092 3108 13758.3
r_3092_3108_i 3092_3108 3108 95645.6
c_3092_3108_i 3092 3092_3108 9.36084e-12
r_3652_3668_e 3652 3668 13758.3
r_3652_3668_i 3652_3668 3668 95645.6
c_3652_3668_i 3652 3652_3668 9.36084e-12
r_293_309_e 293 309 13376.4
r_293_309_i 293_309 309 93218.1
c_293_309_i 293 293_309 2.08965e-09
r_853_869_e 853 869 13376.4
r_853_869_i 853_869 869 93218.1
c_853_869_i 853 853_869 2.08965e-09
r_1413_1429_e 1413 1429 836.944
r_1413_1429_i 1413_1429 1429 4256.89
c_1413_1429_i 1413 1413_1429 4.67522e-10
r_1973_1989_e 1973 1989 836.944
r_1973_1989_i 1973_1989 1989 4256.89
c_1973_1989_i 1973 1973_1989 4.67522e-10
r_2533_2549_e 2533 2549 836.944
r_2533_2549_i 2533_2549 2549 4256.89
c_2533_2549_i 2533 2533_2549 4.67522e-10
r_3093_3109_e 3093 3109 13758.3
r_3093_3109_i 3093_3109 3109 95645.6
c_3093_3109_i 3093 3093_3109 9.36084e-12
r_3653_3669_e 3653 3669 13758.3
r_3653_3669_i 3653_3669 3669 95645.6
c_3653_3669_i 3653 3653_3669 9.36084e-12
r_294_310_e 294 310 13376.4
r_294_310_i 294_310 310 93218.1
c_294_310_i 294 294_310 2.08965e-09
r_854_870_e 854 870 13376.4
r_854_870_i 854_870 870 93218.1
c_854_870_i 854 854_870 2.08965e-09
r_1414_1430_e 1414 1430 836.944
r_1414_1430_i 1414_1430 1430 4256.89
c_1414_1430_i 1414 1414_1430 4.67522e-10
r_1974_1990_e 1974 1990 836.944
r_1974_1990_i 1974_1990 1990 4256.89
c_1974_1990_i 1974 1974_1990 4.67522e-10
r_2534_2550_e 2534 2550 836.944
r_2534_2550_i 2534_2550 2550 4256.89
c_2534_2550_i 2534 2534_2550 4.67522e-10
r_3094_3110_e 3094 3110 13758.3
r_3094_3110_i 3094_3110 3110 95645.6
c_3094_3110_i 3094 3094_3110 9.36084e-12
r_3654_3670_e 3654 3670 13758.3
r_3654_3670_i 3654_3670 3670 95645.6
c_3654_3670_i 3654 3654_3670 9.36084e-12
r_295_311_e 295 311 13376.4
r_295_311_i 295_311 311 93218.1
c_295_311_i 295 295_311 2.08965e-09
r_855_871_e 855 871 13376.4
r_855_871_i 855_871 871 93218.1
c_855_871_i 855 855_871 2.08965e-09
r_1415_1431_e 1415 1431 836.944
r_1415_1431_i 1415_1431 1431 4256.89
c_1415_1431_i 1415 1415_1431 4.67522e-10
r_1975_1991_e 1975 1991 836.944
r_1975_1991_i 1975_1991 1991 4256.89
c_1975_1991_i 1975 1975_1991 4.67522e-10
r_2535_2551_e 2535 2551 836.944
r_2535_2551_i 2535_2551 2551 4256.89
c_2535_2551_i 2535 2535_2551 4.67522e-10
r_3095_3111_e 3095 3111 13758.3
r_3095_3111_i 3095_3111 3111 95645.6
c_3095_3111_i 3095 3095_3111 9.36084e-12
r_3655_3671_e 3655 3671 13758.3
r_3655_3671_i 3655_3671 3671 95645.6
c_3655_3671_i 3655 3655_3671 9.36084e-12
r_296_312_e 296 312 13376.4
r_296_312_i 296_312 312 93218.1
c_296_312_i 296 296_312 2.08965e-09
r_856_872_e 856 872 13376.4
r_856_872_i 856_872 872 93218.1
c_856_872_i 856 856_872 2.08965e-09
r_1416_1432_e 1416 1432 836.944
r_1416_1432_i 1416_1432 1432 4256.89
c_1416_1432_i 1416 1416_1432 4.67522e-10
r_1976_1992_e 1976 1992 836.944
r_1976_1992_i 1976_1992 1992 4256.89
c_1976_1992_i 1976 1976_1992 4.67522e-10
r_2536_2552_e 2536 2552 836.944
r_2536_2552_i 2536_2552 2552 4256.89
c_2536_2552_i 2536 2536_2552 4.67522e-10
r_3096_3112_e 3096 3112 13758.3
r_3096_3112_i 3096_3112 3112 95645.6
c_3096_3112_i 3096 3096_3112 9.36084e-12
r_3656_3672_e 3656 3672 13758.3
r_3656_3672_i 3656_3672 3672 95645.6
c_3656_3672_i 3656 3656_3672 9.36084e-12
r_297_313_e 297 313 13376.4
r_297_313_i 297_313 313 93218.1
c_297_313_i 297 297_313 2.08965e-09
r_857_873_e 857 873 13376.4
r_857_873_i 857_873 873 93218.1
c_857_873_i 857 857_873 2.08965e-09
r_1417_1433_e 1417 1433 836.944
r_1417_1433_i 1417_1433 1433 4256.89
c_1417_1433_i 1417 1417_1433 4.67522e-10
r_1977_1993_e 1977 1993 836.944
r_1977_1993_i 1977_1993 1993 4256.89
c_1977_1993_i 1977 1977_1993 4.67522e-10
r_2537_2553_e 2537 2553 836.944
r_2537_2553_i 2537_2553 2553 4256.89
c_2537_2553_i 2537 2537_2553 4.67522e-10
r_3097_3113_e 3097 3113 13758.3
r_3097_3113_i 3097_3113 3113 95645.6
c_3097_3113_i 3097 3097_3113 9.36084e-12
r_3657_3673_e 3657 3673 13758.3
r_3657_3673_i 3657_3673 3673 95645.6
c_3657_3673_i 3657 3657_3673 9.36084e-12
r_298_314_e 298 314 13376.4
r_298_314_i 298_314 314 93218.1
c_298_314_i 298 298_314 2.08965e-09
r_858_874_e 858 874 13376.4
r_858_874_i 858_874 874 93218.1
c_858_874_i 858 858_874 2.08965e-09
r_1418_1434_e 1418 1434 836.944
r_1418_1434_i 1418_1434 1434 4256.89
c_1418_1434_i 1418 1418_1434 4.67522e-10
r_1978_1994_e 1978 1994 836.944
r_1978_1994_i 1978_1994 1994 4256.89
c_1978_1994_i 1978 1978_1994 4.67522e-10
r_2538_2554_e 2538 2554 836.944
r_2538_2554_i 2538_2554 2554 4256.89
c_2538_2554_i 2538 2538_2554 4.67522e-10
r_3098_3114_e 3098 3114 13758.3
r_3098_3114_i 3098_3114 3114 95645.6
c_3098_3114_i 3098 3098_3114 9.36084e-12
r_3658_3674_e 3658 3674 13758.3
r_3658_3674_i 3658_3674 3674 95645.6
c_3658_3674_i 3658 3658_3674 9.36084e-12
r_299_315_e 299 315 13376.4
r_299_315_i 299_315 315 93218.1
c_299_315_i 299 299_315 2.08965e-09
r_859_875_e 859 875 396.61
r_859_875_i 859_875 875 1005.05
c_859_875_i 859 859_875 1.65831e-10
r_1419_1435_e 1419 1435 396.61
r_1419_1435_i 1419_1435 1435 1005.05
c_1419_1435_i 1419 1419_1435 1.65831e-10
r_1979_1995_e 1979 1995 836.944
r_1979_1995_i 1979_1995 1995 4256.89
c_1979_1995_i 1979 1979_1995 4.67522e-10
r_2539_2555_e 2539 2555 836.944
r_2539_2555_i 2539_2555 2555 4256.89
c_2539_2555_i 2539 2539_2555 4.67522e-10
r_3099_3115_e 3099 3115 13758.3
r_3099_3115_i 3099_3115 3115 95645.6
c_3099_3115_i 3099 3099_3115 9.36084e-12
r_3659_3675_e 3659 3675 13758.3
r_3659_3675_i 3659_3675 3675 95645.6
c_3659_3675_i 3659 3659_3675 9.36084e-12
r_300_316_e 300 316 13376.4
r_300_316_i 300_316 316 93218.1
c_300_316_i 300 300_316 2.08965e-09
r_860_876_e 860 876 396.61
r_860_876_i 860_876 876 1005.05
c_860_876_i 860 860_876 1.65831e-10
r_1420_1436_e 1420 1436 396.61
r_1420_1436_i 1420_1436 1436 1005.05
c_1420_1436_i 1420 1420_1436 1.65831e-10
r_1980_1996_e 1980 1996 836.944
r_1980_1996_i 1980_1996 1996 4256.89
c_1980_1996_i 1980 1980_1996 4.67522e-10
r_2540_2556_e 2540 2556 836.944
r_2540_2556_i 2540_2556 2556 4256.89
c_2540_2556_i 2540 2540_2556 4.67522e-10
r_3100_3116_e 3100 3116 13758.3
r_3100_3116_i 3100_3116 3116 95645.6
c_3100_3116_i 3100 3100_3116 9.36084e-12
r_3660_3676_e 3660 3676 13758.3
r_3660_3676_i 3660_3676 3676 95645.6
c_3660_3676_i 3660 3660_3676 9.36084e-12
r_301_317_e 301 317 13376.4
r_301_317_i 301_317 317 93218.1
c_301_317_i 301 301_317 2.08965e-09
r_861_877_e 861 877 13376.4
r_861_877_i 861_877 877 93218.1
c_861_877_i 861 861_877 2.08965e-09
r_1421_1437_e 1421 1437 836.944
r_1421_1437_i 1421_1437 1437 4256.89
c_1421_1437_i 1421 1421_1437 4.67522e-10
r_1981_1997_e 1981 1997 836.944
r_1981_1997_i 1981_1997 1997 4256.89
c_1981_1997_i 1981 1981_1997 4.67522e-10
r_2541_2557_e 2541 2557 836.944
r_2541_2557_i 2541_2557 2557 4256.89
c_2541_2557_i 2541 2541_2557 4.67522e-10
r_3101_3117_e 3101 3117 13758.3
r_3101_3117_i 3101_3117 3117 95645.6
c_3101_3117_i 3101 3101_3117 9.36084e-12
r_3661_3677_e 3661 3677 13758.3
r_3661_3677_i 3661_3677 3677 95645.6
c_3661_3677_i 3661 3661_3677 9.36084e-12
r_302_318_e 302 318 13376.4
r_302_318_i 302_318 318 93218.1
c_302_318_i 302 302_318 2.08965e-09
r_862_878_e 862 878 13376.4
r_862_878_i 862_878 878 93218.1
c_862_878_i 862 862_878 2.08965e-09
r_1422_1438_e 1422 1438 836.944
r_1422_1438_i 1422_1438 1438 4256.89
c_1422_1438_i 1422 1422_1438 4.67522e-10
r_1982_1998_e 1982 1998 836.944
r_1982_1998_i 1982_1998 1998 4256.89
c_1982_1998_i 1982 1982_1998 4.67522e-10
r_2542_2558_e 2542 2558 836.944
r_2542_2558_i 2542_2558 2558 4256.89
c_2542_2558_i 2542 2542_2558 4.67522e-10
r_3102_3118_e 3102 3118 13758.3
r_3102_3118_i 3102_3118 3118 95645.6
c_3102_3118_i 3102 3102_3118 9.36084e-12
r_3662_3678_e 3662 3678 13758.3
r_3662_3678_i 3662_3678 3678 95645.6
c_3662_3678_i 3662 3662_3678 9.36084e-12
r_303_319_e 303 319 13376.4
r_303_319_i 303_319 319 93218.1
c_303_319_i 303 303_319 2.08965e-09
r_863_879_e 863 879 13376.4
r_863_879_i 863_879 879 93218.1
c_863_879_i 863 863_879 2.08965e-09
r_1423_1439_e 1423 1439 836.944
r_1423_1439_i 1423_1439 1439 4256.89
c_1423_1439_i 1423 1423_1439 4.67522e-10
r_1983_1999_e 1983 1999 836.944
r_1983_1999_i 1983_1999 1999 4256.89
c_1983_1999_i 1983 1983_1999 4.67522e-10
r_2543_2559_e 2543 2559 836.944
r_2543_2559_i 2543_2559 2559 4256.89
c_2543_2559_i 2543 2543_2559 4.67522e-10
r_3103_3119_e 3103 3119 13758.3
r_3103_3119_i 3103_3119 3119 95645.6
c_3103_3119_i 3103 3103_3119 9.36084e-12
r_3663_3679_e 3663 3679 13758.3
r_3663_3679_i 3663_3679 3679 95645.6
c_3663_3679_i 3663 3663_3679 9.36084e-12
r_304_320_e 304 320 13376.4
r_304_320_i 304_320 320 93218.1
c_304_320_i 304 304_320 2.08965e-09
r_864_880_e 864 880 13376.4
r_864_880_i 864_880 880 93218.1
c_864_880_i 864 864_880 2.08965e-09
r_1424_1440_e 1424 1440 836.944
r_1424_1440_i 1424_1440 1440 4256.89
c_1424_1440_i 1424 1424_1440 4.67522e-10
r_1984_2000_e 1984 2000 836.944
r_1984_2000_i 1984_2000 2000 4256.89
c_1984_2000_i 1984 1984_2000 4.67522e-10
r_2544_2560_e 2544 2560 836.944
r_2544_2560_i 2544_2560 2560 4256.89
c_2544_2560_i 2544 2544_2560 4.67522e-10
r_3104_3120_e 3104 3120 13758.3
r_3104_3120_i 3104_3120 3120 95645.6
c_3104_3120_i 3104 3104_3120 9.36084e-12
r_3664_3680_e 3664 3680 13758.3
r_3664_3680_i 3664_3680 3680 95645.6
c_3664_3680_i 3664 3664_3680 9.36084e-12
r_305_321_e 305 321 13376.4
r_305_321_i 305_321 321 93218.1
c_305_321_i 305 305_321 2.08965e-09
r_865_881_e 865 881 13376.4
r_865_881_i 865_881 881 93218.1
c_865_881_i 865 865_881 2.08965e-09
r_1425_1441_e 1425 1441 13376.4
r_1425_1441_i 1425_1441 1441 93218.1
c_1425_1441_i 1425 1425_1441 2.08965e-09
r_1985_2001_e 1985 2001 13376.4
r_1985_2001_i 1985_2001 2001 93218.1
c_1985_2001_i 1985 1985_2001 2.08965e-09
r_2545_2561_e 2545 2561 13376.4
r_2545_2561_i 2545_2561 2561 93218.1
c_2545_2561_i 2545 2545_2561 2.08965e-09
r_3105_3121_e 3105 3121 13376.4
r_3105_3121_i 3105_3121 3121 93218.1
c_3105_3121_i 3105 3105_3121 2.08965e-09
r_3665_3681_e 3665 3681 13376.4
r_3665_3681_i 3665_3681 3681 93218.1
c_3665_3681_i 3665 3665_3681 2.08965e-09
r_306_322_e 306 322 13376.4
r_306_322_i 306_322 322 93218.1
c_306_322_i 306 306_322 2.08965e-09
r_866_882_e 866 882 13376.4
r_866_882_i 866_882 882 93218.1
c_866_882_i 866 866_882 2.08965e-09
r_1426_1442_e 1426 1442 13376.4
r_1426_1442_i 1426_1442 1442 93218.1
c_1426_1442_i 1426 1426_1442 2.08965e-09
r_1986_2002_e 1986 2002 13376.4
r_1986_2002_i 1986_2002 2002 93218.1
c_1986_2002_i 1986 1986_2002 2.08965e-09
r_2546_2562_e 2546 2562 13376.4
r_2546_2562_i 2546_2562 2562 93218.1
c_2546_2562_i 2546 2546_2562 2.08965e-09
r_3106_3122_e 3106 3122 13376.4
r_3106_3122_i 3106_3122 3122 93218.1
c_3106_3122_i 3106 3106_3122 2.08965e-09
r_3666_3682_e 3666 3682 13376.4
r_3666_3682_i 3666_3682 3682 93218.1
c_3666_3682_i 3666 3666_3682 2.08965e-09
r_307_323_e 307 323 13376.4
r_307_323_i 307_323 323 93218.1
c_307_323_i 307 307_323 2.08965e-09
r_867_883_e 867 883 13376.4
r_867_883_i 867_883 883 93218.1
c_867_883_i 867 867_883 2.08965e-09
r_1427_1443_e 1427 1443 836.944
r_1427_1443_i 1427_1443 1443 4256.89
c_1427_1443_i 1427 1427_1443 4.67522e-10
r_1987_2003_e 1987 2003 836.944
r_1987_2003_i 1987_2003 2003 4256.89
c_1987_2003_i 1987 1987_2003 4.67522e-10
r_2547_2563_e 2547 2563 836.944
r_2547_2563_i 2547_2563 2563 4256.89
c_2547_2563_i 2547 2547_2563 4.67522e-10
r_3107_3123_e 3107 3123 836.944
r_3107_3123_i 3107_3123 3123 4256.89
c_3107_3123_i 3107 3107_3123 4.67522e-10
r_3667_3683_e 3667 3683 836.944
r_3667_3683_i 3667_3683 3683 4256.89
c_3667_3683_i 3667 3667_3683 4.67522e-10
r_308_324_e 308 324 13376.4
r_308_324_i 308_324 324 93218.1
c_308_324_i 308 308_324 2.08965e-09
r_868_884_e 868 884 13376.4
r_868_884_i 868_884 884 93218.1
c_868_884_i 868 868_884 2.08965e-09
r_1428_1444_e 1428 1444 836.944
r_1428_1444_i 1428_1444 1444 4256.89
c_1428_1444_i 1428 1428_1444 4.67522e-10
r_1988_2004_e 1988 2004 836.944
r_1988_2004_i 1988_2004 2004 4256.89
c_1988_2004_i 1988 1988_2004 4.67522e-10
r_2548_2564_e 2548 2564 836.944
r_2548_2564_i 2548_2564 2564 4256.89
c_2548_2564_i 2548 2548_2564 4.67522e-10
r_3108_3124_e 3108 3124 13758.3
r_3108_3124_i 3108_3124 3124 95645.6
c_3108_3124_i 3108 3108_3124 9.36084e-12
r_3668_3684_e 3668 3684 13758.3
r_3668_3684_i 3668_3684 3684 95645.6
c_3668_3684_i 3668 3668_3684 9.36084e-12
r_309_325_e 309 325 13376.4
r_309_325_i 309_325 325 93218.1
c_309_325_i 309 309_325 2.08965e-09
r_869_885_e 869 885 13376.4
r_869_885_i 869_885 885 93218.1
c_869_885_i 869 869_885 2.08965e-09
r_1429_1445_e 1429 1445 836.944
r_1429_1445_i 1429_1445 1445 4256.89
c_1429_1445_i 1429 1429_1445 4.67522e-10
r_1989_2005_e 1989 2005 836.944
r_1989_2005_i 1989_2005 2005 4256.89
c_1989_2005_i 1989 1989_2005 4.67522e-10
r_2549_2565_e 2549 2565 836.944
r_2549_2565_i 2549_2565 2565 4256.89
c_2549_2565_i 2549 2549_2565 4.67522e-10
r_3109_3125_e 3109 3125 13758.3
r_3109_3125_i 3109_3125 3125 95645.6
c_3109_3125_i 3109 3109_3125 9.36084e-12
r_3669_3685_e 3669 3685 13758.3
r_3669_3685_i 3669_3685 3685 95645.6
c_3669_3685_i 3669 3669_3685 9.36084e-12
r_310_326_e 310 326 13376.4
r_310_326_i 310_326 326 93218.1
c_310_326_i 310 310_326 2.08965e-09
r_870_886_e 870 886 13376.4
r_870_886_i 870_886 886 93218.1
c_870_886_i 870 870_886 2.08965e-09
r_1430_1446_e 1430 1446 836.944
r_1430_1446_i 1430_1446 1446 4256.89
c_1430_1446_i 1430 1430_1446 4.67522e-10
r_1990_2006_e 1990 2006 836.944
r_1990_2006_i 1990_2006 2006 4256.89
c_1990_2006_i 1990 1990_2006 4.67522e-10
r_2550_2566_e 2550 2566 836.944
r_2550_2566_i 2550_2566 2566 4256.89
c_2550_2566_i 2550 2550_2566 4.67522e-10
r_3110_3126_e 3110 3126 13758.3
r_3110_3126_i 3110_3126 3126 95645.6
c_3110_3126_i 3110 3110_3126 9.36084e-12
r_3670_3686_e 3670 3686 13758.3
r_3670_3686_i 3670_3686 3686 95645.6
c_3670_3686_i 3670 3670_3686 9.36084e-12
r_311_327_e 311 327 13376.4
r_311_327_i 311_327 327 93218.1
c_311_327_i 311 311_327 2.08965e-09
r_871_887_e 871 887 13376.4
r_871_887_i 871_887 887 93218.1
c_871_887_i 871 871_887 2.08965e-09
r_1431_1447_e 1431 1447 836.944
r_1431_1447_i 1431_1447 1447 4256.89
c_1431_1447_i 1431 1431_1447 4.67522e-10
r_1991_2007_e 1991 2007 836.944
r_1991_2007_i 1991_2007 2007 4256.89
c_1991_2007_i 1991 1991_2007 4.67522e-10
r_2551_2567_e 2551 2567 836.944
r_2551_2567_i 2551_2567 2567 4256.89
c_2551_2567_i 2551 2551_2567 4.67522e-10
r_3111_3127_e 3111 3127 13758.3
r_3111_3127_i 3111_3127 3127 95645.6
c_3111_3127_i 3111 3111_3127 9.36084e-12
r_3671_3687_e 3671 3687 13758.3
r_3671_3687_i 3671_3687 3687 95645.6
c_3671_3687_i 3671 3671_3687 9.36084e-12
r_312_328_e 312 328 13376.4
r_312_328_i 312_328 328 93218.1
c_312_328_i 312 312_328 2.08965e-09
r_872_888_e 872 888 13376.4
r_872_888_i 872_888 888 93218.1
c_872_888_i 872 872_888 2.08965e-09
r_1432_1448_e 1432 1448 836.944
r_1432_1448_i 1432_1448 1448 4256.89
c_1432_1448_i 1432 1432_1448 4.67522e-10
r_1992_2008_e 1992 2008 836.944
r_1992_2008_i 1992_2008 2008 4256.89
c_1992_2008_i 1992 1992_2008 4.67522e-10
r_2552_2568_e 2552 2568 836.944
r_2552_2568_i 2552_2568 2568 4256.89
c_2552_2568_i 2552 2552_2568 4.67522e-10
r_3112_3128_e 3112 3128 13758.3
r_3112_3128_i 3112_3128 3128 95645.6
c_3112_3128_i 3112 3112_3128 9.36084e-12
r_3672_3688_e 3672 3688 13758.3
r_3672_3688_i 3672_3688 3688 95645.6
c_3672_3688_i 3672 3672_3688 9.36084e-12
r_313_329_e 313 329 13376.4
r_313_329_i 313_329 329 93218.1
c_313_329_i 313 313_329 2.08965e-09
r_873_889_e 873 889 13376.4
r_873_889_i 873_889 889 93218.1
c_873_889_i 873 873_889 2.08965e-09
r_1433_1449_e 1433 1449 836.944
r_1433_1449_i 1433_1449 1449 4256.89
c_1433_1449_i 1433 1433_1449 4.67522e-10
r_1993_2009_e 1993 2009 836.944
r_1993_2009_i 1993_2009 2009 4256.89
c_1993_2009_i 1993 1993_2009 4.67522e-10
r_2553_2569_e 2553 2569 836.944
r_2553_2569_i 2553_2569 2569 4256.89
c_2553_2569_i 2553 2553_2569 4.67522e-10
r_3113_3129_e 3113 3129 13758.3
r_3113_3129_i 3113_3129 3129 95645.6
c_3113_3129_i 3113 3113_3129 9.36084e-12
r_3673_3689_e 3673 3689 13758.3
r_3673_3689_i 3673_3689 3689 95645.6
c_3673_3689_i 3673 3673_3689 9.36084e-12
r_314_330_e 314 330 13376.4
r_314_330_i 314_330 330 93218.1
c_314_330_i 314 314_330 2.08965e-09
r_874_890_e 874 890 13376.4
r_874_890_i 874_890 890 93218.1
c_874_890_i 874 874_890 2.08965e-09
r_1434_1450_e 1434 1450 836.944
r_1434_1450_i 1434_1450 1450 4256.89
c_1434_1450_i 1434 1434_1450 4.67522e-10
r_1994_2010_e 1994 2010 836.944
r_1994_2010_i 1994_2010 2010 4256.89
c_1994_2010_i 1994 1994_2010 4.67522e-10
r_2554_2570_e 2554 2570 836.944
r_2554_2570_i 2554_2570 2570 4256.89
c_2554_2570_i 2554 2554_2570 4.67522e-10
r_3114_3130_e 3114 3130 13758.3
r_3114_3130_i 3114_3130 3130 95645.6
c_3114_3130_i 3114 3114_3130 9.36084e-12
r_3674_3690_e 3674 3690 13758.3
r_3674_3690_i 3674_3690 3690 95645.6
c_3674_3690_i 3674 3674_3690 9.36084e-12
r_315_331_e 315 331 13376.4
r_315_331_i 315_331 331 93218.1
c_315_331_i 315 315_331 2.08965e-09
r_875_891_e 875 891 396.602
r_875_891_i 875_891 891 1005.03
c_875_891_i 875 875_891 1.65835e-10
r_1435_1451_e 1435 1451 396.602
r_1435_1451_i 1435_1451 1451 1005.03
c_1435_1451_i 1435 1435_1451 1.65835e-10
r_1995_2011_e 1995 2011 836.944
r_1995_2011_i 1995_2011 2011 4256.89
c_1995_2011_i 1995 1995_2011 4.67522e-10
r_2555_2571_e 2555 2571 836.944
r_2555_2571_i 2555_2571 2571 4256.89
c_2555_2571_i 2555 2555_2571 4.67522e-10
r_3115_3131_e 3115 3131 13758.3
r_3115_3131_i 3115_3131 3131 95645.6
c_3115_3131_i 3115 3115_3131 9.36084e-12
r_3675_3691_e 3675 3691 13758.3
r_3675_3691_i 3675_3691 3691 95645.6
c_3675_3691_i 3675 3675_3691 9.36084e-12
r_316_332_e 316 332 13376.4
r_316_332_i 316_332 332 93218.1
c_316_332_i 316 316_332 2.08965e-09
r_876_892_e 876 892 396.602
r_876_892_i 876_892 892 1005.03
c_876_892_i 876 876_892 1.65835e-10
r_1436_1452_e 1436 1452 396.602
r_1436_1452_i 1436_1452 1452 1005.03
c_1436_1452_i 1436 1436_1452 1.65835e-10
r_1996_2012_e 1996 2012 836.944
r_1996_2012_i 1996_2012 2012 4256.89
c_1996_2012_i 1996 1996_2012 4.67522e-10
r_2556_2572_e 2556 2572 836.944
r_2556_2572_i 2556_2572 2572 4256.89
c_2556_2572_i 2556 2556_2572 4.67522e-10
r_3116_3132_e 3116 3132 13758.3
r_3116_3132_i 3116_3132 3132 95645.6
c_3116_3132_i 3116 3116_3132 9.36084e-12
r_3676_3692_e 3676 3692 13758.3
r_3676_3692_i 3676_3692 3692 95645.6
c_3676_3692_i 3676 3676_3692 9.36084e-12
r_317_333_e 317 333 13376.4
r_317_333_i 317_333 333 93218.1
c_317_333_i 317 317_333 2.08965e-09
r_877_893_e 877 893 13376.4
r_877_893_i 877_893 893 93218.1
c_877_893_i 877 877_893 2.08965e-09
r_1437_1453_e 1437 1453 836.944
r_1437_1453_i 1437_1453 1453 4256.89
c_1437_1453_i 1437 1437_1453 4.67522e-10
r_1997_2013_e 1997 2013 836.944
r_1997_2013_i 1997_2013 2013 4256.89
c_1997_2013_i 1997 1997_2013 4.67522e-10
r_2557_2573_e 2557 2573 836.944
r_2557_2573_i 2557_2573 2573 4256.89
c_2557_2573_i 2557 2557_2573 4.67522e-10
r_3117_3133_e 3117 3133 13758.3
r_3117_3133_i 3117_3133 3133 95645.6
c_3117_3133_i 3117 3117_3133 9.36084e-12
r_3677_3693_e 3677 3693 13758.3
r_3677_3693_i 3677_3693 3693 95645.6
c_3677_3693_i 3677 3677_3693 9.36084e-12
r_318_334_e 318 334 13376.4
r_318_334_i 318_334 334 93218.1
c_318_334_i 318 318_334 2.08965e-09
r_878_894_e 878 894 13376.4
r_878_894_i 878_894 894 93218.1
c_878_894_i 878 878_894 2.08965e-09
r_1438_1454_e 1438 1454 836.944
r_1438_1454_i 1438_1454 1454 4256.89
c_1438_1454_i 1438 1438_1454 4.67522e-10
r_1998_2014_e 1998 2014 836.944
r_1998_2014_i 1998_2014 2014 4256.89
c_1998_2014_i 1998 1998_2014 4.67522e-10
r_2558_2574_e 2558 2574 836.944
r_2558_2574_i 2558_2574 2574 4256.89
c_2558_2574_i 2558 2558_2574 4.67522e-10
r_3118_3134_e 3118 3134 13758.3
r_3118_3134_i 3118_3134 3134 95645.6
c_3118_3134_i 3118 3118_3134 9.36084e-12
r_3678_3694_e 3678 3694 13758.3
r_3678_3694_i 3678_3694 3694 95645.6
c_3678_3694_i 3678 3678_3694 9.36084e-12
r_319_335_e 319 335 13376.4
r_319_335_i 319_335 335 93218.1
c_319_335_i 319 319_335 2.08965e-09
r_879_895_e 879 895 13376.4
r_879_895_i 879_895 895 93218.1
c_879_895_i 879 879_895 2.08965e-09
r_1439_1455_e 1439 1455 836.944
r_1439_1455_i 1439_1455 1455 4256.89
c_1439_1455_i 1439 1439_1455 4.67522e-10
r_1999_2015_e 1999 2015 836.944
r_1999_2015_i 1999_2015 2015 4256.89
c_1999_2015_i 1999 1999_2015 4.67522e-10
r_2559_2575_e 2559 2575 836.944
r_2559_2575_i 2559_2575 2575 4256.89
c_2559_2575_i 2559 2559_2575 4.67522e-10
r_3119_3135_e 3119 3135 13758.3
r_3119_3135_i 3119_3135 3135 95645.6
c_3119_3135_i 3119 3119_3135 9.36084e-12
r_3679_3695_e 3679 3695 13758.3
r_3679_3695_i 3679_3695 3695 95645.6
c_3679_3695_i 3679 3679_3695 9.36084e-12
r_320_336_e 320 336 13376.4
r_320_336_i 320_336 336 93218.1
c_320_336_i 320 320_336 2.08965e-09
r_880_896_e 880 896 13376.4
r_880_896_i 880_896 896 93218.1
c_880_896_i 880 880_896 2.08965e-09
r_1440_1456_e 1440 1456 836.944
r_1440_1456_i 1440_1456 1456 4256.89
c_1440_1456_i 1440 1440_1456 4.67522e-10
r_2000_2016_e 2000 2016 836.944
r_2000_2016_i 2000_2016 2016 4256.89
c_2000_2016_i 2000 2000_2016 4.67522e-10
r_2560_2576_e 2560 2576 836.944
r_2560_2576_i 2560_2576 2576 4256.89
c_2560_2576_i 2560 2560_2576 4.67522e-10
r_3120_3136_e 3120 3136 13758.3
r_3120_3136_i 3120_3136 3136 95645.6
c_3120_3136_i 3120 3120_3136 9.36084e-12
r_3680_3696_e 3680 3696 13758.3
r_3680_3696_i 3680_3696 3696 95645.6
c_3680_3696_i 3680 3680_3696 9.36084e-12
r_321_337_e 321 337 13376.4
r_321_337_i 321_337 337 93218.1
c_321_337_i 321 321_337 2.08965e-09
r_881_897_e 881 897 13376.4
r_881_897_i 881_897 897 93218.1
c_881_897_i 881 881_897 2.08965e-09
r_1441_1457_e 1441 1457 13376.4
r_1441_1457_i 1441_1457 1457 93218.1
c_1441_1457_i 1441 1441_1457 2.08965e-09
r_2001_2017_e 2001 2017 13376.4
r_2001_2017_i 2001_2017 2017 93218.1
c_2001_2017_i 2001 2001_2017 2.08965e-09
r_2561_2577_e 2561 2577 13376.4
r_2561_2577_i 2561_2577 2577 93218.1
c_2561_2577_i 2561 2561_2577 2.08965e-09
r_3121_3137_e 3121 3137 13376.4
r_3121_3137_i 3121_3137 3137 93218.1
c_3121_3137_i 3121 3121_3137 2.08965e-09
r_3681_3697_e 3681 3697 13376.4
r_3681_3697_i 3681_3697 3697 93218.1
c_3681_3697_i 3681 3681_3697 2.08965e-09
r_322_338_e 322 338 13376.4
r_322_338_i 322_338 338 93218.1
c_322_338_i 322 322_338 2.08965e-09
r_882_898_e 882 898 13376.4
r_882_898_i 882_898 898 93218.1
c_882_898_i 882 882_898 2.08965e-09
r_1442_1458_e 1442 1458 13376.4
r_1442_1458_i 1442_1458 1458 93218.1
c_1442_1458_i 1442 1442_1458 2.08965e-09
r_2002_2018_e 2002 2018 13376.4
r_2002_2018_i 2002_2018 2018 93218.1
c_2002_2018_i 2002 2002_2018 2.08965e-09
r_2562_2578_e 2562 2578 13376.4
r_2562_2578_i 2562_2578 2578 93218.1
c_2562_2578_i 2562 2562_2578 2.08965e-09
r_3122_3138_e 3122 3138 13376.4
r_3122_3138_i 3122_3138 3138 93218.1
c_3122_3138_i 3122 3122_3138 2.08965e-09
r_3682_3698_e 3682 3698 13376.4
r_3682_3698_i 3682_3698 3698 93218.1
c_3682_3698_i 3682 3682_3698 2.08965e-09
r_323_339_e 323 339 13376.4
r_323_339_i 323_339 339 93218.1
c_323_339_i 323 323_339 2.08965e-09
r_883_899_e 883 899 13376.4
r_883_899_i 883_899 899 93218.1
c_883_899_i 883 883_899 2.08965e-09
r_1443_1459_e 1443 1459 836.944
r_1443_1459_i 1443_1459 1459 4256.89
c_1443_1459_i 1443 1443_1459 4.67522e-10
r_2003_2019_e 2003 2019 836.944
r_2003_2019_i 2003_2019 2019 4256.89
c_2003_2019_i 2003 2003_2019 4.67522e-10
r_2563_2579_e 2563 2579 836.944
r_2563_2579_i 2563_2579 2579 4256.89
c_2563_2579_i 2563 2563_2579 4.67522e-10
r_3123_3139_e 3123 3139 836.944
r_3123_3139_i 3123_3139 3139 4256.89
c_3123_3139_i 3123 3123_3139 4.67522e-10
r_3683_3699_e 3683 3699 836.944
r_3683_3699_i 3683_3699 3699 4256.89
c_3683_3699_i 3683 3683_3699 4.67522e-10
r_324_340_e 324 340 13376.4
r_324_340_i 324_340 340 93218.1
c_324_340_i 324 324_340 2.08965e-09
r_884_900_e 884 900 13376.4
r_884_900_i 884_900 900 93218.1
c_884_900_i 884 884_900 2.08965e-09
r_1444_1460_e 1444 1460 836.944
r_1444_1460_i 1444_1460 1460 4256.89
c_1444_1460_i 1444 1444_1460 4.67522e-10
r_2004_2020_e 2004 2020 836.944
r_2004_2020_i 2004_2020 2020 4256.89
c_2004_2020_i 2004 2004_2020 4.67522e-10
r_2564_2580_e 2564 2580 836.944
r_2564_2580_i 2564_2580 2580 4256.89
c_2564_2580_i 2564 2564_2580 4.67522e-10
r_3124_3140_e 3124 3140 13758.3
r_3124_3140_i 3124_3140 3140 95645.6
c_3124_3140_i 3124 3124_3140 9.36084e-12
r_3684_3700_e 3684 3700 13758.3
r_3684_3700_i 3684_3700 3700 95645.6
c_3684_3700_i 3684 3684_3700 9.36084e-12
r_325_341_e 325 341 13376.4
r_325_341_i 325_341 341 93218.1
c_325_341_i 325 325_341 2.08965e-09
r_885_901_e 885 901 13376.4
r_885_901_i 885_901 901 93218.1
c_885_901_i 885 885_901 2.08965e-09
r_1445_1461_e 1445 1461 836.944
r_1445_1461_i 1445_1461 1461 4256.89
c_1445_1461_i 1445 1445_1461 4.67522e-10
r_2005_2021_e 2005 2021 836.944
r_2005_2021_i 2005_2021 2021 4256.89
c_2005_2021_i 2005 2005_2021 4.67522e-10
r_2565_2581_e 2565 2581 836.944
r_2565_2581_i 2565_2581 2581 4256.89
c_2565_2581_i 2565 2565_2581 4.67522e-10
r_3125_3141_e 3125 3141 13758.3
r_3125_3141_i 3125_3141 3141 95645.6
c_3125_3141_i 3125 3125_3141 9.36084e-12
r_3685_3701_e 3685 3701 13758.3
r_3685_3701_i 3685_3701 3701 95645.6
c_3685_3701_i 3685 3685_3701 9.36084e-12
r_326_342_e 326 342 13376.4
r_326_342_i 326_342 342 93218.1
c_326_342_i 326 326_342 2.08965e-09
r_886_902_e 886 902 13376.4
r_886_902_i 886_902 902 93218.1
c_886_902_i 886 886_902 2.08965e-09
r_1446_1462_e 1446 1462 836.944
r_1446_1462_i 1446_1462 1462 4256.89
c_1446_1462_i 1446 1446_1462 4.67522e-10
r_2006_2022_e 2006 2022 836.944
r_2006_2022_i 2006_2022 2022 4256.89
c_2006_2022_i 2006 2006_2022 4.67522e-10
r_2566_2582_e 2566 2582 836.944
r_2566_2582_i 2566_2582 2582 4256.89
c_2566_2582_i 2566 2566_2582 4.67522e-10
r_3126_3142_e 3126 3142 13758.3
r_3126_3142_i 3126_3142 3142 95645.6
c_3126_3142_i 3126 3126_3142 9.36084e-12
r_3686_3702_e 3686 3702 13758.3
r_3686_3702_i 3686_3702 3702 95645.6
c_3686_3702_i 3686 3686_3702 9.36084e-12
r_327_343_e 327 343 13376.4
r_327_343_i 327_343 343 93218.1
c_327_343_i 327 327_343 2.08965e-09
r_887_903_e 887 903 13376.4
r_887_903_i 887_903 903 93218.1
c_887_903_i 887 887_903 2.08965e-09
r_1447_1463_e 1447 1463 836.944
r_1447_1463_i 1447_1463 1463 4256.89
c_1447_1463_i 1447 1447_1463 4.67522e-10
r_2007_2023_e 2007 2023 836.944
r_2007_2023_i 2007_2023 2023 4256.89
c_2007_2023_i 2007 2007_2023 4.67522e-10
r_2567_2583_e 2567 2583 836.944
r_2567_2583_i 2567_2583 2583 4256.89
c_2567_2583_i 2567 2567_2583 4.67522e-10
r_3127_3143_e 3127 3143 13758.3
r_3127_3143_i 3127_3143 3143 95645.6
c_3127_3143_i 3127 3127_3143 9.36084e-12
r_3687_3703_e 3687 3703 13758.3
r_3687_3703_i 3687_3703 3703 95645.6
c_3687_3703_i 3687 3687_3703 9.36084e-12
r_328_344_e 328 344 13376.4
r_328_344_i 328_344 344 93218.1
c_328_344_i 328 328_344 2.08965e-09
r_888_904_e 888 904 13376.4
r_888_904_i 888_904 904 93218.1
c_888_904_i 888 888_904 2.08965e-09
r_1448_1464_e 1448 1464 836.944
r_1448_1464_i 1448_1464 1464 4256.89
c_1448_1464_i 1448 1448_1464 4.67522e-10
r_2008_2024_e 2008 2024 836.944
r_2008_2024_i 2008_2024 2024 4256.89
c_2008_2024_i 2008 2008_2024 4.67522e-10
r_2568_2584_e 2568 2584 836.944
r_2568_2584_i 2568_2584 2584 4256.89
c_2568_2584_i 2568 2568_2584 4.67522e-10
r_3128_3144_e 3128 3144 13758.3
r_3128_3144_i 3128_3144 3144 95645.6
c_3128_3144_i 3128 3128_3144 9.36084e-12
r_3688_3704_e 3688 3704 13758.3
r_3688_3704_i 3688_3704 3704 95645.6
c_3688_3704_i 3688 3688_3704 9.36084e-12
r_329_345_e 329 345 13376.4
r_329_345_i 329_345 345 93218.1
c_329_345_i 329 329_345 2.08965e-09
r_889_905_e 889 905 13376.4
r_889_905_i 889_905 905 93218.1
c_889_905_i 889 889_905 2.08965e-09
r_1449_1465_e 1449 1465 836.944
r_1449_1465_i 1449_1465 1465 4256.89
c_1449_1465_i 1449 1449_1465 4.67522e-10
r_2009_2025_e 2009 2025 836.944
r_2009_2025_i 2009_2025 2025 4256.89
c_2009_2025_i 2009 2009_2025 4.67522e-10
r_2569_2585_e 2569 2585 836.944
r_2569_2585_i 2569_2585 2585 4256.89
c_2569_2585_i 2569 2569_2585 4.67522e-10
r_3129_3145_e 3129 3145 13758.3
r_3129_3145_i 3129_3145 3145 95645.6
c_3129_3145_i 3129 3129_3145 9.36084e-12
r_3689_3705_e 3689 3705 13758.3
r_3689_3705_i 3689_3705 3705 95645.6
c_3689_3705_i 3689 3689_3705 9.36084e-12
r_330_346_e 330 346 13376.4
r_330_346_i 330_346 346 93218.1
c_330_346_i 330 330_346 2.08965e-09
r_890_906_e 890 906 13376.4
r_890_906_i 890_906 906 93218.1
c_890_906_i 890 890_906 2.08965e-09
r_1450_1466_e 1450 1466 836.944
r_1450_1466_i 1450_1466 1466 4256.89
c_1450_1466_i 1450 1450_1466 4.67522e-10
r_2010_2026_e 2010 2026 836.944
r_2010_2026_i 2010_2026 2026 4256.89
c_2010_2026_i 2010 2010_2026 4.67522e-10
r_2570_2586_e 2570 2586 836.944
r_2570_2586_i 2570_2586 2586 4256.89
c_2570_2586_i 2570 2570_2586 4.67522e-10
r_3130_3146_e 3130 3146 13758.3
r_3130_3146_i 3130_3146 3146 95645.6
c_3130_3146_i 3130 3130_3146 9.36084e-12
r_3690_3706_e 3690 3706 13758.3
r_3690_3706_i 3690_3706 3706 95645.6
c_3690_3706_i 3690 3690_3706 9.36084e-12
r_331_347_e 331 347 13376.4
r_331_347_i 331_347 347 93218.1
c_331_347_i 331 331_347 2.08965e-09
r_891_907_e 891 907 396.593
r_891_907_i 891_907 907 1005.01
c_891_907_i 891 891_907 1.65838e-10
r_1451_1467_e 1451 1467 396.593
r_1451_1467_i 1451_1467 1467 1005.01
c_1451_1467_i 1451 1451_1467 1.65838e-10
r_2011_2027_e 2011 2027 836.944
r_2011_2027_i 2011_2027 2027 4256.89
c_2011_2027_i 2011 2011_2027 4.67522e-10
r_2571_2587_e 2571 2587 836.944
r_2571_2587_i 2571_2587 2587 4256.89
c_2571_2587_i 2571 2571_2587 4.67522e-10
r_3131_3147_e 3131 3147 13758.3
r_3131_3147_i 3131_3147 3147 95645.6
c_3131_3147_i 3131 3131_3147 9.36084e-12
r_3691_3707_e 3691 3707 13758.3
r_3691_3707_i 3691_3707 3707 95645.6
c_3691_3707_i 3691 3691_3707 9.36084e-12
r_332_348_e 332 348 13376.4
r_332_348_i 332_348 348 93218.1
c_332_348_i 332 332_348 2.08965e-09
r_892_908_e 892 908 396.593
r_892_908_i 892_908 908 1005.01
c_892_908_i 892 892_908 1.65838e-10
r_1452_1468_e 1452 1468 396.593
r_1452_1468_i 1452_1468 1468 1005.01
c_1452_1468_i 1452 1452_1468 1.65838e-10
r_2012_2028_e 2012 2028 836.944
r_2012_2028_i 2012_2028 2028 4256.89
c_2012_2028_i 2012 2012_2028 4.67522e-10
r_2572_2588_e 2572 2588 836.944
r_2572_2588_i 2572_2588 2588 4256.89
c_2572_2588_i 2572 2572_2588 4.67522e-10
r_3132_3148_e 3132 3148 13758.3
r_3132_3148_i 3132_3148 3148 95645.6
c_3132_3148_i 3132 3132_3148 9.36084e-12
r_3692_3708_e 3692 3708 13758.3
r_3692_3708_i 3692_3708 3708 95645.6
c_3692_3708_i 3692 3692_3708 9.36084e-12
r_333_349_e 333 349 13376.4
r_333_349_i 333_349 349 93218.1
c_333_349_i 333 333_349 2.08965e-09
r_893_909_e 893 909 13376.4
r_893_909_i 893_909 909 93218.1
c_893_909_i 893 893_909 2.08965e-09
r_1453_1469_e 1453 1469 836.944
r_1453_1469_i 1453_1469 1469 4256.89
c_1453_1469_i 1453 1453_1469 4.67522e-10
r_2013_2029_e 2013 2029 836.944
r_2013_2029_i 2013_2029 2029 4256.89
c_2013_2029_i 2013 2013_2029 4.67522e-10
r_2573_2589_e 2573 2589 836.944
r_2573_2589_i 2573_2589 2589 4256.89
c_2573_2589_i 2573 2573_2589 4.67522e-10
r_3133_3149_e 3133 3149 13758.3
r_3133_3149_i 3133_3149 3149 95645.6
c_3133_3149_i 3133 3133_3149 9.36084e-12
r_3693_3709_e 3693 3709 13758.3
r_3693_3709_i 3693_3709 3709 95645.6
c_3693_3709_i 3693 3693_3709 9.36084e-12
r_334_350_e 334 350 13376.4
r_334_350_i 334_350 350 93218.1
c_334_350_i 334 334_350 2.08965e-09
r_894_910_e 894 910 13376.4
r_894_910_i 894_910 910 93218.1
c_894_910_i 894 894_910 2.08965e-09
r_1454_1470_e 1454 1470 836.944
r_1454_1470_i 1454_1470 1470 4256.89
c_1454_1470_i 1454 1454_1470 4.67522e-10
r_2014_2030_e 2014 2030 836.944
r_2014_2030_i 2014_2030 2030 4256.89
c_2014_2030_i 2014 2014_2030 4.67522e-10
r_2574_2590_e 2574 2590 836.944
r_2574_2590_i 2574_2590 2590 4256.89
c_2574_2590_i 2574 2574_2590 4.67522e-10
r_3134_3150_e 3134 3150 13758.3
r_3134_3150_i 3134_3150 3150 95645.6
c_3134_3150_i 3134 3134_3150 9.36084e-12
r_3694_3710_e 3694 3710 13758.3
r_3694_3710_i 3694_3710 3710 95645.6
c_3694_3710_i 3694 3694_3710 9.36084e-12
r_335_351_e 335 351 13376.4
r_335_351_i 335_351 351 93218.1
c_335_351_i 335 335_351 2.08965e-09
r_895_911_e 895 911 13376.4
r_895_911_i 895_911 911 93218.1
c_895_911_i 895 895_911 2.08965e-09
r_1455_1471_e 1455 1471 836.944
r_1455_1471_i 1455_1471 1471 4256.89
c_1455_1471_i 1455 1455_1471 4.67522e-10
r_2015_2031_e 2015 2031 836.944
r_2015_2031_i 2015_2031 2031 4256.89
c_2015_2031_i 2015 2015_2031 4.67522e-10
r_2575_2591_e 2575 2591 836.944
r_2575_2591_i 2575_2591 2591 4256.89
c_2575_2591_i 2575 2575_2591 4.67522e-10
r_3135_3151_e 3135 3151 13758.3
r_3135_3151_i 3135_3151 3151 95645.6
c_3135_3151_i 3135 3135_3151 9.36084e-12
r_3695_3711_e 3695 3711 13758.3
r_3695_3711_i 3695_3711 3711 95645.6
c_3695_3711_i 3695 3695_3711 9.36084e-12
r_336_352_e 336 352 13376.4
r_336_352_i 336_352 352 93218.1
c_336_352_i 336 336_352 2.08965e-09
r_896_912_e 896 912 13376.4
r_896_912_i 896_912 912 93218.1
c_896_912_i 896 896_912 2.08965e-09
r_1456_1472_e 1456 1472 836.944
r_1456_1472_i 1456_1472 1472 4256.89
c_1456_1472_i 1456 1456_1472 4.67522e-10
r_2016_2032_e 2016 2032 836.944
r_2016_2032_i 2016_2032 2032 4256.89
c_2016_2032_i 2016 2016_2032 4.67522e-10
r_2576_2592_e 2576 2592 836.944
r_2576_2592_i 2576_2592 2592 4256.89
c_2576_2592_i 2576 2576_2592 4.67522e-10
r_3136_3152_e 3136 3152 13758.3
r_3136_3152_i 3136_3152 3152 95645.6
c_3136_3152_i 3136 3136_3152 9.36084e-12
r_3696_3712_e 3696 3712 13758.3
r_3696_3712_i 3696_3712 3712 95645.6
c_3696_3712_i 3696 3696_3712 9.36084e-12
r_337_353_e 337 353 13376.4
r_337_353_i 337_353 353 93218.1
c_337_353_i 337 337_353 2.08965e-09
r_897_913_e 897 913 13376.4
r_897_913_i 897_913 913 93218.1
c_897_913_i 897 897_913 2.08965e-09
r_1457_1473_e 1457 1473 13376.4
r_1457_1473_i 1457_1473 1473 93218.1
c_1457_1473_i 1457 1457_1473 2.08965e-09
r_2017_2033_e 2017 2033 13376.4
r_2017_2033_i 2017_2033 2033 93218.1
c_2017_2033_i 2017 2017_2033 2.08965e-09
r_2577_2593_e 2577 2593 13376.4
r_2577_2593_i 2577_2593 2593 93218.1
c_2577_2593_i 2577 2577_2593 2.08965e-09
r_3137_3153_e 3137 3153 13376.4
r_3137_3153_i 3137_3153 3153 93218.1
c_3137_3153_i 3137 3137_3153 2.08965e-09
r_3697_3713_e 3697 3713 13376.4
r_3697_3713_i 3697_3713 3713 93218.1
c_3697_3713_i 3697 3697_3713 2.08965e-09
r_338_354_e 338 354 13376.4
r_338_354_i 338_354 354 93218.1
c_338_354_i 338 338_354 2.08965e-09
r_898_914_e 898 914 13376.4
r_898_914_i 898_914 914 93218.1
c_898_914_i 898 898_914 2.08965e-09
r_1458_1474_e 1458 1474 13376.4
r_1458_1474_i 1458_1474 1474 93218.1
c_1458_1474_i 1458 1458_1474 2.08965e-09
r_2018_2034_e 2018 2034 13376.4
r_2018_2034_i 2018_2034 2034 93218.1
c_2018_2034_i 2018 2018_2034 2.08965e-09
r_2578_2594_e 2578 2594 13376.4
r_2578_2594_i 2578_2594 2594 93218.1
c_2578_2594_i 2578 2578_2594 2.08965e-09
r_3138_3154_e 3138 3154 13376.4
r_3138_3154_i 3138_3154 3154 93218.1
c_3138_3154_i 3138 3138_3154 2.08965e-09
r_3698_3714_e 3698 3714 13376.4
r_3698_3714_i 3698_3714 3714 93218.1
c_3698_3714_i 3698 3698_3714 2.08965e-09
r_339_355_e 339 355 13376.4
r_339_355_i 339_355 355 93218.1
c_339_355_i 339 339_355 2.08965e-09
r_899_915_e 899 915 13376.4
r_899_915_i 899_915 915 93218.1
c_899_915_i 899 899_915 2.08965e-09
r_1459_1475_e 1459 1475 836.944
r_1459_1475_i 1459_1475 1475 4256.89
c_1459_1475_i 1459 1459_1475 4.67522e-10
r_2019_2035_e 2019 2035 836.944
r_2019_2035_i 2019_2035 2035 4256.89
c_2019_2035_i 2019 2019_2035 4.67522e-10
r_2579_2595_e 2579 2595 836.944
r_2579_2595_i 2579_2595 2595 4256.89
c_2579_2595_i 2579 2579_2595 4.67522e-10
r_3139_3155_e 3139 3155 836.944
r_3139_3155_i 3139_3155 3155 4256.89
c_3139_3155_i 3139 3139_3155 4.67522e-10
r_3699_3715_e 3699 3715 836.944
r_3699_3715_i 3699_3715 3715 4256.89
c_3699_3715_i 3699 3699_3715 4.67522e-10
r_340_356_e 340 356 13376.4
r_340_356_i 340_356 356 93218.1
c_340_356_i 340 340_356 2.08965e-09
r_900_916_e 900 916 13376.4
r_900_916_i 900_916 916 93218.1
c_900_916_i 900 900_916 2.08965e-09
r_1460_1476_e 1460 1476 836.944
r_1460_1476_i 1460_1476 1476 4256.89
c_1460_1476_i 1460 1460_1476 4.67522e-10
r_2020_2036_e 2020 2036 836.944
r_2020_2036_i 2020_2036 2036 4256.89
c_2020_2036_i 2020 2020_2036 4.67522e-10
r_2580_2596_e 2580 2596 836.944
r_2580_2596_i 2580_2596 2596 4256.89
c_2580_2596_i 2580 2580_2596 4.67522e-10
r_3140_3156_e 3140 3156 13758.3
r_3140_3156_i 3140_3156 3156 95645.6
c_3140_3156_i 3140 3140_3156 9.36084e-12
r_3700_3716_e 3700 3716 13758.3
r_3700_3716_i 3700_3716 3716 95645.6
c_3700_3716_i 3700 3700_3716 9.36084e-12
r_341_357_e 341 357 13376.4
r_341_357_i 341_357 357 93218.1
c_341_357_i 341 341_357 2.08965e-09
r_901_917_e 901 917 13376.4
r_901_917_i 901_917 917 93218.1
c_901_917_i 901 901_917 2.08965e-09
r_1461_1477_e 1461 1477 836.944
r_1461_1477_i 1461_1477 1477 4256.89
c_1461_1477_i 1461 1461_1477 4.67522e-10
r_2021_2037_e 2021 2037 836.944
r_2021_2037_i 2021_2037 2037 4256.89
c_2021_2037_i 2021 2021_2037 4.67522e-10
r_2581_2597_e 2581 2597 836.944
r_2581_2597_i 2581_2597 2597 4256.89
c_2581_2597_i 2581 2581_2597 4.67522e-10
r_3141_3157_e 3141 3157 13758.3
r_3141_3157_i 3141_3157 3157 95645.6
c_3141_3157_i 3141 3141_3157 9.36084e-12
r_3701_3717_e 3701 3717 13758.3
r_3701_3717_i 3701_3717 3717 95645.6
c_3701_3717_i 3701 3701_3717 9.36084e-12
r_342_358_e 342 358 13376.4
r_342_358_i 342_358 358 93218.1
c_342_358_i 342 342_358 2.08965e-09
r_902_918_e 902 918 13376.4
r_902_918_i 902_918 918 93218.1
c_902_918_i 902 902_918 2.08965e-09
r_1462_1478_e 1462 1478 836.944
r_1462_1478_i 1462_1478 1478 4256.89
c_1462_1478_i 1462 1462_1478 4.67522e-10
r_2022_2038_e 2022 2038 836.944
r_2022_2038_i 2022_2038 2038 4256.89
c_2022_2038_i 2022 2022_2038 4.67522e-10
r_2582_2598_e 2582 2598 836.944
r_2582_2598_i 2582_2598 2598 4256.89
c_2582_2598_i 2582 2582_2598 4.67522e-10
r_3142_3158_e 3142 3158 13758.3
r_3142_3158_i 3142_3158 3158 95645.6
c_3142_3158_i 3142 3142_3158 9.36084e-12
r_3702_3718_e 3702 3718 13758.3
r_3702_3718_i 3702_3718 3718 95645.6
c_3702_3718_i 3702 3702_3718 9.36084e-12
r_343_359_e 343 359 13376.4
r_343_359_i 343_359 359 93218.1
c_343_359_i 343 343_359 2.08965e-09
r_903_919_e 903 919 13376.4
r_903_919_i 903_919 919 93218.1
c_903_919_i 903 903_919 2.08965e-09
r_1463_1479_e 1463 1479 836.944
r_1463_1479_i 1463_1479 1479 4256.89
c_1463_1479_i 1463 1463_1479 4.67522e-10
r_2023_2039_e 2023 2039 836.944
r_2023_2039_i 2023_2039 2039 4256.89
c_2023_2039_i 2023 2023_2039 4.67522e-10
r_2583_2599_e 2583 2599 836.944
r_2583_2599_i 2583_2599 2599 4256.89
c_2583_2599_i 2583 2583_2599 4.67522e-10
r_3143_3159_e 3143 3159 13758.3
r_3143_3159_i 3143_3159 3159 95645.6
c_3143_3159_i 3143 3143_3159 9.36084e-12
r_3703_3719_e 3703 3719 13758.3
r_3703_3719_i 3703_3719 3719 95645.6
c_3703_3719_i 3703 3703_3719 9.36084e-12
r_344_360_e 344 360 13376.4
r_344_360_i 344_360 360 93218.1
c_344_360_i 344 344_360 2.08965e-09
r_904_920_e 904 920 13376.4
r_904_920_i 904_920 920 93218.1
c_904_920_i 904 904_920 2.08965e-09
r_1464_1480_e 1464 1480 836.944
r_1464_1480_i 1464_1480 1480 4256.89
c_1464_1480_i 1464 1464_1480 4.67522e-10
r_2024_2040_e 2024 2040 836.944
r_2024_2040_i 2024_2040 2040 4256.89
c_2024_2040_i 2024 2024_2040 4.67522e-10
r_2584_2600_e 2584 2600 836.944
r_2584_2600_i 2584_2600 2600 4256.89
c_2584_2600_i 2584 2584_2600 4.67522e-10
r_3144_3160_e 3144 3160 13758.3
r_3144_3160_i 3144_3160 3160 95645.6
c_3144_3160_i 3144 3144_3160 9.36084e-12
r_3704_3720_e 3704 3720 13758.3
r_3704_3720_i 3704_3720 3720 95645.6
c_3704_3720_i 3704 3704_3720 9.36084e-12
r_345_361_e 345 361 13376.4
r_345_361_i 345_361 361 93218.1
c_345_361_i 345 345_361 2.08965e-09
r_905_921_e 905 921 13376.4
r_905_921_i 905_921 921 93218.1
c_905_921_i 905 905_921 2.08965e-09
r_1465_1481_e 1465 1481 836.944
r_1465_1481_i 1465_1481 1481 4256.89
c_1465_1481_i 1465 1465_1481 4.67522e-10
r_2025_2041_e 2025 2041 836.944
r_2025_2041_i 2025_2041 2041 4256.89
c_2025_2041_i 2025 2025_2041 4.67522e-10
r_2585_2601_e 2585 2601 836.944
r_2585_2601_i 2585_2601 2601 4256.89
c_2585_2601_i 2585 2585_2601 4.67522e-10
r_3145_3161_e 3145 3161 13758.3
r_3145_3161_i 3145_3161 3161 95645.6
c_3145_3161_i 3145 3145_3161 9.36084e-12
r_3705_3721_e 3705 3721 13758.3
r_3705_3721_i 3705_3721 3721 95645.6
c_3705_3721_i 3705 3705_3721 9.36084e-12
r_346_362_e 346 362 13376.4
r_346_362_i 346_362 362 93218.1
c_346_362_i 346 346_362 2.08965e-09
r_906_922_e 906 922 13376.4
r_906_922_i 906_922 922 93218.1
c_906_922_i 906 906_922 2.08965e-09
r_1466_1482_e 1466 1482 836.944
r_1466_1482_i 1466_1482 1482 4256.89
c_1466_1482_i 1466 1466_1482 4.67522e-10
r_2026_2042_e 2026 2042 836.944
r_2026_2042_i 2026_2042 2042 4256.89
c_2026_2042_i 2026 2026_2042 4.67522e-10
r_2586_2602_e 2586 2602 836.944
r_2586_2602_i 2586_2602 2602 4256.89
c_2586_2602_i 2586 2586_2602 4.67522e-10
r_3146_3162_e 3146 3162 13758.3
r_3146_3162_i 3146_3162 3162 95645.6
c_3146_3162_i 3146 3146_3162 9.36084e-12
r_3706_3722_e 3706 3722 13758.3
r_3706_3722_i 3706_3722 3722 95645.6
c_3706_3722_i 3706 3706_3722 9.36084e-12
r_347_363_e 347 363 13376.4
r_347_363_i 347_363 363 93218.1
c_347_363_i 347 347_363 2.08965e-09
r_907_923_e 907 923 396.585
r_907_923_i 907_923 923 1004.98
c_907_923_i 907 907_923 1.65842e-10
r_1467_1483_e 1467 1483 396.585
r_1467_1483_i 1467_1483 1483 1004.98
c_1467_1483_i 1467 1467_1483 1.65842e-10
r_2027_2043_e 2027 2043 836.944
r_2027_2043_i 2027_2043 2043 4256.89
c_2027_2043_i 2027 2027_2043 4.67522e-10
r_2587_2603_e 2587 2603 836.944
r_2587_2603_i 2587_2603 2603 4256.89
c_2587_2603_i 2587 2587_2603 4.67522e-10
r_3147_3163_e 3147 3163 13758.3
r_3147_3163_i 3147_3163 3163 95645.6
c_3147_3163_i 3147 3147_3163 9.36084e-12
r_3707_3723_e 3707 3723 13758.3
r_3707_3723_i 3707_3723 3723 95645.6
c_3707_3723_i 3707 3707_3723 9.36084e-12
r_348_364_e 348 364 13376.4
r_348_364_i 348_364 364 93218.1
c_348_364_i 348 348_364 2.08965e-09
r_908_924_e 908 924 396.585
r_908_924_i 908_924 924 1004.98
c_908_924_i 908 908_924 1.65842e-10
r_1468_1484_e 1468 1484 396.585
r_1468_1484_i 1468_1484 1484 1004.98
c_1468_1484_i 1468 1468_1484 1.65842e-10
r_2028_2044_e 2028 2044 836.944
r_2028_2044_i 2028_2044 2044 4256.89
c_2028_2044_i 2028 2028_2044 4.67522e-10
r_2588_2604_e 2588 2604 836.944
r_2588_2604_i 2588_2604 2604 4256.89
c_2588_2604_i 2588 2588_2604 4.67522e-10
r_3148_3164_e 3148 3164 13758.3
r_3148_3164_i 3148_3164 3164 95645.6
c_3148_3164_i 3148 3148_3164 9.36084e-12
r_3708_3724_e 3708 3724 13758.3
r_3708_3724_i 3708_3724 3724 95645.6
c_3708_3724_i 3708 3708_3724 9.36084e-12
r_349_365_e 349 365 13376.4
r_349_365_i 349_365 365 93218.1
c_349_365_i 349 349_365 2.08965e-09
r_909_925_e 909 925 13376.4
r_909_925_i 909_925 925 93218.1
c_909_925_i 909 909_925 2.08965e-09
r_1469_1485_e 1469 1485 836.944
r_1469_1485_i 1469_1485 1485 4256.89
c_1469_1485_i 1469 1469_1485 4.67522e-10
r_2029_2045_e 2029 2045 836.944
r_2029_2045_i 2029_2045 2045 4256.89
c_2029_2045_i 2029 2029_2045 4.67522e-10
r_2589_2605_e 2589 2605 836.944
r_2589_2605_i 2589_2605 2605 4256.89
c_2589_2605_i 2589 2589_2605 4.67522e-10
r_3149_3165_e 3149 3165 13758.3
r_3149_3165_i 3149_3165 3165 95645.6
c_3149_3165_i 3149 3149_3165 9.36084e-12
r_3709_3725_e 3709 3725 13758.3
r_3709_3725_i 3709_3725 3725 95645.6
c_3709_3725_i 3709 3709_3725 9.36084e-12
r_350_366_e 350 366 13376.4
r_350_366_i 350_366 366 93218.1
c_350_366_i 350 350_366 2.08965e-09
r_910_926_e 910 926 13376.4
r_910_926_i 910_926 926 93218.1
c_910_926_i 910 910_926 2.08965e-09
r_1470_1486_e 1470 1486 836.944
r_1470_1486_i 1470_1486 1486 4256.89
c_1470_1486_i 1470 1470_1486 4.67522e-10
r_2030_2046_e 2030 2046 836.944
r_2030_2046_i 2030_2046 2046 4256.89
c_2030_2046_i 2030 2030_2046 4.67522e-10
r_2590_2606_e 2590 2606 836.944
r_2590_2606_i 2590_2606 2606 4256.89
c_2590_2606_i 2590 2590_2606 4.67522e-10
r_3150_3166_e 3150 3166 13758.3
r_3150_3166_i 3150_3166 3166 95645.6
c_3150_3166_i 3150 3150_3166 9.36084e-12
r_3710_3726_e 3710 3726 13758.3
r_3710_3726_i 3710_3726 3726 95645.6
c_3710_3726_i 3710 3710_3726 9.36084e-12
r_351_367_e 351 367 13376.4
r_351_367_i 351_367 367 93218.1
c_351_367_i 351 351_367 2.08965e-09
r_911_927_e 911 927 13376.4
r_911_927_i 911_927 927 93218.1
c_911_927_i 911 911_927 2.08965e-09
r_1471_1487_e 1471 1487 836.944
r_1471_1487_i 1471_1487 1487 4256.89
c_1471_1487_i 1471 1471_1487 4.67522e-10
r_2031_2047_e 2031 2047 836.944
r_2031_2047_i 2031_2047 2047 4256.89
c_2031_2047_i 2031 2031_2047 4.67522e-10
r_2591_2607_e 2591 2607 836.944
r_2591_2607_i 2591_2607 2607 4256.89
c_2591_2607_i 2591 2591_2607 4.67522e-10
r_3151_3167_e 3151 3167 13758.3
r_3151_3167_i 3151_3167 3167 95645.6
c_3151_3167_i 3151 3151_3167 9.36084e-12
r_3711_3727_e 3711 3727 13758.3
r_3711_3727_i 3711_3727 3727 95645.6
c_3711_3727_i 3711 3711_3727 9.36084e-12
r_352_368_e 352 368 13376.4
r_352_368_i 352_368 368 93218.1
c_352_368_i 352 352_368 2.08965e-09
r_912_928_e 912 928 13376.4
r_912_928_i 912_928 928 93218.1
c_912_928_i 912 912_928 2.08965e-09
r_1472_1488_e 1472 1488 836.944
r_1472_1488_i 1472_1488 1488 4256.89
c_1472_1488_i 1472 1472_1488 4.67522e-10
r_2032_2048_e 2032 2048 836.944
r_2032_2048_i 2032_2048 2048 4256.89
c_2032_2048_i 2032 2032_2048 4.67522e-10
r_2592_2608_e 2592 2608 836.944
r_2592_2608_i 2592_2608 2608 4256.89
c_2592_2608_i 2592 2592_2608 4.67522e-10
r_3152_3168_e 3152 3168 13758.3
r_3152_3168_i 3152_3168 3168 95645.6
c_3152_3168_i 3152 3152_3168 9.36084e-12
r_3712_3728_e 3712 3728 13758.3
r_3712_3728_i 3712_3728 3728 95645.6
c_3712_3728_i 3712 3712_3728 9.36084e-12
r_353_369_e 353 369 13376.4
r_353_369_i 353_369 369 93218.1
c_353_369_i 353 353_369 2.08965e-09
r_913_929_e 913 929 13376.4
r_913_929_i 913_929 929 93218.1
c_913_929_i 913 913_929 2.08965e-09
r_1473_1489_e 1473 1489 13376.4
r_1473_1489_i 1473_1489 1489 93218.1
c_1473_1489_i 1473 1473_1489 2.08965e-09
r_2033_2049_e 2033 2049 13376.4
r_2033_2049_i 2033_2049 2049 93218.1
c_2033_2049_i 2033 2033_2049 2.08965e-09
r_2593_2609_e 2593 2609 13376.4
r_2593_2609_i 2593_2609 2609 93218.1
c_2593_2609_i 2593 2593_2609 2.08965e-09
r_3153_3169_e 3153 3169 13376.4
r_3153_3169_i 3153_3169 3169 93218.1
c_3153_3169_i 3153 3153_3169 2.08965e-09
r_3713_3729_e 3713 3729 13376.4
r_3713_3729_i 3713_3729 3729 93218.1
c_3713_3729_i 3713 3713_3729 2.08965e-09
r_354_370_e 354 370 13376.4
r_354_370_i 354_370 370 93218.1
c_354_370_i 354 354_370 2.08965e-09
r_914_930_e 914 930 13376.4
r_914_930_i 914_930 930 93218.1
c_914_930_i 914 914_930 2.08965e-09
r_1474_1490_e 1474 1490 13376.4
r_1474_1490_i 1474_1490 1490 93218.1
c_1474_1490_i 1474 1474_1490 2.08965e-09
r_2034_2050_e 2034 2050 13376.4
r_2034_2050_i 2034_2050 2050 93218.1
c_2034_2050_i 2034 2034_2050 2.08965e-09
r_2594_2610_e 2594 2610 13376.4
r_2594_2610_i 2594_2610 2610 93218.1
c_2594_2610_i 2594 2594_2610 2.08965e-09
r_3154_3170_e 3154 3170 13376.4
r_3154_3170_i 3154_3170 3170 93218.1
c_3154_3170_i 3154 3154_3170 2.08965e-09
r_3714_3730_e 3714 3730 13376.4
r_3714_3730_i 3714_3730 3730 93218.1
c_3714_3730_i 3714 3714_3730 2.08965e-09
r_355_371_e 355 371 13376.4
r_355_371_i 355_371 371 93218.1
c_355_371_i 355 355_371 2.08965e-09
r_915_931_e 915 931 13376.4
r_915_931_i 915_931 931 93218.1
c_915_931_i 915 915_931 2.08965e-09
r_1475_1491_e 1475 1491 836.944
r_1475_1491_i 1475_1491 1491 4256.89
c_1475_1491_i 1475 1475_1491 4.67522e-10
r_2035_2051_e 2035 2051 836.944
r_2035_2051_i 2035_2051 2051 4256.89
c_2035_2051_i 2035 2035_2051 4.67522e-10
r_2595_2611_e 2595 2611 836.944
r_2595_2611_i 2595_2611 2611 4256.89
c_2595_2611_i 2595 2595_2611 4.67522e-10
r_3155_3171_e 3155 3171 836.944
r_3155_3171_i 3155_3171 3171 4256.89
c_3155_3171_i 3155 3155_3171 4.67522e-10
r_3715_3731_e 3715 3731 836.944
r_3715_3731_i 3715_3731 3731 4256.89
c_3715_3731_i 3715 3715_3731 4.67522e-10
r_356_372_e 356 372 13376.4
r_356_372_i 356_372 372 93218.1
c_356_372_i 356 356_372 2.08965e-09
r_916_932_e 916 932 13376.4
r_916_932_i 916_932 932 93218.1
c_916_932_i 916 916_932 2.08965e-09
r_1476_1492_e 1476 1492 836.944
r_1476_1492_i 1476_1492 1492 4256.89
c_1476_1492_i 1476 1476_1492 4.67522e-10
r_2036_2052_e 2036 2052 836.944
r_2036_2052_i 2036_2052 2052 4256.89
c_2036_2052_i 2036 2036_2052 4.67522e-10
r_2596_2612_e 2596 2612 836.944
r_2596_2612_i 2596_2612 2612 4256.89
c_2596_2612_i 2596 2596_2612 4.67522e-10
r_3156_3172_e 3156 3172 13758.3
r_3156_3172_i 3156_3172 3172 95645.6
c_3156_3172_i 3156 3156_3172 9.36084e-12
r_3716_3732_e 3716 3732 13758.3
r_3716_3732_i 3716_3732 3732 95645.6
c_3716_3732_i 3716 3716_3732 9.36084e-12
r_357_373_e 357 373 13376.4
r_357_373_i 357_373 373 93218.1
c_357_373_i 357 357_373 2.08965e-09
r_917_933_e 917 933 13376.4
r_917_933_i 917_933 933 93218.1
c_917_933_i 917 917_933 2.08965e-09
r_1477_1493_e 1477 1493 836.944
r_1477_1493_i 1477_1493 1493 4256.89
c_1477_1493_i 1477 1477_1493 4.67522e-10
r_2037_2053_e 2037 2053 836.944
r_2037_2053_i 2037_2053 2053 4256.89
c_2037_2053_i 2037 2037_2053 4.67522e-10
r_2597_2613_e 2597 2613 836.944
r_2597_2613_i 2597_2613 2613 4256.89
c_2597_2613_i 2597 2597_2613 4.67522e-10
r_3157_3173_e 3157 3173 13758.3
r_3157_3173_i 3157_3173 3173 95645.6
c_3157_3173_i 3157 3157_3173 9.36084e-12
r_3717_3733_e 3717 3733 13758.3
r_3717_3733_i 3717_3733 3733 95645.6
c_3717_3733_i 3717 3717_3733 9.36084e-12
r_358_374_e 358 374 13376.4
r_358_374_i 358_374 374 93218.1
c_358_374_i 358 358_374 2.08965e-09
r_918_934_e 918 934 13376.4
r_918_934_i 918_934 934 93218.1
c_918_934_i 918 918_934 2.08965e-09
r_1478_1494_e 1478 1494 836.944
r_1478_1494_i 1478_1494 1494 4256.89
c_1478_1494_i 1478 1478_1494 4.67522e-10
r_2038_2054_e 2038 2054 836.944
r_2038_2054_i 2038_2054 2054 4256.89
c_2038_2054_i 2038 2038_2054 4.67522e-10
r_2598_2614_e 2598 2614 836.944
r_2598_2614_i 2598_2614 2614 4256.89
c_2598_2614_i 2598 2598_2614 4.67522e-10
r_3158_3174_e 3158 3174 13758.3
r_3158_3174_i 3158_3174 3174 95645.6
c_3158_3174_i 3158 3158_3174 9.36084e-12
r_3718_3734_e 3718 3734 13758.3
r_3718_3734_i 3718_3734 3734 95645.6
c_3718_3734_i 3718 3718_3734 9.36084e-12
r_359_375_e 359 375 13376.4
r_359_375_i 359_375 375 93218.1
c_359_375_i 359 359_375 2.08965e-09
r_919_935_e 919 935 13376.4
r_919_935_i 919_935 935 93218.1
c_919_935_i 919 919_935 2.08965e-09
r_1479_1495_e 1479 1495 836.944
r_1479_1495_i 1479_1495 1495 4256.89
c_1479_1495_i 1479 1479_1495 4.67522e-10
r_2039_2055_e 2039 2055 836.944
r_2039_2055_i 2039_2055 2055 4256.89
c_2039_2055_i 2039 2039_2055 4.67522e-10
r_2599_2615_e 2599 2615 836.944
r_2599_2615_i 2599_2615 2615 4256.89
c_2599_2615_i 2599 2599_2615 4.67522e-10
r_3159_3175_e 3159 3175 13758.3
r_3159_3175_i 3159_3175 3175 95645.6
c_3159_3175_i 3159 3159_3175 9.36084e-12
r_3719_3735_e 3719 3735 13758.3
r_3719_3735_i 3719_3735 3735 95645.6
c_3719_3735_i 3719 3719_3735 9.36084e-12
r_360_376_e 360 376 13376.4
r_360_376_i 360_376 376 93218.1
c_360_376_i 360 360_376 2.08965e-09
r_920_936_e 920 936 13376.4
r_920_936_i 920_936 936 93218.1
c_920_936_i 920 920_936 2.08965e-09
r_1480_1496_e 1480 1496 836.944
r_1480_1496_i 1480_1496 1496 4256.89
c_1480_1496_i 1480 1480_1496 4.67522e-10
r_2040_2056_e 2040 2056 836.944
r_2040_2056_i 2040_2056 2056 4256.89
c_2040_2056_i 2040 2040_2056 4.67522e-10
r_2600_2616_e 2600 2616 836.944
r_2600_2616_i 2600_2616 2616 4256.89
c_2600_2616_i 2600 2600_2616 4.67522e-10
r_3160_3176_e 3160 3176 13758.3
r_3160_3176_i 3160_3176 3176 95645.6
c_3160_3176_i 3160 3160_3176 9.36084e-12
r_3720_3736_e 3720 3736 13758.3
r_3720_3736_i 3720_3736 3736 95645.6
c_3720_3736_i 3720 3720_3736 9.36084e-12
r_361_377_e 361 377 13376.4
r_361_377_i 361_377 377 93218.1
c_361_377_i 361 361_377 2.08965e-09
r_921_937_e 921 937 13376.4
r_921_937_i 921_937 937 93218.1
c_921_937_i 921 921_937 2.08965e-09
r_1481_1497_e 1481 1497 836.944
r_1481_1497_i 1481_1497 1497 4256.89
c_1481_1497_i 1481 1481_1497 4.67522e-10
r_2041_2057_e 2041 2057 836.944
r_2041_2057_i 2041_2057 2057 4256.89
c_2041_2057_i 2041 2041_2057 4.67522e-10
r_2601_2617_e 2601 2617 836.944
r_2601_2617_i 2601_2617 2617 4256.89
c_2601_2617_i 2601 2601_2617 4.67522e-10
r_3161_3177_e 3161 3177 13758.3
r_3161_3177_i 3161_3177 3177 95645.6
c_3161_3177_i 3161 3161_3177 9.36084e-12
r_3721_3737_e 3721 3737 13758.3
r_3721_3737_i 3721_3737 3737 95645.6
c_3721_3737_i 3721 3721_3737 9.36084e-12
r_362_378_e 362 378 13376.4
r_362_378_i 362_378 378 93218.1
c_362_378_i 362 362_378 2.08965e-09
r_922_938_e 922 938 13376.4
r_922_938_i 922_938 938 93218.1
c_922_938_i 922 922_938 2.08965e-09
r_1482_1498_e 1482 1498 836.944
r_1482_1498_i 1482_1498 1498 4256.89
c_1482_1498_i 1482 1482_1498 4.67522e-10
r_2042_2058_e 2042 2058 836.944
r_2042_2058_i 2042_2058 2058 4256.89
c_2042_2058_i 2042 2042_2058 4.67522e-10
r_2602_2618_e 2602 2618 836.944
r_2602_2618_i 2602_2618 2618 4256.89
c_2602_2618_i 2602 2602_2618 4.67522e-10
r_3162_3178_e 3162 3178 13758.3
r_3162_3178_i 3162_3178 3178 95645.6
c_3162_3178_i 3162 3162_3178 9.36084e-12
r_3722_3738_e 3722 3738 13758.3
r_3722_3738_i 3722_3738 3738 95645.6
c_3722_3738_i 3722 3722_3738 9.36084e-12
r_363_379_e 363 379 13376.4
r_363_379_i 363_379 379 93218.1
c_363_379_i 363 363_379 2.08965e-09
r_923_939_e 923 939 396.576
r_923_939_i 923_939 939 1004.96
c_923_939_i 923 923_939 1.65845e-10
r_1483_1499_e 1483 1499 396.576
r_1483_1499_i 1483_1499 1499 1004.96
c_1483_1499_i 1483 1483_1499 1.65845e-10
r_2043_2059_e 2043 2059 836.944
r_2043_2059_i 2043_2059 2059 4256.89
c_2043_2059_i 2043 2043_2059 4.67522e-10
r_2603_2619_e 2603 2619 836.944
r_2603_2619_i 2603_2619 2619 4256.89
c_2603_2619_i 2603 2603_2619 4.67522e-10
r_3163_3179_e 3163 3179 13758.3
r_3163_3179_i 3163_3179 3179 95645.6
c_3163_3179_i 3163 3163_3179 9.36084e-12
r_3723_3739_e 3723 3739 13758.3
r_3723_3739_i 3723_3739 3739 95645.6
c_3723_3739_i 3723 3723_3739 9.36084e-12
r_364_380_e 364 380 13376.4
r_364_380_i 364_380 380 93218.1
c_364_380_i 364 364_380 2.08965e-09
r_924_940_e 924 940 396.576
r_924_940_i 924_940 940 1004.96
c_924_940_i 924 924_940 1.65845e-10
r_1484_1500_e 1484 1500 396.576
r_1484_1500_i 1484_1500 1500 1004.96
c_1484_1500_i 1484 1484_1500 1.65845e-10
r_2044_2060_e 2044 2060 836.944
r_2044_2060_i 2044_2060 2060 4256.89
c_2044_2060_i 2044 2044_2060 4.67522e-10
r_2604_2620_e 2604 2620 836.944
r_2604_2620_i 2604_2620 2620 4256.89
c_2604_2620_i 2604 2604_2620 4.67522e-10
r_3164_3180_e 3164 3180 13758.3
r_3164_3180_i 3164_3180 3180 95645.6
c_3164_3180_i 3164 3164_3180 9.36084e-12
r_3724_3740_e 3724 3740 13758.3
r_3724_3740_i 3724_3740 3740 95645.6
c_3724_3740_i 3724 3724_3740 9.36084e-12
r_365_381_e 365 381 13376.4
r_365_381_i 365_381 381 93218.1
c_365_381_i 365 365_381 2.08965e-09
r_925_941_e 925 941 13376.4
r_925_941_i 925_941 941 93218.1
c_925_941_i 925 925_941 2.08965e-09
r_1485_1501_e 1485 1501 836.944
r_1485_1501_i 1485_1501 1501 4256.89
c_1485_1501_i 1485 1485_1501 4.67522e-10
r_2045_2061_e 2045 2061 836.944
r_2045_2061_i 2045_2061 2061 4256.89
c_2045_2061_i 2045 2045_2061 4.67522e-10
r_2605_2621_e 2605 2621 836.944
r_2605_2621_i 2605_2621 2621 4256.89
c_2605_2621_i 2605 2605_2621 4.67522e-10
r_3165_3181_e 3165 3181 13758.3
r_3165_3181_i 3165_3181 3181 95645.6
c_3165_3181_i 3165 3165_3181 9.36084e-12
r_3725_3741_e 3725 3741 13758.3
r_3725_3741_i 3725_3741 3741 95645.6
c_3725_3741_i 3725 3725_3741 9.36084e-12
r_366_382_e 366 382 13376.4
r_366_382_i 366_382 382 93218.1
c_366_382_i 366 366_382 2.08965e-09
r_926_942_e 926 942 13376.4
r_926_942_i 926_942 942 93218.1
c_926_942_i 926 926_942 2.08965e-09
r_1486_1502_e 1486 1502 836.944
r_1486_1502_i 1486_1502 1502 4256.89
c_1486_1502_i 1486 1486_1502 4.67522e-10
r_2046_2062_e 2046 2062 836.944
r_2046_2062_i 2046_2062 2062 4256.89
c_2046_2062_i 2046 2046_2062 4.67522e-10
r_2606_2622_e 2606 2622 836.944
r_2606_2622_i 2606_2622 2622 4256.89
c_2606_2622_i 2606 2606_2622 4.67522e-10
r_3166_3182_e 3166 3182 13758.3
r_3166_3182_i 3166_3182 3182 95645.6
c_3166_3182_i 3166 3166_3182 9.36084e-12
r_3726_3742_e 3726 3742 13758.3
r_3726_3742_i 3726_3742 3742 95645.6
c_3726_3742_i 3726 3726_3742 9.36084e-12
r_367_383_e 367 383 13376.4
r_367_383_i 367_383 383 93218.1
c_367_383_i 367 367_383 2.08965e-09
r_927_943_e 927 943 13376.4
r_927_943_i 927_943 943 93218.1
c_927_943_i 927 927_943 2.08965e-09
r_1487_1503_e 1487 1503 836.944
r_1487_1503_i 1487_1503 1503 4256.89
c_1487_1503_i 1487 1487_1503 4.67522e-10
r_2047_2063_e 2047 2063 836.944
r_2047_2063_i 2047_2063 2063 4256.89
c_2047_2063_i 2047 2047_2063 4.67522e-10
r_2607_2623_e 2607 2623 836.944
r_2607_2623_i 2607_2623 2623 4256.89
c_2607_2623_i 2607 2607_2623 4.67522e-10
r_3167_3183_e 3167 3183 13758.3
r_3167_3183_i 3167_3183 3183 95645.6
c_3167_3183_i 3167 3167_3183 9.36084e-12
r_3727_3743_e 3727 3743 13758.3
r_3727_3743_i 3727_3743 3743 95645.6
c_3727_3743_i 3727 3727_3743 9.36084e-12
r_368_384_e 368 384 13376.4
r_368_384_i 368_384 384 93218.1
c_368_384_i 368 368_384 2.08965e-09
r_928_944_e 928 944 13376.4
r_928_944_i 928_944 944 93218.1
c_928_944_i 928 928_944 2.08965e-09
r_1488_1504_e 1488 1504 836.944
r_1488_1504_i 1488_1504 1504 4256.89
c_1488_1504_i 1488 1488_1504 4.67522e-10
r_2048_2064_e 2048 2064 836.944
r_2048_2064_i 2048_2064 2064 4256.89
c_2048_2064_i 2048 2048_2064 4.67522e-10
r_2608_2624_e 2608 2624 836.944
r_2608_2624_i 2608_2624 2624 4256.89
c_2608_2624_i 2608 2608_2624 4.67522e-10
r_3168_3184_e 3168 3184 13758.3
r_3168_3184_i 3168_3184 3184 95645.6
c_3168_3184_i 3168 3168_3184 9.36084e-12
r_3728_3744_e 3728 3744 13758.3
r_3728_3744_i 3728_3744 3744 95645.6
c_3728_3744_i 3728 3728_3744 9.36084e-12
r_369_385_e 369 385 13376.4
r_369_385_i 369_385 385 93218.1
c_369_385_i 369 369_385 2.08965e-09
r_929_945_e 929 945 13376.4
r_929_945_i 929_945 945 93218.1
c_929_945_i 929 929_945 2.08965e-09
r_1489_1505_e 1489 1505 13376.4
r_1489_1505_i 1489_1505 1505 93218.1
c_1489_1505_i 1489 1489_1505 2.08965e-09
r_2049_2065_e 2049 2065 13376.4
r_2049_2065_i 2049_2065 2065 93218.1
c_2049_2065_i 2049 2049_2065 2.08965e-09
r_2609_2625_e 2609 2625 13376.4
r_2609_2625_i 2609_2625 2625 93218.1
c_2609_2625_i 2609 2609_2625 2.08965e-09
r_3169_3185_e 3169 3185 13376.4
r_3169_3185_i 3169_3185 3185 93218.1
c_3169_3185_i 3169 3169_3185 2.08965e-09
r_3729_3745_e 3729 3745 13376.4
r_3729_3745_i 3729_3745 3745 93218.1
c_3729_3745_i 3729 3729_3745 2.08965e-09
r_370_386_e 370 386 13376.4
r_370_386_i 370_386 386 93218.1
c_370_386_i 370 370_386 2.08965e-09
r_930_946_e 930 946 13376.4
r_930_946_i 930_946 946 93218.1
c_930_946_i 930 930_946 2.08965e-09
r_1490_1506_e 1490 1506 13376.4
r_1490_1506_i 1490_1506 1506 93218.1
c_1490_1506_i 1490 1490_1506 2.08965e-09
r_2050_2066_e 2050 2066 13376.4
r_2050_2066_i 2050_2066 2066 93218.1
c_2050_2066_i 2050 2050_2066 2.08965e-09
r_2610_2626_e 2610 2626 13376.4
r_2610_2626_i 2610_2626 2626 93218.1
c_2610_2626_i 2610 2610_2626 2.08965e-09
r_3170_3186_e 3170 3186 13376.4
r_3170_3186_i 3170_3186 3186 93218.1
c_3170_3186_i 3170 3170_3186 2.08965e-09
r_3730_3746_e 3730 3746 13376.4
r_3730_3746_i 3730_3746 3746 93218.1
c_3730_3746_i 3730 3730_3746 2.08965e-09
r_371_387_e 371 387 13376.4
r_371_387_i 371_387 387 93218.1
c_371_387_i 371 371_387 2.08965e-09
r_931_947_e 931 947 13376.4
r_931_947_i 931_947 947 93218.1
c_931_947_i 931 931_947 2.08965e-09
r_1491_1507_e 1491 1507 836.944
r_1491_1507_i 1491_1507 1507 4256.89
c_1491_1507_i 1491 1491_1507 4.67522e-10
r_2051_2067_e 2051 2067 836.944
r_2051_2067_i 2051_2067 2067 4256.89
c_2051_2067_i 2051 2051_2067 4.67522e-10
r_2611_2627_e 2611 2627 836.944
r_2611_2627_i 2611_2627 2627 4256.89
c_2611_2627_i 2611 2611_2627 4.67522e-10
r_3171_3187_e 3171 3187 836.944
r_3171_3187_i 3171_3187 3187 4256.89
c_3171_3187_i 3171 3171_3187 4.67522e-10
r_3731_3747_e 3731 3747 836.944
r_3731_3747_i 3731_3747 3747 4256.89
c_3731_3747_i 3731 3731_3747 4.67522e-10
r_372_388_e 372 388 13376.4
r_372_388_i 372_388 388 93218.1
c_372_388_i 372 372_388 2.08965e-09
r_932_948_e 932 948 13376.4
r_932_948_i 932_948 948 93218.1
c_932_948_i 932 932_948 2.08965e-09
r_1492_1508_e 1492 1508 836.944
r_1492_1508_i 1492_1508 1508 4256.89
c_1492_1508_i 1492 1492_1508 4.67522e-10
r_2052_2068_e 2052 2068 836.944
r_2052_2068_i 2052_2068 2068 4256.89
c_2052_2068_i 2052 2052_2068 4.67522e-10
r_2612_2628_e 2612 2628 836.944
r_2612_2628_i 2612_2628 2628 4256.89
c_2612_2628_i 2612 2612_2628 4.67522e-10
r_3172_3188_e 3172 3188 13758.3
r_3172_3188_i 3172_3188 3188 95645.6
c_3172_3188_i 3172 3172_3188 9.36084e-12
r_3732_3748_e 3732 3748 13758.3
r_3732_3748_i 3732_3748 3748 95645.6
c_3732_3748_i 3732 3732_3748 9.36084e-12
r_373_389_e 373 389 13376.4
r_373_389_i 373_389 389 93218.1
c_373_389_i 373 373_389 2.08965e-09
r_933_949_e 933 949 13376.4
r_933_949_i 933_949 949 93218.1
c_933_949_i 933 933_949 2.08965e-09
r_1493_1509_e 1493 1509 836.944
r_1493_1509_i 1493_1509 1509 4256.89
c_1493_1509_i 1493 1493_1509 4.67522e-10
r_2053_2069_e 2053 2069 836.944
r_2053_2069_i 2053_2069 2069 4256.89
c_2053_2069_i 2053 2053_2069 4.67522e-10
r_2613_2629_e 2613 2629 836.944
r_2613_2629_i 2613_2629 2629 4256.89
c_2613_2629_i 2613 2613_2629 4.67522e-10
r_3173_3189_e 3173 3189 13758.3
r_3173_3189_i 3173_3189 3189 95645.6
c_3173_3189_i 3173 3173_3189 9.36084e-12
r_3733_3749_e 3733 3749 13758.3
r_3733_3749_i 3733_3749 3749 95645.6
c_3733_3749_i 3733 3733_3749 9.36084e-12
r_374_390_e 374 390 13376.4
r_374_390_i 374_390 390 93218.1
c_374_390_i 374 374_390 2.08965e-09
r_934_950_e 934 950 13376.4
r_934_950_i 934_950 950 93218.1
c_934_950_i 934 934_950 2.08965e-09
r_1494_1510_e 1494 1510 836.944
r_1494_1510_i 1494_1510 1510 4256.89
c_1494_1510_i 1494 1494_1510 4.67522e-10
r_2054_2070_e 2054 2070 836.944
r_2054_2070_i 2054_2070 2070 4256.89
c_2054_2070_i 2054 2054_2070 4.67522e-10
r_2614_2630_e 2614 2630 836.944
r_2614_2630_i 2614_2630 2630 4256.89
c_2614_2630_i 2614 2614_2630 4.67522e-10
r_3174_3190_e 3174 3190 13758.3
r_3174_3190_i 3174_3190 3190 95645.6
c_3174_3190_i 3174 3174_3190 9.36084e-12
r_3734_3750_e 3734 3750 13758.3
r_3734_3750_i 3734_3750 3750 95645.6
c_3734_3750_i 3734 3734_3750 9.36084e-12
r_375_391_e 375 391 13376.4
r_375_391_i 375_391 391 93218.1
c_375_391_i 375 375_391 2.08965e-09
r_935_951_e 935 951 13376.4
r_935_951_i 935_951 951 93218.1
c_935_951_i 935 935_951 2.08965e-09
r_1495_1511_e 1495 1511 836.944
r_1495_1511_i 1495_1511 1511 4256.89
c_1495_1511_i 1495 1495_1511 4.67522e-10
r_2055_2071_e 2055 2071 836.944
r_2055_2071_i 2055_2071 2071 4256.89
c_2055_2071_i 2055 2055_2071 4.67522e-10
r_2615_2631_e 2615 2631 836.944
r_2615_2631_i 2615_2631 2631 4256.89
c_2615_2631_i 2615 2615_2631 4.67522e-10
r_3175_3191_e 3175 3191 13758.3
r_3175_3191_i 3175_3191 3191 95645.6
c_3175_3191_i 3175 3175_3191 9.36084e-12
r_3735_3751_e 3735 3751 13758.3
r_3735_3751_i 3735_3751 3751 95645.6
c_3735_3751_i 3735 3735_3751 9.36084e-12
r_376_392_e 376 392 13376.4
r_376_392_i 376_392 392 93218.1
c_376_392_i 376 376_392 2.08965e-09
r_936_952_e 936 952 13376.4
r_936_952_i 936_952 952 93218.1
c_936_952_i 936 936_952 2.08965e-09
r_1496_1512_e 1496 1512 836.944
r_1496_1512_i 1496_1512 1512 4256.89
c_1496_1512_i 1496 1496_1512 4.67522e-10
r_2056_2072_e 2056 2072 836.944
r_2056_2072_i 2056_2072 2072 4256.89
c_2056_2072_i 2056 2056_2072 4.67522e-10
r_2616_2632_e 2616 2632 836.944
r_2616_2632_i 2616_2632 2632 4256.89
c_2616_2632_i 2616 2616_2632 4.67522e-10
r_3176_3192_e 3176 3192 13758.3
r_3176_3192_i 3176_3192 3192 95645.6
c_3176_3192_i 3176 3176_3192 9.36084e-12
r_3736_3752_e 3736 3752 13758.3
r_3736_3752_i 3736_3752 3752 95645.6
c_3736_3752_i 3736 3736_3752 9.36084e-12
r_377_393_e 377 393 13376.4
r_377_393_i 377_393 393 93218.1
c_377_393_i 377 377_393 2.08965e-09
r_937_953_e 937 953 13376.4
r_937_953_i 937_953 953 93218.1
c_937_953_i 937 937_953 2.08965e-09
r_1497_1513_e 1497 1513 836.944
r_1497_1513_i 1497_1513 1513 4256.89
c_1497_1513_i 1497 1497_1513 4.67522e-10
r_2057_2073_e 2057 2073 836.944
r_2057_2073_i 2057_2073 2073 4256.89
c_2057_2073_i 2057 2057_2073 4.67522e-10
r_2617_2633_e 2617 2633 836.944
r_2617_2633_i 2617_2633 2633 4256.89
c_2617_2633_i 2617 2617_2633 4.67522e-10
r_3177_3193_e 3177 3193 13758.3
r_3177_3193_i 3177_3193 3193 95645.6
c_3177_3193_i 3177 3177_3193 9.36084e-12
r_3737_3753_e 3737 3753 13758.3
r_3737_3753_i 3737_3753 3753 95645.6
c_3737_3753_i 3737 3737_3753 9.36084e-12
r_378_394_e 378 394 13376.4
r_378_394_i 378_394 394 93218.1
c_378_394_i 378 378_394 2.08965e-09
r_938_954_e 938 954 13376.4
r_938_954_i 938_954 954 93218.1
c_938_954_i 938 938_954 2.08965e-09
r_1498_1514_e 1498 1514 836.944
r_1498_1514_i 1498_1514 1514 4256.89
c_1498_1514_i 1498 1498_1514 4.67522e-10
r_2058_2074_e 2058 2074 836.944
r_2058_2074_i 2058_2074 2074 4256.89
c_2058_2074_i 2058 2058_2074 4.67522e-10
r_2618_2634_e 2618 2634 836.944
r_2618_2634_i 2618_2634 2634 4256.89
c_2618_2634_i 2618 2618_2634 4.67522e-10
r_3178_3194_e 3178 3194 13758.3
r_3178_3194_i 3178_3194 3194 95645.6
c_3178_3194_i 3178 3178_3194 9.36084e-12
r_3738_3754_e 3738 3754 13758.3
r_3738_3754_i 3738_3754 3754 95645.6
c_3738_3754_i 3738 3738_3754 9.36084e-12
r_379_395_e 379 395 13376.4
r_379_395_i 379_395 395 93218.1
c_379_395_i 379 379_395 2.08965e-09
r_939_955_e 939 955 396.568
r_939_955_i 939_955 955 1004.94
c_939_955_i 939 939_955 1.65849e-10
r_1499_1515_e 1499 1515 396.568
r_1499_1515_i 1499_1515 1515 1004.94
c_1499_1515_i 1499 1499_1515 1.65849e-10
r_2059_2075_e 2059 2075 836.944
r_2059_2075_i 2059_2075 2075 4256.89
c_2059_2075_i 2059 2059_2075 4.67522e-10
r_2619_2635_e 2619 2635 836.944
r_2619_2635_i 2619_2635 2635 4256.89
c_2619_2635_i 2619 2619_2635 4.67522e-10
r_3179_3195_e 3179 3195 13758.3
r_3179_3195_i 3179_3195 3195 95645.6
c_3179_3195_i 3179 3179_3195 9.36084e-12
r_3739_3755_e 3739 3755 13758.3
r_3739_3755_i 3739_3755 3755 95645.6
c_3739_3755_i 3739 3739_3755 9.36084e-12
r_380_396_e 380 396 13376.4
r_380_396_i 380_396 396 93218.1
c_380_396_i 380 380_396 2.08965e-09
r_940_956_e 940 956 396.568
r_940_956_i 940_956 956 1004.94
c_940_956_i 940 940_956 1.65849e-10
r_1500_1516_e 1500 1516 396.568
r_1500_1516_i 1500_1516 1516 1004.94
c_1500_1516_i 1500 1500_1516 1.65849e-10
r_2060_2076_e 2060 2076 836.944
r_2060_2076_i 2060_2076 2076 4256.89
c_2060_2076_i 2060 2060_2076 4.67522e-10
r_2620_2636_e 2620 2636 836.944
r_2620_2636_i 2620_2636 2636 4256.89
c_2620_2636_i 2620 2620_2636 4.67522e-10
r_3180_3196_e 3180 3196 13758.3
r_3180_3196_i 3180_3196 3196 95645.6
c_3180_3196_i 3180 3180_3196 9.36084e-12
r_3740_3756_e 3740 3756 13758.3
r_3740_3756_i 3740_3756 3756 95645.6
c_3740_3756_i 3740 3740_3756 9.36084e-12
r_381_397_e 381 397 13376.4
r_381_397_i 381_397 397 93218.1
c_381_397_i 381 381_397 2.08965e-09
r_941_957_e 941 957 13376.4
r_941_957_i 941_957 957 93218.1
c_941_957_i 941 941_957 2.08965e-09
r_1501_1517_e 1501 1517 836.944
r_1501_1517_i 1501_1517 1517 4256.89
c_1501_1517_i 1501 1501_1517 4.67522e-10
r_2061_2077_e 2061 2077 836.944
r_2061_2077_i 2061_2077 2077 4256.89
c_2061_2077_i 2061 2061_2077 4.67522e-10
r_2621_2637_e 2621 2637 836.944
r_2621_2637_i 2621_2637 2637 4256.89
c_2621_2637_i 2621 2621_2637 4.67522e-10
r_3181_3197_e 3181 3197 13758.3
r_3181_3197_i 3181_3197 3197 95645.6
c_3181_3197_i 3181 3181_3197 9.36084e-12
r_3741_3757_e 3741 3757 13758.3
r_3741_3757_i 3741_3757 3757 95645.6
c_3741_3757_i 3741 3741_3757 9.36084e-12
r_382_398_e 382 398 13376.4
r_382_398_i 382_398 398 93218.1
c_382_398_i 382 382_398 2.08965e-09
r_942_958_e 942 958 13376.4
r_942_958_i 942_958 958 93218.1
c_942_958_i 942 942_958 2.08965e-09
r_1502_1518_e 1502 1518 836.944
r_1502_1518_i 1502_1518 1518 4256.89
c_1502_1518_i 1502 1502_1518 4.67522e-10
r_2062_2078_e 2062 2078 836.944
r_2062_2078_i 2062_2078 2078 4256.89
c_2062_2078_i 2062 2062_2078 4.67522e-10
r_2622_2638_e 2622 2638 836.944
r_2622_2638_i 2622_2638 2638 4256.89
c_2622_2638_i 2622 2622_2638 4.67522e-10
r_3182_3198_e 3182 3198 13758.3
r_3182_3198_i 3182_3198 3198 95645.6
c_3182_3198_i 3182 3182_3198 9.36084e-12
r_3742_3758_e 3742 3758 13758.3
r_3742_3758_i 3742_3758 3758 95645.6
c_3742_3758_i 3742 3742_3758 9.36084e-12
r_383_399_e 383 399 13376.4
r_383_399_i 383_399 399 93218.1
c_383_399_i 383 383_399 2.08965e-09
r_943_959_e 943 959 13376.4
r_943_959_i 943_959 959 93218.1
c_943_959_i 943 943_959 2.08965e-09
r_1503_1519_e 1503 1519 836.944
r_1503_1519_i 1503_1519 1519 4256.89
c_1503_1519_i 1503 1503_1519 4.67522e-10
r_2063_2079_e 2063 2079 836.944
r_2063_2079_i 2063_2079 2079 4256.89
c_2063_2079_i 2063 2063_2079 4.67522e-10
r_2623_2639_e 2623 2639 836.944
r_2623_2639_i 2623_2639 2639 4256.89
c_2623_2639_i 2623 2623_2639 4.67522e-10
r_3183_3199_e 3183 3199 13758.3
r_3183_3199_i 3183_3199 3199 95645.6
c_3183_3199_i 3183 3183_3199 9.36084e-12
r_3743_3759_e 3743 3759 13758.3
r_3743_3759_i 3743_3759 3759 95645.6
c_3743_3759_i 3743 3743_3759 9.36084e-12
r_384_400_e 384 400 13376.4
r_384_400_i 384_400 400 93218.1
c_384_400_i 384 384_400 2.08965e-09
r_944_960_e 944 960 13376.4
r_944_960_i 944_960 960 93218.1
c_944_960_i 944 944_960 2.08965e-09
r_1504_1520_e 1504 1520 836.944
r_1504_1520_i 1504_1520 1520 4256.89
c_1504_1520_i 1504 1504_1520 4.67522e-10
r_2064_2080_e 2064 2080 836.944
r_2064_2080_i 2064_2080 2080 4256.89
c_2064_2080_i 2064 2064_2080 4.67522e-10
r_2624_2640_e 2624 2640 836.944
r_2624_2640_i 2624_2640 2640 4256.89
c_2624_2640_i 2624 2624_2640 4.67522e-10
r_3184_3200_e 3184 3200 13758.3
r_3184_3200_i 3184_3200 3200 95645.6
c_3184_3200_i 3184 3184_3200 9.36084e-12
r_3744_3760_e 3744 3760 13758.3
r_3744_3760_i 3744_3760 3760 95645.6
c_3744_3760_i 3744 3744_3760 9.36084e-12
r_385_401_e 385 401 13376.4
r_385_401_i 385_401 401 93218.1
c_385_401_i 385 385_401 2.08965e-09
r_945_961_e 945 961 13376.4
r_945_961_i 945_961 961 93218.1
c_945_961_i 945 945_961 2.08965e-09
r_1505_1521_e 1505 1521 13376.4
r_1505_1521_i 1505_1521 1521 93218.1
c_1505_1521_i 1505 1505_1521 2.08965e-09
r_2065_2081_e 2065 2081 13376.4
r_2065_2081_i 2065_2081 2081 93218.1
c_2065_2081_i 2065 2065_2081 2.08965e-09
r_2625_2641_e 2625 2641 13376.4
r_2625_2641_i 2625_2641 2641 93218.1
c_2625_2641_i 2625 2625_2641 2.08965e-09
r_3185_3201_e 3185 3201 13376.4
r_3185_3201_i 3185_3201 3201 93218.1
c_3185_3201_i 3185 3185_3201 2.08965e-09
r_3745_3761_e 3745 3761 13376.4
r_3745_3761_i 3745_3761 3761 93218.1
c_3745_3761_i 3745 3745_3761 2.08965e-09
r_386_402_e 386 402 13376.4
r_386_402_i 386_402 402 93218.1
c_386_402_i 386 386_402 2.08965e-09
r_946_962_e 946 962 13376.4
r_946_962_i 946_962 962 93218.1
c_946_962_i 946 946_962 2.08965e-09
r_1506_1522_e 1506 1522 13376.4
r_1506_1522_i 1506_1522 1522 93218.1
c_1506_1522_i 1506 1506_1522 2.08965e-09
r_2066_2082_e 2066 2082 13376.4
r_2066_2082_i 2066_2082 2082 93218.1
c_2066_2082_i 2066 2066_2082 2.08965e-09
r_2626_2642_e 2626 2642 13376.4
r_2626_2642_i 2626_2642 2642 93218.1
c_2626_2642_i 2626 2626_2642 2.08965e-09
r_3186_3202_e 3186 3202 13376.4
r_3186_3202_i 3186_3202 3202 93218.1
c_3186_3202_i 3186 3186_3202 2.08965e-09
r_3746_3762_e 3746 3762 13376.4
r_3746_3762_i 3746_3762 3762 93218.1
c_3746_3762_i 3746 3746_3762 2.08965e-09
r_387_403_e 387 403 13376.4
r_387_403_i 387_403 403 93218.1
c_387_403_i 387 387_403 2.08965e-09
r_947_963_e 947 963 13376.4
r_947_963_i 947_963 963 93218.1
c_947_963_i 947 947_963 2.08965e-09
r_1507_1523_e 1507 1523 836.944
r_1507_1523_i 1507_1523 1523 4256.89
c_1507_1523_i 1507 1507_1523 4.67522e-10
r_2067_2083_e 2067 2083 836.944
r_2067_2083_i 2067_2083 2083 4256.89
c_2067_2083_i 2067 2067_2083 4.67522e-10
r_2627_2643_e 2627 2643 836.944
r_2627_2643_i 2627_2643 2643 4256.89
c_2627_2643_i 2627 2627_2643 4.67522e-10
r_3187_3203_e 3187 3203 836.944
r_3187_3203_i 3187_3203 3203 4256.89
c_3187_3203_i 3187 3187_3203 4.67522e-10
r_3747_3763_e 3747 3763 836.944
r_3747_3763_i 3747_3763 3763 4256.89
c_3747_3763_i 3747 3747_3763 4.67522e-10
r_388_404_e 388 404 13376.4
r_388_404_i 388_404 404 93218.1
c_388_404_i 388 388_404 2.08965e-09
r_948_964_e 948 964 13376.4
r_948_964_i 948_964 964 93218.1
c_948_964_i 948 948_964 2.08965e-09
r_1508_1524_e 1508 1524 836.944
r_1508_1524_i 1508_1524 1524 4256.89
c_1508_1524_i 1508 1508_1524 4.67522e-10
r_2068_2084_e 2068 2084 836.944
r_2068_2084_i 2068_2084 2084 4256.89
c_2068_2084_i 2068 2068_2084 4.67522e-10
r_2628_2644_e 2628 2644 836.944
r_2628_2644_i 2628_2644 2644 4256.89
c_2628_2644_i 2628 2628_2644 4.67522e-10
r_3188_3204_e 3188 3204 13758.3
r_3188_3204_i 3188_3204 3204 95645.6
c_3188_3204_i 3188 3188_3204 9.36084e-12
r_3748_3764_e 3748 3764 13758.3
r_3748_3764_i 3748_3764 3764 95645.6
c_3748_3764_i 3748 3748_3764 9.36084e-12
r_389_405_e 389 405 13376.4
r_389_405_i 389_405 405 93218.1
c_389_405_i 389 389_405 2.08965e-09
r_949_965_e 949 965 13376.4
r_949_965_i 949_965 965 93218.1
c_949_965_i 949 949_965 2.08965e-09
r_1509_1525_e 1509 1525 836.944
r_1509_1525_i 1509_1525 1525 4256.89
c_1509_1525_i 1509 1509_1525 4.67522e-10
r_2069_2085_e 2069 2085 836.944
r_2069_2085_i 2069_2085 2085 4256.89
c_2069_2085_i 2069 2069_2085 4.67522e-10
r_2629_2645_e 2629 2645 836.944
r_2629_2645_i 2629_2645 2645 4256.89
c_2629_2645_i 2629 2629_2645 4.67522e-10
r_3189_3205_e 3189 3205 13758.3
r_3189_3205_i 3189_3205 3205 95645.6
c_3189_3205_i 3189 3189_3205 9.36084e-12
r_3749_3765_e 3749 3765 13758.3
r_3749_3765_i 3749_3765 3765 95645.6
c_3749_3765_i 3749 3749_3765 9.36084e-12
r_390_406_e 390 406 13376.4
r_390_406_i 390_406 406 93218.1
c_390_406_i 390 390_406 2.08965e-09
r_950_966_e 950 966 13376.4
r_950_966_i 950_966 966 93218.1
c_950_966_i 950 950_966 2.08965e-09
r_1510_1526_e 1510 1526 836.944
r_1510_1526_i 1510_1526 1526 4256.89
c_1510_1526_i 1510 1510_1526 4.67522e-10
r_2070_2086_e 2070 2086 836.944
r_2070_2086_i 2070_2086 2086 4256.89
c_2070_2086_i 2070 2070_2086 4.67522e-10
r_2630_2646_e 2630 2646 836.944
r_2630_2646_i 2630_2646 2646 4256.89
c_2630_2646_i 2630 2630_2646 4.67522e-10
r_3190_3206_e 3190 3206 13758.3
r_3190_3206_i 3190_3206 3206 95645.6
c_3190_3206_i 3190 3190_3206 9.36084e-12
r_3750_3766_e 3750 3766 13758.3
r_3750_3766_i 3750_3766 3766 95645.6
c_3750_3766_i 3750 3750_3766 9.36084e-12
r_391_407_e 391 407 13376.4
r_391_407_i 391_407 407 93218.1
c_391_407_i 391 391_407 2.08965e-09
r_951_967_e 951 967 13376.4
r_951_967_i 951_967 967 93218.1
c_951_967_i 951 951_967 2.08965e-09
r_1511_1527_e 1511 1527 836.944
r_1511_1527_i 1511_1527 1527 4256.89
c_1511_1527_i 1511 1511_1527 4.67522e-10
r_2071_2087_e 2071 2087 836.944
r_2071_2087_i 2071_2087 2087 4256.89
c_2071_2087_i 2071 2071_2087 4.67522e-10
r_2631_2647_e 2631 2647 836.944
r_2631_2647_i 2631_2647 2647 4256.89
c_2631_2647_i 2631 2631_2647 4.67522e-10
r_3191_3207_e 3191 3207 13758.3
r_3191_3207_i 3191_3207 3207 95645.6
c_3191_3207_i 3191 3191_3207 9.36084e-12
r_3751_3767_e 3751 3767 13758.3
r_3751_3767_i 3751_3767 3767 95645.6
c_3751_3767_i 3751 3751_3767 9.36084e-12
r_392_408_e 392 408 13376.4
r_392_408_i 392_408 408 93218.1
c_392_408_i 392 392_408 2.08965e-09
r_952_968_e 952 968 13376.4
r_952_968_i 952_968 968 93218.1
c_952_968_i 952 952_968 2.08965e-09
r_1512_1528_e 1512 1528 836.944
r_1512_1528_i 1512_1528 1528 4256.89
c_1512_1528_i 1512 1512_1528 4.67522e-10
r_2072_2088_e 2072 2088 836.944
r_2072_2088_i 2072_2088 2088 4256.89
c_2072_2088_i 2072 2072_2088 4.67522e-10
r_2632_2648_e 2632 2648 836.944
r_2632_2648_i 2632_2648 2648 4256.89
c_2632_2648_i 2632 2632_2648 4.67522e-10
r_3192_3208_e 3192 3208 13758.3
r_3192_3208_i 3192_3208 3208 95645.6
c_3192_3208_i 3192 3192_3208 9.36084e-12
r_3752_3768_e 3752 3768 13758.3
r_3752_3768_i 3752_3768 3768 95645.6
c_3752_3768_i 3752 3752_3768 9.36084e-12
r_393_409_e 393 409 13376.4
r_393_409_i 393_409 409 93218.1
c_393_409_i 393 393_409 2.08965e-09
r_953_969_e 953 969 13376.4
r_953_969_i 953_969 969 93218.1
c_953_969_i 953 953_969 2.08965e-09
r_1513_1529_e 1513 1529 836.944
r_1513_1529_i 1513_1529 1529 4256.89
c_1513_1529_i 1513 1513_1529 4.67522e-10
r_2073_2089_e 2073 2089 836.944
r_2073_2089_i 2073_2089 2089 4256.89
c_2073_2089_i 2073 2073_2089 4.67522e-10
r_2633_2649_e 2633 2649 836.944
r_2633_2649_i 2633_2649 2649 4256.89
c_2633_2649_i 2633 2633_2649 4.67522e-10
r_3193_3209_e 3193 3209 13758.3
r_3193_3209_i 3193_3209 3209 95645.6
c_3193_3209_i 3193 3193_3209 9.36084e-12
r_3753_3769_e 3753 3769 13758.3
r_3753_3769_i 3753_3769 3769 95645.6
c_3753_3769_i 3753 3753_3769 9.36084e-12
r_394_410_e 394 410 13376.4
r_394_410_i 394_410 410 93218.1
c_394_410_i 394 394_410 2.08965e-09
r_954_970_e 954 970 13376.4
r_954_970_i 954_970 970 93218.1
c_954_970_i 954 954_970 2.08965e-09
r_1514_1530_e 1514 1530 836.944
r_1514_1530_i 1514_1530 1530 4256.89
c_1514_1530_i 1514 1514_1530 4.67522e-10
r_2074_2090_e 2074 2090 836.944
r_2074_2090_i 2074_2090 2090 4256.89
c_2074_2090_i 2074 2074_2090 4.67522e-10
r_2634_2650_e 2634 2650 836.944
r_2634_2650_i 2634_2650 2650 4256.89
c_2634_2650_i 2634 2634_2650 4.67522e-10
r_3194_3210_e 3194 3210 13758.3
r_3194_3210_i 3194_3210 3210 95645.6
c_3194_3210_i 3194 3194_3210 9.36084e-12
r_3754_3770_e 3754 3770 13758.3
r_3754_3770_i 3754_3770 3770 95645.6
c_3754_3770_i 3754 3754_3770 9.36084e-12
r_395_411_e 395 411 13376.4
r_395_411_i 395_411 411 93218.1
c_395_411_i 395 395_411 2.08965e-09
r_955_971_e 955 971 396.56
r_955_971_i 955_971 971 1004.92
c_955_971_i 955 955_971 1.65852e-10
r_1515_1531_e 1515 1531 396.56
r_1515_1531_i 1515_1531 1531 1004.92
c_1515_1531_i 1515 1515_1531 1.65852e-10
r_2075_2091_e 2075 2091 836.944
r_2075_2091_i 2075_2091 2091 4256.89
c_2075_2091_i 2075 2075_2091 4.67522e-10
r_2635_2651_e 2635 2651 836.944
r_2635_2651_i 2635_2651 2651 4256.89
c_2635_2651_i 2635 2635_2651 4.67522e-10
r_3195_3211_e 3195 3211 13758.3
r_3195_3211_i 3195_3211 3211 95645.6
c_3195_3211_i 3195 3195_3211 9.36084e-12
r_3755_3771_e 3755 3771 13758.3
r_3755_3771_i 3755_3771 3771 95645.6
c_3755_3771_i 3755 3755_3771 9.36084e-12
r_396_412_e 396 412 13376.4
r_396_412_i 396_412 412 93218.1
c_396_412_i 396 396_412 2.08965e-09
r_956_972_e 956 972 396.56
r_956_972_i 956_972 972 1004.92
c_956_972_i 956 956_972 1.65852e-10
r_1516_1532_e 1516 1532 396.56
r_1516_1532_i 1516_1532 1532 1004.92
c_1516_1532_i 1516 1516_1532 1.65852e-10
r_2076_2092_e 2076 2092 836.944
r_2076_2092_i 2076_2092 2092 4256.89
c_2076_2092_i 2076 2076_2092 4.67522e-10
r_2636_2652_e 2636 2652 836.944
r_2636_2652_i 2636_2652 2652 4256.89
c_2636_2652_i 2636 2636_2652 4.67522e-10
r_3196_3212_e 3196 3212 13758.3
r_3196_3212_i 3196_3212 3212 95645.6
c_3196_3212_i 3196 3196_3212 9.36084e-12
r_3756_3772_e 3756 3772 13758.3
r_3756_3772_i 3756_3772 3772 95645.6
c_3756_3772_i 3756 3756_3772 9.36084e-12
r_397_413_e 397 413 13376.4
r_397_413_i 397_413 413 93218.1
c_397_413_i 397 397_413 2.08965e-09
r_957_973_e 957 973 13376.4
r_957_973_i 957_973 973 93218.1
c_957_973_i 957 957_973 2.08965e-09
r_1517_1533_e 1517 1533 836.944
r_1517_1533_i 1517_1533 1533 4256.89
c_1517_1533_i 1517 1517_1533 4.67522e-10
r_2077_2093_e 2077 2093 836.944
r_2077_2093_i 2077_2093 2093 4256.89
c_2077_2093_i 2077 2077_2093 4.67522e-10
r_2637_2653_e 2637 2653 836.944
r_2637_2653_i 2637_2653 2653 4256.89
c_2637_2653_i 2637 2637_2653 4.67522e-10
r_3197_3213_e 3197 3213 13758.3
r_3197_3213_i 3197_3213 3213 95645.6
c_3197_3213_i 3197 3197_3213 9.36084e-12
r_3757_3773_e 3757 3773 13758.3
r_3757_3773_i 3757_3773 3773 95645.6
c_3757_3773_i 3757 3757_3773 9.36084e-12
r_398_414_e 398 414 13376.4
r_398_414_i 398_414 414 93218.1
c_398_414_i 398 398_414 2.08965e-09
r_958_974_e 958 974 13376.4
r_958_974_i 958_974 974 93218.1
c_958_974_i 958 958_974 2.08965e-09
r_1518_1534_e 1518 1534 836.944
r_1518_1534_i 1518_1534 1534 4256.89
c_1518_1534_i 1518 1518_1534 4.67522e-10
r_2078_2094_e 2078 2094 836.944
r_2078_2094_i 2078_2094 2094 4256.89
c_2078_2094_i 2078 2078_2094 4.67522e-10
r_2638_2654_e 2638 2654 836.944
r_2638_2654_i 2638_2654 2654 4256.89
c_2638_2654_i 2638 2638_2654 4.67522e-10
r_3198_3214_e 3198 3214 13758.3
r_3198_3214_i 3198_3214 3214 95645.6
c_3198_3214_i 3198 3198_3214 9.36084e-12
r_3758_3774_e 3758 3774 13758.3
r_3758_3774_i 3758_3774 3774 95645.6
c_3758_3774_i 3758 3758_3774 9.36084e-12
r_399_415_e 399 415 13376.4
r_399_415_i 399_415 415 93218.1
c_399_415_i 399 399_415 2.08965e-09
r_959_975_e 959 975 13376.4
r_959_975_i 959_975 975 93218.1
c_959_975_i 959 959_975 2.08965e-09
r_1519_1535_e 1519 1535 836.944
r_1519_1535_i 1519_1535 1535 4256.89
c_1519_1535_i 1519 1519_1535 4.67522e-10
r_2079_2095_e 2079 2095 836.944
r_2079_2095_i 2079_2095 2095 4256.89
c_2079_2095_i 2079 2079_2095 4.67522e-10
r_2639_2655_e 2639 2655 836.944
r_2639_2655_i 2639_2655 2655 4256.89
c_2639_2655_i 2639 2639_2655 4.67522e-10
r_3199_3215_e 3199 3215 13758.3
r_3199_3215_i 3199_3215 3215 95645.6
c_3199_3215_i 3199 3199_3215 9.36084e-12
r_3759_3775_e 3759 3775 13758.3
r_3759_3775_i 3759_3775 3775 95645.6
c_3759_3775_i 3759 3759_3775 9.36084e-12
r_400_416_e 400 416 13376.4
r_400_416_i 400_416 416 93218.1
c_400_416_i 400 400_416 2.08965e-09
r_960_976_e 960 976 13376.4
r_960_976_i 960_976 976 93218.1
c_960_976_i 960 960_976 2.08965e-09
r_1520_1536_e 1520 1536 836.944
r_1520_1536_i 1520_1536 1536 4256.89
c_1520_1536_i 1520 1520_1536 4.67522e-10
r_2080_2096_e 2080 2096 836.944
r_2080_2096_i 2080_2096 2096 4256.89
c_2080_2096_i 2080 2080_2096 4.67522e-10
r_2640_2656_e 2640 2656 836.944
r_2640_2656_i 2640_2656 2656 4256.89
c_2640_2656_i 2640 2640_2656 4.67522e-10
r_3200_3216_e 3200 3216 13758.3
r_3200_3216_i 3200_3216 3216 95645.6
c_3200_3216_i 3200 3200_3216 9.36084e-12
r_3760_3776_e 3760 3776 13758.3
r_3760_3776_i 3760_3776 3776 95645.6
c_3760_3776_i 3760 3760_3776 9.36084e-12
r_401_417_e 401 417 13376.4
r_401_417_i 401_417 417 93218.1
c_401_417_i 401 401_417 2.08965e-09
r_961_977_e 961 977 13376.4
r_961_977_i 961_977 977 93218.1
c_961_977_i 961 961_977 2.08965e-09
r_1521_1537_e 1521 1537 13376.4
r_1521_1537_i 1521_1537 1537 93218.1
c_1521_1537_i 1521 1521_1537 2.08965e-09
r_2081_2097_e 2081 2097 13376.4
r_2081_2097_i 2081_2097 2097 93218.1
c_2081_2097_i 2081 2081_2097 2.08965e-09
r_2641_2657_e 2641 2657 13376.4
r_2641_2657_i 2641_2657 2657 93218.1
c_2641_2657_i 2641 2641_2657 2.08965e-09
r_3201_3217_e 3201 3217 13376.4
r_3201_3217_i 3201_3217 3217 93218.1
c_3201_3217_i 3201 3201_3217 2.08965e-09
r_3761_3777_e 3761 3777 13376.4
r_3761_3777_i 3761_3777 3777 93218.1
c_3761_3777_i 3761 3761_3777 2.08965e-09
r_402_418_e 402 418 13376.4
r_402_418_i 402_418 418 93218.1
c_402_418_i 402 402_418 2.08965e-09
r_962_978_e 962 978 13376.4
r_962_978_i 962_978 978 93218.1
c_962_978_i 962 962_978 2.08965e-09
r_1522_1538_e 1522 1538 13376.4
r_1522_1538_i 1522_1538 1538 93218.1
c_1522_1538_i 1522 1522_1538 2.08965e-09
r_2082_2098_e 2082 2098 13376.4
r_2082_2098_i 2082_2098 2098 93218.1
c_2082_2098_i 2082 2082_2098 2.08965e-09
r_2642_2658_e 2642 2658 13376.4
r_2642_2658_i 2642_2658 2658 93218.1
c_2642_2658_i 2642 2642_2658 2.08965e-09
r_3202_3218_e 3202 3218 13376.4
r_3202_3218_i 3202_3218 3218 93218.1
c_3202_3218_i 3202 3202_3218 2.08965e-09
r_3762_3778_e 3762 3778 13376.4
r_3762_3778_i 3762_3778 3778 93218.1
c_3762_3778_i 3762 3762_3778 2.08965e-09
r_403_419_e 403 419 13376.4
r_403_419_i 403_419 419 93218.1
c_403_419_i 403 403_419 2.08965e-09
r_963_979_e 963 979 13376.4
r_963_979_i 963_979 979 93218.1
c_963_979_i 963 963_979 2.08965e-09
r_1523_1539_e 1523 1539 836.944
r_1523_1539_i 1523_1539 1539 4256.89
c_1523_1539_i 1523 1523_1539 4.67522e-10
r_2083_2099_e 2083 2099 836.944
r_2083_2099_i 2083_2099 2099 4256.89
c_2083_2099_i 2083 2083_2099 4.67522e-10
r_2643_2659_e 2643 2659 836.944
r_2643_2659_i 2643_2659 2659 4256.89
c_2643_2659_i 2643 2643_2659 4.67522e-10
r_3203_3219_e 3203 3219 836.944
r_3203_3219_i 3203_3219 3219 4256.89
c_3203_3219_i 3203 3203_3219 4.67522e-10
r_3763_3779_e 3763 3779 836.944
r_3763_3779_i 3763_3779 3779 4256.89
c_3763_3779_i 3763 3763_3779 4.67522e-10
r_404_420_e 404 420 13376.4
r_404_420_i 404_420 420 93218.1
c_404_420_i 404 404_420 2.08965e-09
r_964_980_e 964 980 13376.4
r_964_980_i 964_980 980 93218.1
c_964_980_i 964 964_980 2.08965e-09
r_1524_1540_e 1524 1540 836.944
r_1524_1540_i 1524_1540 1540 4256.89
c_1524_1540_i 1524 1524_1540 4.67522e-10
r_2084_2100_e 2084 2100 836.944
r_2084_2100_i 2084_2100 2100 4256.89
c_2084_2100_i 2084 2084_2100 4.67522e-10
r_2644_2660_e 2644 2660 836.944
r_2644_2660_i 2644_2660 2660 4256.89
c_2644_2660_i 2644 2644_2660 4.67522e-10
r_3204_3220_e 3204 3220 13758.3
r_3204_3220_i 3204_3220 3220 95645.6
c_3204_3220_i 3204 3204_3220 9.36084e-12
r_3764_3780_e 3764 3780 13758.3
r_3764_3780_i 3764_3780 3780 95645.6
c_3764_3780_i 3764 3764_3780 9.36084e-12
r_405_421_e 405 421 13376.4
r_405_421_i 405_421 421 93218.1
c_405_421_i 405 405_421 2.08965e-09
r_965_981_e 965 981 13376.4
r_965_981_i 965_981 981 93218.1
c_965_981_i 965 965_981 2.08965e-09
r_1525_1541_e 1525 1541 836.944
r_1525_1541_i 1525_1541 1541 4256.89
c_1525_1541_i 1525 1525_1541 4.67522e-10
r_2085_2101_e 2085 2101 836.944
r_2085_2101_i 2085_2101 2101 4256.89
c_2085_2101_i 2085 2085_2101 4.67522e-10
r_2645_2661_e 2645 2661 836.944
r_2645_2661_i 2645_2661 2661 4256.89
c_2645_2661_i 2645 2645_2661 4.67522e-10
r_3205_3221_e 3205 3221 13758.3
r_3205_3221_i 3205_3221 3221 95645.6
c_3205_3221_i 3205 3205_3221 9.36084e-12
r_3765_3781_e 3765 3781 13758.3
r_3765_3781_i 3765_3781 3781 95645.6
c_3765_3781_i 3765 3765_3781 9.36084e-12
r_406_422_e 406 422 13376.4
r_406_422_i 406_422 422 93218.1
c_406_422_i 406 406_422 2.08965e-09
r_966_982_e 966 982 13376.4
r_966_982_i 966_982 982 93218.1
c_966_982_i 966 966_982 2.08965e-09
r_1526_1542_e 1526 1542 836.944
r_1526_1542_i 1526_1542 1542 4256.89
c_1526_1542_i 1526 1526_1542 4.67522e-10
r_2086_2102_e 2086 2102 836.944
r_2086_2102_i 2086_2102 2102 4256.89
c_2086_2102_i 2086 2086_2102 4.67522e-10
r_2646_2662_e 2646 2662 836.944
r_2646_2662_i 2646_2662 2662 4256.89
c_2646_2662_i 2646 2646_2662 4.67522e-10
r_3206_3222_e 3206 3222 13758.3
r_3206_3222_i 3206_3222 3222 95645.6
c_3206_3222_i 3206 3206_3222 9.36084e-12
r_3766_3782_e 3766 3782 13758.3
r_3766_3782_i 3766_3782 3782 95645.6
c_3766_3782_i 3766 3766_3782 9.36084e-12
r_407_423_e 407 423 13376.4
r_407_423_i 407_423 423 93218.1
c_407_423_i 407 407_423 2.08965e-09
r_967_983_e 967 983 13376.4
r_967_983_i 967_983 983 93218.1
c_967_983_i 967 967_983 2.08965e-09
r_1527_1543_e 1527 1543 836.944
r_1527_1543_i 1527_1543 1543 4256.89
c_1527_1543_i 1527 1527_1543 4.67522e-10
r_2087_2103_e 2087 2103 836.944
r_2087_2103_i 2087_2103 2103 4256.89
c_2087_2103_i 2087 2087_2103 4.67522e-10
r_2647_2663_e 2647 2663 836.944
r_2647_2663_i 2647_2663 2663 4256.89
c_2647_2663_i 2647 2647_2663 4.67522e-10
r_3207_3223_e 3207 3223 13758.3
r_3207_3223_i 3207_3223 3223 95645.6
c_3207_3223_i 3207 3207_3223 9.36084e-12
r_3767_3783_e 3767 3783 13758.3
r_3767_3783_i 3767_3783 3783 95645.6
c_3767_3783_i 3767 3767_3783 9.36084e-12
r_408_424_e 408 424 13376.4
r_408_424_i 408_424 424 93218.1
c_408_424_i 408 408_424 2.08965e-09
r_968_984_e 968 984 13376.4
r_968_984_i 968_984 984 93218.1
c_968_984_i 968 968_984 2.08965e-09
r_1528_1544_e 1528 1544 836.944
r_1528_1544_i 1528_1544 1544 4256.89
c_1528_1544_i 1528 1528_1544 4.67522e-10
r_2088_2104_e 2088 2104 836.944
r_2088_2104_i 2088_2104 2104 4256.89
c_2088_2104_i 2088 2088_2104 4.67522e-10
r_2648_2664_e 2648 2664 836.944
r_2648_2664_i 2648_2664 2664 4256.89
c_2648_2664_i 2648 2648_2664 4.67522e-10
r_3208_3224_e 3208 3224 13758.3
r_3208_3224_i 3208_3224 3224 95645.6
c_3208_3224_i 3208 3208_3224 9.36084e-12
r_3768_3784_e 3768 3784 13758.3
r_3768_3784_i 3768_3784 3784 95645.6
c_3768_3784_i 3768 3768_3784 9.36084e-12
r_409_425_e 409 425 13376.4
r_409_425_i 409_425 425 93218.1
c_409_425_i 409 409_425 2.08965e-09
r_969_985_e 969 985 13376.4
r_969_985_i 969_985 985 93218.1
c_969_985_i 969 969_985 2.08965e-09
r_1529_1545_e 1529 1545 836.944
r_1529_1545_i 1529_1545 1545 4256.89
c_1529_1545_i 1529 1529_1545 4.67522e-10
r_2089_2105_e 2089 2105 836.944
r_2089_2105_i 2089_2105 2105 4256.89
c_2089_2105_i 2089 2089_2105 4.67522e-10
r_2649_2665_e 2649 2665 836.944
r_2649_2665_i 2649_2665 2665 4256.89
c_2649_2665_i 2649 2649_2665 4.67522e-10
r_3209_3225_e 3209 3225 13758.3
r_3209_3225_i 3209_3225 3225 95645.6
c_3209_3225_i 3209 3209_3225 9.36084e-12
r_3769_3785_e 3769 3785 13758.3
r_3769_3785_i 3769_3785 3785 95645.6
c_3769_3785_i 3769 3769_3785 9.36084e-12
r_410_426_e 410 426 13376.4
r_410_426_i 410_426 426 93218.1
c_410_426_i 410 410_426 2.08965e-09
r_970_986_e 970 986 13376.4
r_970_986_i 970_986 986 93218.1
c_970_986_i 970 970_986 2.08965e-09
r_1530_1546_e 1530 1546 836.944
r_1530_1546_i 1530_1546 1546 4256.89
c_1530_1546_i 1530 1530_1546 4.67522e-10
r_2090_2106_e 2090 2106 836.944
r_2090_2106_i 2090_2106 2106 4256.89
c_2090_2106_i 2090 2090_2106 4.67522e-10
r_2650_2666_e 2650 2666 836.944
r_2650_2666_i 2650_2666 2666 4256.89
c_2650_2666_i 2650 2650_2666 4.67522e-10
r_3210_3226_e 3210 3226 13758.3
r_3210_3226_i 3210_3226 3226 95645.6
c_3210_3226_i 3210 3210_3226 9.36084e-12
r_3770_3786_e 3770 3786 13758.3
r_3770_3786_i 3770_3786 3786 95645.6
c_3770_3786_i 3770 3770_3786 9.36084e-12
r_411_427_e 411 427 13376.4
r_411_427_i 411_427 427 93218.1
c_411_427_i 411 411_427 2.08965e-09
r_971_987_e 971 987 396.551
r_971_987_i 971_987 987 1004.9
c_971_987_i 971 971_987 1.65856e-10
r_1531_1547_e 1531 1547 396.551
r_1531_1547_i 1531_1547 1547 1004.9
c_1531_1547_i 1531 1531_1547 1.65856e-10
r_2091_2107_e 2091 2107 836.944
r_2091_2107_i 2091_2107 2107 4256.89
c_2091_2107_i 2091 2091_2107 4.67522e-10
r_2651_2667_e 2651 2667 836.944
r_2651_2667_i 2651_2667 2667 4256.89
c_2651_2667_i 2651 2651_2667 4.67522e-10
r_3211_3227_e 3211 3227 13758.3
r_3211_3227_i 3211_3227 3227 95645.6
c_3211_3227_i 3211 3211_3227 9.36084e-12
r_3771_3787_e 3771 3787 13758.3
r_3771_3787_i 3771_3787 3787 95645.6
c_3771_3787_i 3771 3771_3787 9.36084e-12
r_412_428_e 412 428 13376.4
r_412_428_i 412_428 428 93218.1
c_412_428_i 412 412_428 2.08965e-09
r_972_988_e 972 988 396.551
r_972_988_i 972_988 988 1004.9
c_972_988_i 972 972_988 1.65856e-10
r_1532_1548_e 1532 1548 396.551
r_1532_1548_i 1532_1548 1548 1004.9
c_1532_1548_i 1532 1532_1548 1.65856e-10
r_2092_2108_e 2092 2108 836.944
r_2092_2108_i 2092_2108 2108 4256.89
c_2092_2108_i 2092 2092_2108 4.67522e-10
r_2652_2668_e 2652 2668 836.944
r_2652_2668_i 2652_2668 2668 4256.89
c_2652_2668_i 2652 2652_2668 4.67522e-10
r_3212_3228_e 3212 3228 13758.3
r_3212_3228_i 3212_3228 3228 95645.6
c_3212_3228_i 3212 3212_3228 9.36084e-12
r_3772_3788_e 3772 3788 13758.3
r_3772_3788_i 3772_3788 3788 95645.6
c_3772_3788_i 3772 3772_3788 9.36084e-12
r_413_429_e 413 429 13376.4
r_413_429_i 413_429 429 93218.1
c_413_429_i 413 413_429 2.08965e-09
r_973_989_e 973 989 13376.4
r_973_989_i 973_989 989 93218.1
c_973_989_i 973 973_989 2.08965e-09
r_1533_1549_e 1533 1549 836.944
r_1533_1549_i 1533_1549 1549 4256.89
c_1533_1549_i 1533 1533_1549 4.67522e-10
r_2093_2109_e 2093 2109 836.944
r_2093_2109_i 2093_2109 2109 4256.89
c_2093_2109_i 2093 2093_2109 4.67522e-10
r_2653_2669_e 2653 2669 836.944
r_2653_2669_i 2653_2669 2669 4256.89
c_2653_2669_i 2653 2653_2669 4.67522e-10
r_3213_3229_e 3213 3229 13758.3
r_3213_3229_i 3213_3229 3229 95645.6
c_3213_3229_i 3213 3213_3229 9.36084e-12
r_3773_3789_e 3773 3789 13758.3
r_3773_3789_i 3773_3789 3789 95645.6
c_3773_3789_i 3773 3773_3789 9.36084e-12
r_414_430_e 414 430 13376.4
r_414_430_i 414_430 430 93218.1
c_414_430_i 414 414_430 2.08965e-09
r_974_990_e 974 990 13376.4
r_974_990_i 974_990 990 93218.1
c_974_990_i 974 974_990 2.08965e-09
r_1534_1550_e 1534 1550 836.944
r_1534_1550_i 1534_1550 1550 4256.89
c_1534_1550_i 1534 1534_1550 4.67522e-10
r_2094_2110_e 2094 2110 836.944
r_2094_2110_i 2094_2110 2110 4256.89
c_2094_2110_i 2094 2094_2110 4.67522e-10
r_2654_2670_e 2654 2670 836.944
r_2654_2670_i 2654_2670 2670 4256.89
c_2654_2670_i 2654 2654_2670 4.67522e-10
r_3214_3230_e 3214 3230 13758.3
r_3214_3230_i 3214_3230 3230 95645.6
c_3214_3230_i 3214 3214_3230 9.36084e-12
r_3774_3790_e 3774 3790 13758.3
r_3774_3790_i 3774_3790 3790 95645.6
c_3774_3790_i 3774 3774_3790 9.36084e-12
r_415_431_e 415 431 13376.4
r_415_431_i 415_431 431 93218.1
c_415_431_i 415 415_431 2.08965e-09
r_975_991_e 975 991 13376.4
r_975_991_i 975_991 991 93218.1
c_975_991_i 975 975_991 2.08965e-09
r_1535_1551_e 1535 1551 836.944
r_1535_1551_i 1535_1551 1551 4256.89
c_1535_1551_i 1535 1535_1551 4.67522e-10
r_2095_2111_e 2095 2111 836.944
r_2095_2111_i 2095_2111 2111 4256.89
c_2095_2111_i 2095 2095_2111 4.67522e-10
r_2655_2671_e 2655 2671 836.944
r_2655_2671_i 2655_2671 2671 4256.89
c_2655_2671_i 2655 2655_2671 4.67522e-10
r_3215_3231_e 3215 3231 13758.3
r_3215_3231_i 3215_3231 3231 95645.6
c_3215_3231_i 3215 3215_3231 9.36084e-12
r_3775_3791_e 3775 3791 13758.3
r_3775_3791_i 3775_3791 3791 95645.6
c_3775_3791_i 3775 3775_3791 9.36084e-12
r_416_432_e 416 432 13376.4
r_416_432_i 416_432 432 93218.1
c_416_432_i 416 416_432 2.08965e-09
r_976_992_e 976 992 13376.4
r_976_992_i 976_992 992 93218.1
c_976_992_i 976 976_992 2.08965e-09
r_1536_1552_e 1536 1552 836.944
r_1536_1552_i 1536_1552 1552 4256.89
c_1536_1552_i 1536 1536_1552 4.67522e-10
r_2096_2112_e 2096 2112 836.944
r_2096_2112_i 2096_2112 2112 4256.89
c_2096_2112_i 2096 2096_2112 4.67522e-10
r_2656_2672_e 2656 2672 836.944
r_2656_2672_i 2656_2672 2672 4256.89
c_2656_2672_i 2656 2656_2672 4.67522e-10
r_3216_3232_e 3216 3232 13758.3
r_3216_3232_i 3216_3232 3232 95645.6
c_3216_3232_i 3216 3216_3232 9.36084e-12
r_3776_3792_e 3776 3792 13758.3
r_3776_3792_i 3776_3792 3792 95645.6
c_3776_3792_i 3776 3776_3792 9.36084e-12
r_417_433_e 417 433 13376.4
r_417_433_i 417_433 433 93218.1
c_417_433_i 417 417_433 2.08965e-09
r_977_993_e 977 993 13376.4
r_977_993_i 977_993 993 93218.1
c_977_993_i 977 977_993 2.08965e-09
r_1537_1553_e 1537 1553 13376.4
r_1537_1553_i 1537_1553 1553 93218.1
c_1537_1553_i 1537 1537_1553 2.08965e-09
r_2097_2113_e 2097 2113 13376.4
r_2097_2113_i 2097_2113 2113 93218.1
c_2097_2113_i 2097 2097_2113 2.08965e-09
r_2657_2673_e 2657 2673 13376.4
r_2657_2673_i 2657_2673 2673 93218.1
c_2657_2673_i 2657 2657_2673 2.08965e-09
r_3217_3233_e 3217 3233 13376.4
r_3217_3233_i 3217_3233 3233 93218.1
c_3217_3233_i 3217 3217_3233 2.08965e-09
r_3777_3793_e 3777 3793 13376.4
r_3777_3793_i 3777_3793 3793 93218.1
c_3777_3793_i 3777 3777_3793 2.08965e-09
r_418_434_e 418 434 13376.4
r_418_434_i 418_434 434 93218.1
c_418_434_i 418 418_434 2.08965e-09
r_978_994_e 978 994 13376.4
r_978_994_i 978_994 994 93218.1
c_978_994_i 978 978_994 2.08965e-09
r_1538_1554_e 1538 1554 13376.4
r_1538_1554_i 1538_1554 1554 93218.1
c_1538_1554_i 1538 1538_1554 2.08965e-09
r_2098_2114_e 2098 2114 13376.4
r_2098_2114_i 2098_2114 2114 93218.1
c_2098_2114_i 2098 2098_2114 2.08965e-09
r_2658_2674_e 2658 2674 13376.4
r_2658_2674_i 2658_2674 2674 93218.1
c_2658_2674_i 2658 2658_2674 2.08965e-09
r_3218_3234_e 3218 3234 13376.4
r_3218_3234_i 3218_3234 3234 93218.1
c_3218_3234_i 3218 3218_3234 2.08965e-09
r_3778_3794_e 3778 3794 13376.4
r_3778_3794_i 3778_3794 3794 93218.1
c_3778_3794_i 3778 3778_3794 2.08965e-09
r_419_435_e 419 435 13376.4
r_419_435_i 419_435 435 93218.1
c_419_435_i 419 419_435 2.08965e-09
r_979_995_e 979 995 13376.4
r_979_995_i 979_995 995 93218.1
c_979_995_i 979 979_995 2.08965e-09
r_1539_1555_e 1539 1555 836.944
r_1539_1555_i 1539_1555 1555 4256.89
c_1539_1555_i 1539 1539_1555 4.67522e-10
r_2099_2115_e 2099 2115 836.944
r_2099_2115_i 2099_2115 2115 4256.89
c_2099_2115_i 2099 2099_2115 4.67522e-10
r_2659_2675_e 2659 2675 836.944
r_2659_2675_i 2659_2675 2675 4256.89
c_2659_2675_i 2659 2659_2675 4.67522e-10
r_3219_3235_e 3219 3235 836.944
r_3219_3235_i 3219_3235 3235 4256.89
c_3219_3235_i 3219 3219_3235 4.67522e-10
r_3779_3795_e 3779 3795 836.944
r_3779_3795_i 3779_3795 3795 4256.89
c_3779_3795_i 3779 3779_3795 4.67522e-10
r_420_436_e 420 436 13376.4
r_420_436_i 420_436 436 93218.1
c_420_436_i 420 420_436 2.08965e-09
r_980_996_e 980 996 13376.4
r_980_996_i 980_996 996 93218.1
c_980_996_i 980 980_996 2.08965e-09
r_1540_1556_e 1540 1556 836.944
r_1540_1556_i 1540_1556 1556 4256.89
c_1540_1556_i 1540 1540_1556 4.67522e-10
r_2100_2116_e 2100 2116 836.944
r_2100_2116_i 2100_2116 2116 4256.89
c_2100_2116_i 2100 2100_2116 4.67522e-10
r_2660_2676_e 2660 2676 836.944
r_2660_2676_i 2660_2676 2676 4256.89
c_2660_2676_i 2660 2660_2676 4.67522e-10
r_3220_3236_e 3220 3236 13758.3
r_3220_3236_i 3220_3236 3236 95645.6
c_3220_3236_i 3220 3220_3236 9.36084e-12
r_3780_3796_e 3780 3796 13758.3
r_3780_3796_i 3780_3796 3796 95645.6
c_3780_3796_i 3780 3780_3796 9.36084e-12
r_421_437_e 421 437 13376.4
r_421_437_i 421_437 437 93218.1
c_421_437_i 421 421_437 2.08965e-09
r_981_997_e 981 997 13376.4
r_981_997_i 981_997 997 93218.1
c_981_997_i 981 981_997 2.08965e-09
r_1541_1557_e 1541 1557 836.944
r_1541_1557_i 1541_1557 1557 4256.89
c_1541_1557_i 1541 1541_1557 4.67522e-10
r_2101_2117_e 2101 2117 836.944
r_2101_2117_i 2101_2117 2117 4256.89
c_2101_2117_i 2101 2101_2117 4.67522e-10
r_2661_2677_e 2661 2677 836.944
r_2661_2677_i 2661_2677 2677 4256.89
c_2661_2677_i 2661 2661_2677 4.67522e-10
r_3221_3237_e 3221 3237 13758.3
r_3221_3237_i 3221_3237 3237 95645.6
c_3221_3237_i 3221 3221_3237 9.36084e-12
r_3781_3797_e 3781 3797 13758.3
r_3781_3797_i 3781_3797 3797 95645.6
c_3781_3797_i 3781 3781_3797 9.36084e-12
r_422_438_e 422 438 13376.4
r_422_438_i 422_438 438 93218.1
c_422_438_i 422 422_438 2.08965e-09
r_982_998_e 982 998 13376.4
r_982_998_i 982_998 998 93218.1
c_982_998_i 982 982_998 2.08965e-09
r_1542_1558_e 1542 1558 836.944
r_1542_1558_i 1542_1558 1558 4256.89
c_1542_1558_i 1542 1542_1558 4.67522e-10
r_2102_2118_e 2102 2118 836.944
r_2102_2118_i 2102_2118 2118 4256.89
c_2102_2118_i 2102 2102_2118 4.67522e-10
r_2662_2678_e 2662 2678 836.944
r_2662_2678_i 2662_2678 2678 4256.89
c_2662_2678_i 2662 2662_2678 4.67522e-10
r_3222_3238_e 3222 3238 13758.3
r_3222_3238_i 3222_3238 3238 95645.6
c_3222_3238_i 3222 3222_3238 9.36084e-12
r_3782_3798_e 3782 3798 13758.3
r_3782_3798_i 3782_3798 3798 95645.6
c_3782_3798_i 3782 3782_3798 9.36084e-12
r_423_439_e 423 439 13376.4
r_423_439_i 423_439 439 93218.1
c_423_439_i 423 423_439 2.08965e-09
r_983_999_e 983 999 13376.4
r_983_999_i 983_999 999 93218.1
c_983_999_i 983 983_999 2.08965e-09
r_1543_1559_e 1543 1559 836.944
r_1543_1559_i 1543_1559 1559 4256.89
c_1543_1559_i 1543 1543_1559 4.67522e-10
r_2103_2119_e 2103 2119 836.944
r_2103_2119_i 2103_2119 2119 4256.89
c_2103_2119_i 2103 2103_2119 4.67522e-10
r_2663_2679_e 2663 2679 836.944
r_2663_2679_i 2663_2679 2679 4256.89
c_2663_2679_i 2663 2663_2679 4.67522e-10
r_3223_3239_e 3223 3239 13758.3
r_3223_3239_i 3223_3239 3239 95645.6
c_3223_3239_i 3223 3223_3239 9.36084e-12
r_3783_3799_e 3783 3799 13758.3
r_3783_3799_i 3783_3799 3799 95645.6
c_3783_3799_i 3783 3783_3799 9.36084e-12
r_424_440_e 424 440 13376.4
r_424_440_i 424_440 440 93218.1
c_424_440_i 424 424_440 2.08965e-09
r_984_1000_e 984 1000 13376.4
r_984_1000_i 984_1000 1000 93218.1
c_984_1000_i 984 984_1000 2.08965e-09
r_1544_1560_e 1544 1560 836.944
r_1544_1560_i 1544_1560 1560 4256.89
c_1544_1560_i 1544 1544_1560 4.67522e-10
r_2104_2120_e 2104 2120 836.944
r_2104_2120_i 2104_2120 2120 4256.89
c_2104_2120_i 2104 2104_2120 4.67522e-10
r_2664_2680_e 2664 2680 836.944
r_2664_2680_i 2664_2680 2680 4256.89
c_2664_2680_i 2664 2664_2680 4.67522e-10
r_3224_3240_e 3224 3240 13758.3
r_3224_3240_i 3224_3240 3240 95645.6
c_3224_3240_i 3224 3224_3240 9.36084e-12
r_3784_3800_e 3784 3800 13758.3
r_3784_3800_i 3784_3800 3800 95645.6
c_3784_3800_i 3784 3784_3800 9.36084e-12
r_425_441_e 425 441 13376.4
r_425_441_i 425_441 441 93218.1
c_425_441_i 425 425_441 2.08965e-09
r_985_1001_e 985 1001 13376.4
r_985_1001_i 985_1001 1001 93218.1
c_985_1001_i 985 985_1001 2.08965e-09
r_1545_1561_e 1545 1561 836.944
r_1545_1561_i 1545_1561 1561 4256.89
c_1545_1561_i 1545 1545_1561 4.67522e-10
r_2105_2121_e 2105 2121 836.944
r_2105_2121_i 2105_2121 2121 4256.89
c_2105_2121_i 2105 2105_2121 4.67522e-10
r_2665_2681_e 2665 2681 836.944
r_2665_2681_i 2665_2681 2681 4256.89
c_2665_2681_i 2665 2665_2681 4.67522e-10
r_3225_3241_e 3225 3241 13758.3
r_3225_3241_i 3225_3241 3241 95645.6
c_3225_3241_i 3225 3225_3241 9.36084e-12
r_3785_3801_e 3785 3801 13758.3
r_3785_3801_i 3785_3801 3801 95645.6
c_3785_3801_i 3785 3785_3801 9.36084e-12
r_426_442_e 426 442 13376.4
r_426_442_i 426_442 442 93218.1
c_426_442_i 426 426_442 2.08965e-09
r_986_1002_e 986 1002 13376.4
r_986_1002_i 986_1002 1002 93218.1
c_986_1002_i 986 986_1002 2.08965e-09
r_1546_1562_e 1546 1562 836.944
r_1546_1562_i 1546_1562 1562 4256.89
c_1546_1562_i 1546 1546_1562 4.67522e-10
r_2106_2122_e 2106 2122 836.944
r_2106_2122_i 2106_2122 2122 4256.89
c_2106_2122_i 2106 2106_2122 4.67522e-10
r_2666_2682_e 2666 2682 836.944
r_2666_2682_i 2666_2682 2682 4256.89
c_2666_2682_i 2666 2666_2682 4.67522e-10
r_3226_3242_e 3226 3242 13758.3
r_3226_3242_i 3226_3242 3242 95645.6
c_3226_3242_i 3226 3226_3242 9.36084e-12
r_3786_3802_e 3786 3802 13758.3
r_3786_3802_i 3786_3802 3802 95645.6
c_3786_3802_i 3786 3786_3802 9.36084e-12
r_427_443_e 427 443 13376.4
r_427_443_i 427_443 443 93218.1
c_427_443_i 427 427_443 2.08965e-09
r_987_1003_e 987 1003 396.543
r_987_1003_i 987_1003 1003 1004.88
c_987_1003_i 987 987_1003 1.65859e-10
r_1547_1563_e 1547 1563 396.543
r_1547_1563_i 1547_1563 1563 1004.88
c_1547_1563_i 1547 1547_1563 1.65859e-10
r_2107_2123_e 2107 2123 836.944
r_2107_2123_i 2107_2123 2123 4256.89
c_2107_2123_i 2107 2107_2123 4.67522e-10
r_2667_2683_e 2667 2683 836.944
r_2667_2683_i 2667_2683 2683 4256.89
c_2667_2683_i 2667 2667_2683 4.67522e-10
r_3227_3243_e 3227 3243 13758.3
r_3227_3243_i 3227_3243 3243 95645.6
c_3227_3243_i 3227 3227_3243 9.36084e-12
r_3787_3803_e 3787 3803 13758.3
r_3787_3803_i 3787_3803 3803 95645.6
c_3787_3803_i 3787 3787_3803 9.36084e-12
r_428_444_e 428 444 13376.4
r_428_444_i 428_444 444 93218.1
c_428_444_i 428 428_444 2.08965e-09
r_988_1004_e 988 1004 396.543
r_988_1004_i 988_1004 1004 1004.88
c_988_1004_i 988 988_1004 1.65859e-10
r_1548_1564_e 1548 1564 396.543
r_1548_1564_i 1548_1564 1564 1004.88
c_1548_1564_i 1548 1548_1564 1.65859e-10
r_2108_2124_e 2108 2124 836.944
r_2108_2124_i 2108_2124 2124 4256.89
c_2108_2124_i 2108 2108_2124 4.67522e-10
r_2668_2684_e 2668 2684 836.944
r_2668_2684_i 2668_2684 2684 4256.89
c_2668_2684_i 2668 2668_2684 4.67522e-10
r_3228_3244_e 3228 3244 13758.3
r_3228_3244_i 3228_3244 3244 95645.6
c_3228_3244_i 3228 3228_3244 9.36084e-12
r_3788_3804_e 3788 3804 13758.3
r_3788_3804_i 3788_3804 3804 95645.6
c_3788_3804_i 3788 3788_3804 9.36084e-12
r_429_445_e 429 445 13376.4
r_429_445_i 429_445 445 93218.1
c_429_445_i 429 429_445 2.08965e-09
r_989_1005_e 989 1005 13376.4
r_989_1005_i 989_1005 1005 93218.1
c_989_1005_i 989 989_1005 2.08965e-09
r_1549_1565_e 1549 1565 836.944
r_1549_1565_i 1549_1565 1565 4256.89
c_1549_1565_i 1549 1549_1565 4.67522e-10
r_2109_2125_e 2109 2125 836.944
r_2109_2125_i 2109_2125 2125 4256.89
c_2109_2125_i 2109 2109_2125 4.67522e-10
r_2669_2685_e 2669 2685 836.944
r_2669_2685_i 2669_2685 2685 4256.89
c_2669_2685_i 2669 2669_2685 4.67522e-10
r_3229_3245_e 3229 3245 13758.3
r_3229_3245_i 3229_3245 3245 95645.6
c_3229_3245_i 3229 3229_3245 9.36084e-12
r_3789_3805_e 3789 3805 13758.3
r_3789_3805_i 3789_3805 3805 95645.6
c_3789_3805_i 3789 3789_3805 9.36084e-12
r_430_446_e 430 446 13376.4
r_430_446_i 430_446 446 93218.1
c_430_446_i 430 430_446 2.08965e-09
r_990_1006_e 990 1006 13376.4
r_990_1006_i 990_1006 1006 93218.1
c_990_1006_i 990 990_1006 2.08965e-09
r_1550_1566_e 1550 1566 836.944
r_1550_1566_i 1550_1566 1566 4256.89
c_1550_1566_i 1550 1550_1566 4.67522e-10
r_2110_2126_e 2110 2126 836.944
r_2110_2126_i 2110_2126 2126 4256.89
c_2110_2126_i 2110 2110_2126 4.67522e-10
r_2670_2686_e 2670 2686 836.944
r_2670_2686_i 2670_2686 2686 4256.89
c_2670_2686_i 2670 2670_2686 4.67522e-10
r_3230_3246_e 3230 3246 13758.3
r_3230_3246_i 3230_3246 3246 95645.6
c_3230_3246_i 3230 3230_3246 9.36084e-12
r_3790_3806_e 3790 3806 13758.3
r_3790_3806_i 3790_3806 3806 95645.6
c_3790_3806_i 3790 3790_3806 9.36084e-12
r_431_447_e 431 447 13376.4
r_431_447_i 431_447 447 93218.1
c_431_447_i 431 431_447 2.08965e-09
r_991_1007_e 991 1007 13376.4
r_991_1007_i 991_1007 1007 93218.1
c_991_1007_i 991 991_1007 2.08965e-09
r_1551_1567_e 1551 1567 836.944
r_1551_1567_i 1551_1567 1567 4256.89
c_1551_1567_i 1551 1551_1567 4.67522e-10
r_2111_2127_e 2111 2127 836.944
r_2111_2127_i 2111_2127 2127 4256.89
c_2111_2127_i 2111 2111_2127 4.67522e-10
r_2671_2687_e 2671 2687 836.944
r_2671_2687_i 2671_2687 2687 4256.89
c_2671_2687_i 2671 2671_2687 4.67522e-10
r_3231_3247_e 3231 3247 13758.3
r_3231_3247_i 3231_3247 3247 95645.6
c_3231_3247_i 3231 3231_3247 9.36084e-12
r_3791_3807_e 3791 3807 13758.3
r_3791_3807_i 3791_3807 3807 95645.6
c_3791_3807_i 3791 3791_3807 9.36084e-12
r_432_448_e 432 448 13376.4
r_432_448_i 432_448 448 93218.1
c_432_448_i 432 432_448 2.08965e-09
r_992_1008_e 992 1008 13376.4
r_992_1008_i 992_1008 1008 93218.1
c_992_1008_i 992 992_1008 2.08965e-09
r_1552_1568_e 1552 1568 836.944
r_1552_1568_i 1552_1568 1568 4256.89
c_1552_1568_i 1552 1552_1568 4.67522e-10
r_2112_2128_e 2112 2128 836.944
r_2112_2128_i 2112_2128 2128 4256.89
c_2112_2128_i 2112 2112_2128 4.67522e-10
r_2672_2688_e 2672 2688 836.944
r_2672_2688_i 2672_2688 2688 4256.89
c_2672_2688_i 2672 2672_2688 4.67522e-10
r_3232_3248_e 3232 3248 13758.3
r_3232_3248_i 3232_3248 3248 95645.6
c_3232_3248_i 3232 3232_3248 9.36084e-12
r_3792_3808_e 3792 3808 13758.3
r_3792_3808_i 3792_3808 3808 95645.6
c_3792_3808_i 3792 3792_3808 9.36084e-12
r_433_449_e 433 449 13376.4
r_433_449_i 433_449 449 93218.1
c_433_449_i 433 433_449 2.08965e-09
r_993_1009_e 993 1009 13376.4
r_993_1009_i 993_1009 1009 93218.1
c_993_1009_i 993 993_1009 2.08965e-09
r_1553_1569_e 1553 1569 13376.4
r_1553_1569_i 1553_1569 1569 93218.1
c_1553_1569_i 1553 1553_1569 2.08965e-09
r_2113_2129_e 2113 2129 13376.4
r_2113_2129_i 2113_2129 2129 93218.1
c_2113_2129_i 2113 2113_2129 2.08965e-09
r_2673_2689_e 2673 2689 13376.4
r_2673_2689_i 2673_2689 2689 93218.1
c_2673_2689_i 2673 2673_2689 2.08965e-09
r_3233_3249_e 3233 3249 13376.4
r_3233_3249_i 3233_3249 3249 93218.1
c_3233_3249_i 3233 3233_3249 2.08965e-09
r_3793_3809_e 3793 3809 13376.4
r_3793_3809_i 3793_3809 3809 93218.1
c_3793_3809_i 3793 3793_3809 2.08965e-09
r_434_450_e 434 450 13376.4
r_434_450_i 434_450 450 93218.1
c_434_450_i 434 434_450 2.08965e-09
r_994_1010_e 994 1010 13376.4
r_994_1010_i 994_1010 1010 93218.1
c_994_1010_i 994 994_1010 2.08965e-09
r_1554_1570_e 1554 1570 13376.4
r_1554_1570_i 1554_1570 1570 93218.1
c_1554_1570_i 1554 1554_1570 2.08965e-09
r_2114_2130_e 2114 2130 13376.4
r_2114_2130_i 2114_2130 2130 93218.1
c_2114_2130_i 2114 2114_2130 2.08965e-09
r_2674_2690_e 2674 2690 13376.4
r_2674_2690_i 2674_2690 2690 93218.1
c_2674_2690_i 2674 2674_2690 2.08965e-09
r_3234_3250_e 3234 3250 13376.4
r_3234_3250_i 3234_3250 3250 93218.1
c_3234_3250_i 3234 3234_3250 2.08965e-09
r_3794_3810_e 3794 3810 13376.4
r_3794_3810_i 3794_3810 3810 93218.1
c_3794_3810_i 3794 3794_3810 2.08965e-09
r_435_451_e 435 451 13376.4
r_435_451_i 435_451 451 93218.1
c_435_451_i 435 435_451 2.08965e-09
r_995_1011_e 995 1011 13376.4
r_995_1011_i 995_1011 1011 93218.1
c_995_1011_i 995 995_1011 2.08965e-09
r_1555_1571_e 1555 1571 836.944
r_1555_1571_i 1555_1571 1571 4256.89
c_1555_1571_i 1555 1555_1571 4.67522e-10
r_2115_2131_e 2115 2131 836.944
r_2115_2131_i 2115_2131 2131 4256.89
c_2115_2131_i 2115 2115_2131 4.67522e-10
r_2675_2691_e 2675 2691 836.944
r_2675_2691_i 2675_2691 2691 4256.89
c_2675_2691_i 2675 2675_2691 4.67522e-10
r_3235_3251_e 3235 3251 836.944
r_3235_3251_i 3235_3251 3251 4256.89
c_3235_3251_i 3235 3235_3251 4.67522e-10
r_3795_3811_e 3795 3811 836.944
r_3795_3811_i 3795_3811 3811 4256.89
c_3795_3811_i 3795 3795_3811 4.67522e-10
r_436_452_e 436 452 13376.4
r_436_452_i 436_452 452 93218.1
c_436_452_i 436 436_452 2.08965e-09
r_996_1012_e 996 1012 13376.4
r_996_1012_i 996_1012 1012 93218.1
c_996_1012_i 996 996_1012 2.08965e-09
r_1556_1572_e 1556 1572 836.944
r_1556_1572_i 1556_1572 1572 4256.89
c_1556_1572_i 1556 1556_1572 4.67522e-10
r_2116_2132_e 2116 2132 836.944
r_2116_2132_i 2116_2132 2132 4256.89
c_2116_2132_i 2116 2116_2132 4.67522e-10
r_2676_2692_e 2676 2692 836.944
r_2676_2692_i 2676_2692 2692 4256.89
c_2676_2692_i 2676 2676_2692 4.67522e-10
r_3236_3252_e 3236 3252 13758.3
r_3236_3252_i 3236_3252 3252 95645.6
c_3236_3252_i 3236 3236_3252 9.36084e-12
r_3796_3812_e 3796 3812 13758.3
r_3796_3812_i 3796_3812 3812 95645.6
c_3796_3812_i 3796 3796_3812 9.36084e-12
r_437_453_e 437 453 13376.4
r_437_453_i 437_453 453 93218.1
c_437_453_i 437 437_453 2.08965e-09
r_997_1013_e 997 1013 13376.4
r_997_1013_i 997_1013 1013 93218.1
c_997_1013_i 997 997_1013 2.08965e-09
r_1557_1573_e 1557 1573 836.944
r_1557_1573_i 1557_1573 1573 4256.89
c_1557_1573_i 1557 1557_1573 4.67522e-10
r_2117_2133_e 2117 2133 836.944
r_2117_2133_i 2117_2133 2133 4256.89
c_2117_2133_i 2117 2117_2133 4.67522e-10
r_2677_2693_e 2677 2693 836.944
r_2677_2693_i 2677_2693 2693 4256.89
c_2677_2693_i 2677 2677_2693 4.67522e-10
r_3237_3253_e 3237 3253 13758.3
r_3237_3253_i 3237_3253 3253 95645.6
c_3237_3253_i 3237 3237_3253 9.36084e-12
r_3797_3813_e 3797 3813 13758.3
r_3797_3813_i 3797_3813 3813 95645.6
c_3797_3813_i 3797 3797_3813 9.36084e-12
r_438_454_e 438 454 13376.4
r_438_454_i 438_454 454 93218.1
c_438_454_i 438 438_454 2.08965e-09
r_998_1014_e 998 1014 13376.4
r_998_1014_i 998_1014 1014 93218.1
c_998_1014_i 998 998_1014 2.08965e-09
r_1558_1574_e 1558 1574 836.944
r_1558_1574_i 1558_1574 1574 4256.89
c_1558_1574_i 1558 1558_1574 4.67522e-10
r_2118_2134_e 2118 2134 836.944
r_2118_2134_i 2118_2134 2134 4256.89
c_2118_2134_i 2118 2118_2134 4.67522e-10
r_2678_2694_e 2678 2694 836.944
r_2678_2694_i 2678_2694 2694 4256.89
c_2678_2694_i 2678 2678_2694 4.67522e-10
r_3238_3254_e 3238 3254 13758.3
r_3238_3254_i 3238_3254 3254 95645.6
c_3238_3254_i 3238 3238_3254 9.36084e-12
r_3798_3814_e 3798 3814 13758.3
r_3798_3814_i 3798_3814 3814 95645.6
c_3798_3814_i 3798 3798_3814 9.36084e-12
r_439_455_e 439 455 13376.4
r_439_455_i 439_455 455 93218.1
c_439_455_i 439 439_455 2.08965e-09
r_999_1015_e 999 1015 13376.4
r_999_1015_i 999_1015 1015 93218.1
c_999_1015_i 999 999_1015 2.08965e-09
r_1559_1575_e 1559 1575 836.944
r_1559_1575_i 1559_1575 1575 4256.89
c_1559_1575_i 1559 1559_1575 4.67522e-10
r_2119_2135_e 2119 2135 836.944
r_2119_2135_i 2119_2135 2135 4256.89
c_2119_2135_i 2119 2119_2135 4.67522e-10
r_2679_2695_e 2679 2695 836.944
r_2679_2695_i 2679_2695 2695 4256.89
c_2679_2695_i 2679 2679_2695 4.67522e-10
r_3239_3255_e 3239 3255 13758.3
r_3239_3255_i 3239_3255 3255 95645.6
c_3239_3255_i 3239 3239_3255 9.36084e-12
r_3799_3815_e 3799 3815 13758.3
r_3799_3815_i 3799_3815 3815 95645.6
c_3799_3815_i 3799 3799_3815 9.36084e-12
r_440_456_e 440 456 13376.4
r_440_456_i 440_456 456 93218.1
c_440_456_i 440 440_456 2.08965e-09
r_1000_1016_e 1000 1016 13376.4
r_1000_1016_i 1000_1016 1016 93218.1
c_1000_1016_i 1000 1000_1016 2.08965e-09
r_1560_1576_e 1560 1576 836.944
r_1560_1576_i 1560_1576 1576 4256.89
c_1560_1576_i 1560 1560_1576 4.67522e-10
r_2120_2136_e 2120 2136 836.944
r_2120_2136_i 2120_2136 2136 4256.89
c_2120_2136_i 2120 2120_2136 4.67522e-10
r_2680_2696_e 2680 2696 836.944
r_2680_2696_i 2680_2696 2696 4256.89
c_2680_2696_i 2680 2680_2696 4.67522e-10
r_3240_3256_e 3240 3256 13758.3
r_3240_3256_i 3240_3256 3256 95645.6
c_3240_3256_i 3240 3240_3256 9.36084e-12
r_3800_3816_e 3800 3816 13758.3
r_3800_3816_i 3800_3816 3816 95645.6
c_3800_3816_i 3800 3800_3816 9.36084e-12
r_441_457_e 441 457 13376.4
r_441_457_i 441_457 457 93218.1
c_441_457_i 441 441_457 2.08965e-09
r_1001_1017_e 1001 1017 13376.4
r_1001_1017_i 1001_1017 1017 93218.1
c_1001_1017_i 1001 1001_1017 2.08965e-09
r_1561_1577_e 1561 1577 836.944
r_1561_1577_i 1561_1577 1577 4256.89
c_1561_1577_i 1561 1561_1577 4.67522e-10
r_2121_2137_e 2121 2137 836.944
r_2121_2137_i 2121_2137 2137 4256.89
c_2121_2137_i 2121 2121_2137 4.67522e-10
r_2681_2697_e 2681 2697 836.944
r_2681_2697_i 2681_2697 2697 4256.89
c_2681_2697_i 2681 2681_2697 4.67522e-10
r_3241_3257_e 3241 3257 13758.3
r_3241_3257_i 3241_3257 3257 95645.6
c_3241_3257_i 3241 3241_3257 9.36084e-12
r_3801_3817_e 3801 3817 13758.3
r_3801_3817_i 3801_3817 3817 95645.6
c_3801_3817_i 3801 3801_3817 9.36084e-12
r_442_458_e 442 458 13376.4
r_442_458_i 442_458 458 93218.1
c_442_458_i 442 442_458 2.08965e-09
r_1002_1018_e 1002 1018 13376.4
r_1002_1018_i 1002_1018 1018 93218.1
c_1002_1018_i 1002 1002_1018 2.08965e-09
r_1562_1578_e 1562 1578 836.944
r_1562_1578_i 1562_1578 1578 4256.89
c_1562_1578_i 1562 1562_1578 4.67522e-10
r_2122_2138_e 2122 2138 836.944
r_2122_2138_i 2122_2138 2138 4256.89
c_2122_2138_i 2122 2122_2138 4.67522e-10
r_2682_2698_e 2682 2698 836.944
r_2682_2698_i 2682_2698 2698 4256.89
c_2682_2698_i 2682 2682_2698 4.67522e-10
r_3242_3258_e 3242 3258 13758.3
r_3242_3258_i 3242_3258 3258 95645.6
c_3242_3258_i 3242 3242_3258 9.36084e-12
r_3802_3818_e 3802 3818 13758.3
r_3802_3818_i 3802_3818 3818 95645.6
c_3802_3818_i 3802 3802_3818 9.36084e-12
r_443_459_e 443 459 13376.4
r_443_459_i 443_459 459 93218.1
c_443_459_i 443 443_459 2.08965e-09
r_1003_1019_e 1003 1019 396.535
r_1003_1019_i 1003_1019 1019 1004.86
c_1003_1019_i 1003 1003_1019 1.65863e-10
r_1563_1579_e 1563 1579 396.535
r_1563_1579_i 1563_1579 1579 1004.86
c_1563_1579_i 1563 1563_1579 1.65863e-10
r_2123_2139_e 2123 2139 836.944
r_2123_2139_i 2123_2139 2139 4256.89
c_2123_2139_i 2123 2123_2139 4.67522e-10
r_2683_2699_e 2683 2699 836.944
r_2683_2699_i 2683_2699 2699 4256.89
c_2683_2699_i 2683 2683_2699 4.67522e-10
r_3243_3259_e 3243 3259 13758.3
r_3243_3259_i 3243_3259 3259 95645.6
c_3243_3259_i 3243 3243_3259 9.36084e-12
r_3803_3819_e 3803 3819 13758.3
r_3803_3819_i 3803_3819 3819 95645.6
c_3803_3819_i 3803 3803_3819 9.36084e-12
r_444_460_e 444 460 13376.4
r_444_460_i 444_460 460 93218.1
c_444_460_i 444 444_460 2.08965e-09
r_1004_1020_e 1004 1020 396.535
r_1004_1020_i 1004_1020 1020 1004.86
c_1004_1020_i 1004 1004_1020 1.65863e-10
r_1564_1580_e 1564 1580 396.535
r_1564_1580_i 1564_1580 1580 1004.86
c_1564_1580_i 1564 1564_1580 1.65863e-10
r_2124_2140_e 2124 2140 836.944
r_2124_2140_i 2124_2140 2140 4256.89
c_2124_2140_i 2124 2124_2140 4.67522e-10
r_2684_2700_e 2684 2700 836.944
r_2684_2700_i 2684_2700 2700 4256.89
c_2684_2700_i 2684 2684_2700 4.67522e-10
r_3244_3260_e 3244 3260 13758.3
r_3244_3260_i 3244_3260 3260 95645.6
c_3244_3260_i 3244 3244_3260 9.36084e-12
r_3804_3820_e 3804 3820 13758.3
r_3804_3820_i 3804_3820 3820 95645.6
c_3804_3820_i 3804 3804_3820 9.36084e-12
r_445_461_e 445 461 13376.4
r_445_461_i 445_461 461 93218.1
c_445_461_i 445 445_461 2.08965e-09
r_1005_1021_e 1005 1021 13376.4
r_1005_1021_i 1005_1021 1021 93218.1
c_1005_1021_i 1005 1005_1021 2.08965e-09
r_1565_1581_e 1565 1581 836.944
r_1565_1581_i 1565_1581 1581 4256.89
c_1565_1581_i 1565 1565_1581 4.67522e-10
r_2125_2141_e 2125 2141 836.944
r_2125_2141_i 2125_2141 2141 4256.89
c_2125_2141_i 2125 2125_2141 4.67522e-10
r_2685_2701_e 2685 2701 836.944
r_2685_2701_i 2685_2701 2701 4256.89
c_2685_2701_i 2685 2685_2701 4.67522e-10
r_3245_3261_e 3245 3261 13758.3
r_3245_3261_i 3245_3261 3261 95645.6
c_3245_3261_i 3245 3245_3261 9.36084e-12
r_3805_3821_e 3805 3821 13758.3
r_3805_3821_i 3805_3821 3821 95645.6
c_3805_3821_i 3805 3805_3821 9.36084e-12
r_446_462_e 446 462 13376.4
r_446_462_i 446_462 462 93218.1
c_446_462_i 446 446_462 2.08965e-09
r_1006_1022_e 1006 1022 13376.4
r_1006_1022_i 1006_1022 1022 93218.1
c_1006_1022_i 1006 1006_1022 2.08965e-09
r_1566_1582_e 1566 1582 836.944
r_1566_1582_i 1566_1582 1582 4256.89
c_1566_1582_i 1566 1566_1582 4.67522e-10
r_2126_2142_e 2126 2142 836.944
r_2126_2142_i 2126_2142 2142 4256.89
c_2126_2142_i 2126 2126_2142 4.67522e-10
r_2686_2702_e 2686 2702 836.944
r_2686_2702_i 2686_2702 2702 4256.89
c_2686_2702_i 2686 2686_2702 4.67522e-10
r_3246_3262_e 3246 3262 13758.3
r_3246_3262_i 3246_3262 3262 95645.6
c_3246_3262_i 3246 3246_3262 9.36084e-12
r_3806_3822_e 3806 3822 13758.3
r_3806_3822_i 3806_3822 3822 95645.6
c_3806_3822_i 3806 3806_3822 9.36084e-12
r_447_463_e 447 463 13376.4
r_447_463_i 447_463 463 93218.1
c_447_463_i 447 447_463 2.08965e-09
r_1007_1023_e 1007 1023 13376.4
r_1007_1023_i 1007_1023 1023 93218.1
c_1007_1023_i 1007 1007_1023 2.08965e-09
r_1567_1583_e 1567 1583 836.944
r_1567_1583_i 1567_1583 1583 4256.89
c_1567_1583_i 1567 1567_1583 4.67522e-10
r_2127_2143_e 2127 2143 836.944
r_2127_2143_i 2127_2143 2143 4256.89
c_2127_2143_i 2127 2127_2143 4.67522e-10
r_2687_2703_e 2687 2703 836.944
r_2687_2703_i 2687_2703 2703 4256.89
c_2687_2703_i 2687 2687_2703 4.67522e-10
r_3247_3263_e 3247 3263 13758.3
r_3247_3263_i 3247_3263 3263 95645.6
c_3247_3263_i 3247 3247_3263 9.36084e-12
r_3807_3823_e 3807 3823 13758.3
r_3807_3823_i 3807_3823 3823 95645.6
c_3807_3823_i 3807 3807_3823 9.36084e-12
r_448_464_e 448 464 13376.4
r_448_464_i 448_464 464 93218.1
c_448_464_i 448 448_464 2.08965e-09
r_1008_1024_e 1008 1024 13376.4
r_1008_1024_i 1008_1024 1024 93218.1
c_1008_1024_i 1008 1008_1024 2.08965e-09
r_1568_1584_e 1568 1584 836.944
r_1568_1584_i 1568_1584 1584 4256.89
c_1568_1584_i 1568 1568_1584 4.67522e-10
r_2128_2144_e 2128 2144 836.944
r_2128_2144_i 2128_2144 2144 4256.89
c_2128_2144_i 2128 2128_2144 4.67522e-10
r_2688_2704_e 2688 2704 836.944
r_2688_2704_i 2688_2704 2704 4256.89
c_2688_2704_i 2688 2688_2704 4.67522e-10
r_3248_3264_e 3248 3264 13758.3
r_3248_3264_i 3248_3264 3264 95645.6
c_3248_3264_i 3248 3248_3264 9.36084e-12
r_3808_3824_e 3808 3824 13758.3
r_3808_3824_i 3808_3824 3824 95645.6
c_3808_3824_i 3808 3808_3824 9.36084e-12
r_449_465_e 449 465 13376.4
r_449_465_i 449_465 465 93218.1
c_449_465_i 449 449_465 2.08965e-09
r_1009_1025_e 1009 1025 13376.4
r_1009_1025_i 1009_1025 1025 93218.1
c_1009_1025_i 1009 1009_1025 2.08965e-09
r_1569_1585_e 1569 1585 13376.4
r_1569_1585_i 1569_1585 1585 93218.1
c_1569_1585_i 1569 1569_1585 2.08965e-09
r_2129_2145_e 2129 2145 13376.4
r_2129_2145_i 2129_2145 2145 93218.1
c_2129_2145_i 2129 2129_2145 2.08965e-09
r_2689_2705_e 2689 2705 13376.4
r_2689_2705_i 2689_2705 2705 93218.1
c_2689_2705_i 2689 2689_2705 2.08965e-09
r_3249_3265_e 3249 3265 13376.4
r_3249_3265_i 3249_3265 3265 93218.1
c_3249_3265_i 3249 3249_3265 2.08965e-09
r_3809_3825_e 3809 3825 13376.4
r_3809_3825_i 3809_3825 3825 93218.1
c_3809_3825_i 3809 3809_3825 2.08965e-09
r_450_466_e 450 466 13376.4
r_450_466_i 450_466 466 93218.1
c_450_466_i 450 450_466 2.08965e-09
r_1010_1026_e 1010 1026 13376.4
r_1010_1026_i 1010_1026 1026 93218.1
c_1010_1026_i 1010 1010_1026 2.08965e-09
r_1570_1586_e 1570 1586 13376.4
r_1570_1586_i 1570_1586 1586 93218.1
c_1570_1586_i 1570 1570_1586 2.08965e-09
r_2130_2146_e 2130 2146 13376.4
r_2130_2146_i 2130_2146 2146 93218.1
c_2130_2146_i 2130 2130_2146 2.08965e-09
r_2690_2706_e 2690 2706 13376.4
r_2690_2706_i 2690_2706 2706 93218.1
c_2690_2706_i 2690 2690_2706 2.08965e-09
r_3250_3266_e 3250 3266 13376.4
r_3250_3266_i 3250_3266 3266 93218.1
c_3250_3266_i 3250 3250_3266 2.08965e-09
r_3810_3826_e 3810 3826 13376.4
r_3810_3826_i 3810_3826 3826 93218.1
c_3810_3826_i 3810 3810_3826 2.08965e-09
r_451_467_e 451 467 13376.4
r_451_467_i 451_467 467 93218.1
c_451_467_i 451 451_467 2.08965e-09
r_1011_1027_e 1011 1027 13376.4
r_1011_1027_i 1011_1027 1027 93218.1
c_1011_1027_i 1011 1011_1027 2.08965e-09
r_1571_1587_e 1571 1587 836.944
r_1571_1587_i 1571_1587 1587 4256.89
c_1571_1587_i 1571 1571_1587 4.67522e-10
r_2131_2147_e 2131 2147 836.944
r_2131_2147_i 2131_2147 2147 4256.89
c_2131_2147_i 2131 2131_2147 4.67522e-10
r_2691_2707_e 2691 2707 836.944
r_2691_2707_i 2691_2707 2707 4256.89
c_2691_2707_i 2691 2691_2707 4.67522e-10
r_3251_3267_e 3251 3267 836.944
r_3251_3267_i 3251_3267 3267 4256.89
c_3251_3267_i 3251 3251_3267 4.67522e-10
r_3811_3827_e 3811 3827 836.944
r_3811_3827_i 3811_3827 3827 4256.89
c_3811_3827_i 3811 3811_3827 4.67522e-10
r_452_468_e 452 468 13376.4
r_452_468_i 452_468 468 93218.1
c_452_468_i 452 452_468 2.08965e-09
r_1012_1028_e 1012 1028 13376.4
r_1012_1028_i 1012_1028 1028 93218.1
c_1012_1028_i 1012 1012_1028 2.08965e-09
r_1572_1588_e 1572 1588 836.944
r_1572_1588_i 1572_1588 1588 4256.89
c_1572_1588_i 1572 1572_1588 4.67522e-10
r_2132_2148_e 2132 2148 836.944
r_2132_2148_i 2132_2148 2148 4256.89
c_2132_2148_i 2132 2132_2148 4.67522e-10
r_2692_2708_e 2692 2708 836.944
r_2692_2708_i 2692_2708 2708 4256.89
c_2692_2708_i 2692 2692_2708 4.67522e-10
r_3252_3268_e 3252 3268 13758.3
r_3252_3268_i 3252_3268 3268 95645.6
c_3252_3268_i 3252 3252_3268 9.36084e-12
r_3812_3828_e 3812 3828 13758.3
r_3812_3828_i 3812_3828 3828 95645.6
c_3812_3828_i 3812 3812_3828 9.36084e-12
r_453_469_e 453 469 13376.4
r_453_469_i 453_469 469 93218.1
c_453_469_i 453 453_469 2.08965e-09
r_1013_1029_e 1013 1029 13376.4
r_1013_1029_i 1013_1029 1029 93218.1
c_1013_1029_i 1013 1013_1029 2.08965e-09
r_1573_1589_e 1573 1589 836.944
r_1573_1589_i 1573_1589 1589 4256.89
c_1573_1589_i 1573 1573_1589 4.67522e-10
r_2133_2149_e 2133 2149 836.944
r_2133_2149_i 2133_2149 2149 4256.89
c_2133_2149_i 2133 2133_2149 4.67522e-10
r_2693_2709_e 2693 2709 836.944
r_2693_2709_i 2693_2709 2709 4256.89
c_2693_2709_i 2693 2693_2709 4.67522e-10
r_3253_3269_e 3253 3269 13758.3
r_3253_3269_i 3253_3269 3269 95645.6
c_3253_3269_i 3253 3253_3269 9.36084e-12
r_3813_3829_e 3813 3829 13758.3
r_3813_3829_i 3813_3829 3829 95645.6
c_3813_3829_i 3813 3813_3829 9.36084e-12
r_454_470_e 454 470 13376.4
r_454_470_i 454_470 470 93218.1
c_454_470_i 454 454_470 2.08965e-09
r_1014_1030_e 1014 1030 13376.4
r_1014_1030_i 1014_1030 1030 93218.1
c_1014_1030_i 1014 1014_1030 2.08965e-09
r_1574_1590_e 1574 1590 836.944
r_1574_1590_i 1574_1590 1590 4256.89
c_1574_1590_i 1574 1574_1590 4.67522e-10
r_2134_2150_e 2134 2150 836.944
r_2134_2150_i 2134_2150 2150 4256.89
c_2134_2150_i 2134 2134_2150 4.67522e-10
r_2694_2710_e 2694 2710 836.944
r_2694_2710_i 2694_2710 2710 4256.89
c_2694_2710_i 2694 2694_2710 4.67522e-10
r_3254_3270_e 3254 3270 13758.3
r_3254_3270_i 3254_3270 3270 95645.6
c_3254_3270_i 3254 3254_3270 9.36084e-12
r_3814_3830_e 3814 3830 13758.3
r_3814_3830_i 3814_3830 3830 95645.6
c_3814_3830_i 3814 3814_3830 9.36084e-12
r_455_471_e 455 471 13376.4
r_455_471_i 455_471 471 93218.1
c_455_471_i 455 455_471 2.08965e-09
r_1015_1031_e 1015 1031 13376.4
r_1015_1031_i 1015_1031 1031 93218.1
c_1015_1031_i 1015 1015_1031 2.08965e-09
r_1575_1591_e 1575 1591 836.944
r_1575_1591_i 1575_1591 1591 4256.89
c_1575_1591_i 1575 1575_1591 4.67522e-10
r_2135_2151_e 2135 2151 836.944
r_2135_2151_i 2135_2151 2151 4256.89
c_2135_2151_i 2135 2135_2151 4.67522e-10
r_2695_2711_e 2695 2711 836.944
r_2695_2711_i 2695_2711 2711 4256.89
c_2695_2711_i 2695 2695_2711 4.67522e-10
r_3255_3271_e 3255 3271 13758.3
r_3255_3271_i 3255_3271 3271 95645.6
c_3255_3271_i 3255 3255_3271 9.36084e-12
r_3815_3831_e 3815 3831 13758.3
r_3815_3831_i 3815_3831 3831 95645.6
c_3815_3831_i 3815 3815_3831 9.36084e-12
r_456_472_e 456 472 13376.4
r_456_472_i 456_472 472 93218.1
c_456_472_i 456 456_472 2.08965e-09
r_1016_1032_e 1016 1032 13376.4
r_1016_1032_i 1016_1032 1032 93218.1
c_1016_1032_i 1016 1016_1032 2.08965e-09
r_1576_1592_e 1576 1592 836.944
r_1576_1592_i 1576_1592 1592 4256.89
c_1576_1592_i 1576 1576_1592 4.67522e-10
r_2136_2152_e 2136 2152 836.944
r_2136_2152_i 2136_2152 2152 4256.89
c_2136_2152_i 2136 2136_2152 4.67522e-10
r_2696_2712_e 2696 2712 836.944
r_2696_2712_i 2696_2712 2712 4256.89
c_2696_2712_i 2696 2696_2712 4.67522e-10
r_3256_3272_e 3256 3272 13758.3
r_3256_3272_i 3256_3272 3272 95645.6
c_3256_3272_i 3256 3256_3272 9.36084e-12
r_3816_3832_e 3816 3832 13758.3
r_3816_3832_i 3816_3832 3832 95645.6
c_3816_3832_i 3816 3816_3832 9.36084e-12
r_457_473_e 457 473 13376.4
r_457_473_i 457_473 473 93218.1
c_457_473_i 457 457_473 2.08965e-09
r_1017_1033_e 1017 1033 13376.4
r_1017_1033_i 1017_1033 1033 93218.1
c_1017_1033_i 1017 1017_1033 2.08965e-09
r_1577_1593_e 1577 1593 836.944
r_1577_1593_i 1577_1593 1593 4256.89
c_1577_1593_i 1577 1577_1593 4.67522e-10
r_2137_2153_e 2137 2153 836.944
r_2137_2153_i 2137_2153 2153 4256.89
c_2137_2153_i 2137 2137_2153 4.67522e-10
r_2697_2713_e 2697 2713 836.944
r_2697_2713_i 2697_2713 2713 4256.89
c_2697_2713_i 2697 2697_2713 4.67522e-10
r_3257_3273_e 3257 3273 13758.3
r_3257_3273_i 3257_3273 3273 95645.6
c_3257_3273_i 3257 3257_3273 9.36084e-12
r_3817_3833_e 3817 3833 13758.3
r_3817_3833_i 3817_3833 3833 95645.6
c_3817_3833_i 3817 3817_3833 9.36084e-12
r_458_474_e 458 474 13376.4
r_458_474_i 458_474 474 93218.1
c_458_474_i 458 458_474 2.08965e-09
r_1018_1034_e 1018 1034 13376.4
r_1018_1034_i 1018_1034 1034 93218.1
c_1018_1034_i 1018 1018_1034 2.08965e-09
r_1578_1594_e 1578 1594 836.944
r_1578_1594_i 1578_1594 1594 4256.89
c_1578_1594_i 1578 1578_1594 4.67522e-10
r_2138_2154_e 2138 2154 836.944
r_2138_2154_i 2138_2154 2154 4256.89
c_2138_2154_i 2138 2138_2154 4.67522e-10
r_2698_2714_e 2698 2714 836.944
r_2698_2714_i 2698_2714 2714 4256.89
c_2698_2714_i 2698 2698_2714 4.67522e-10
r_3258_3274_e 3258 3274 13758.3
r_3258_3274_i 3258_3274 3274 95645.6
c_3258_3274_i 3258 3258_3274 9.36084e-12
r_3818_3834_e 3818 3834 13758.3
r_3818_3834_i 3818_3834 3834 95645.6
c_3818_3834_i 3818 3818_3834 9.36084e-12
r_459_475_e 459 475 13376.4
r_459_475_i 459_475 475 93218.1
c_459_475_i 459 459_475 2.08965e-09
r_1019_1035_e 1019 1035 396.526
r_1019_1035_i 1019_1035 1035 1004.84
c_1019_1035_i 1019 1019_1035 1.65866e-10
r_1579_1595_e 1579 1595 396.526
r_1579_1595_i 1579_1595 1595 1004.84
c_1579_1595_i 1579 1579_1595 1.65866e-10
r_2139_2155_e 2139 2155 836.944
r_2139_2155_i 2139_2155 2155 4256.89
c_2139_2155_i 2139 2139_2155 4.67522e-10
r_2699_2715_e 2699 2715 836.944
r_2699_2715_i 2699_2715 2715 4256.89
c_2699_2715_i 2699 2699_2715 4.67522e-10
r_3259_3275_e 3259 3275 13758.3
r_3259_3275_i 3259_3275 3275 95645.6
c_3259_3275_i 3259 3259_3275 9.36084e-12
r_3819_3835_e 3819 3835 13758.3
r_3819_3835_i 3819_3835 3835 95645.6
c_3819_3835_i 3819 3819_3835 9.36084e-12
r_460_476_e 460 476 13376.4
r_460_476_i 460_476 476 93218.1
c_460_476_i 460 460_476 2.08965e-09
r_1020_1036_e 1020 1036 396.526
r_1020_1036_i 1020_1036 1036 1004.84
c_1020_1036_i 1020 1020_1036 1.65866e-10
r_1580_1596_e 1580 1596 396.526
r_1580_1596_i 1580_1596 1596 1004.84
c_1580_1596_i 1580 1580_1596 1.65866e-10
r_2140_2156_e 2140 2156 836.944
r_2140_2156_i 2140_2156 2156 4256.89
c_2140_2156_i 2140 2140_2156 4.67522e-10
r_2700_2716_e 2700 2716 836.944
r_2700_2716_i 2700_2716 2716 4256.89
c_2700_2716_i 2700 2700_2716 4.67522e-10
r_3260_3276_e 3260 3276 13758.3
r_3260_3276_i 3260_3276 3276 95645.6
c_3260_3276_i 3260 3260_3276 9.36084e-12
r_3820_3836_e 3820 3836 13758.3
r_3820_3836_i 3820_3836 3836 95645.6
c_3820_3836_i 3820 3820_3836 9.36084e-12
r_461_477_e 461 477 13376.4
r_461_477_i 461_477 477 93218.1
c_461_477_i 461 461_477 2.08965e-09
r_1021_1037_e 1021 1037 13376.4
r_1021_1037_i 1021_1037 1037 93218.1
c_1021_1037_i 1021 1021_1037 2.08965e-09
r_1581_1597_e 1581 1597 836.944
r_1581_1597_i 1581_1597 1597 4256.89
c_1581_1597_i 1581 1581_1597 4.67522e-10
r_2141_2157_e 2141 2157 836.944
r_2141_2157_i 2141_2157 2157 4256.89
c_2141_2157_i 2141 2141_2157 4.67522e-10
r_2701_2717_e 2701 2717 836.944
r_2701_2717_i 2701_2717 2717 4256.89
c_2701_2717_i 2701 2701_2717 4.67522e-10
r_3261_3277_e 3261 3277 13758.3
r_3261_3277_i 3261_3277 3277 95645.6
c_3261_3277_i 3261 3261_3277 9.36084e-12
r_3821_3837_e 3821 3837 13758.3
r_3821_3837_i 3821_3837 3837 95645.6
c_3821_3837_i 3821 3821_3837 9.36084e-12
r_462_478_e 462 478 13376.4
r_462_478_i 462_478 478 93218.1
c_462_478_i 462 462_478 2.08965e-09
r_1022_1038_e 1022 1038 13376.4
r_1022_1038_i 1022_1038 1038 93218.1
c_1022_1038_i 1022 1022_1038 2.08965e-09
r_1582_1598_e 1582 1598 836.944
r_1582_1598_i 1582_1598 1598 4256.89
c_1582_1598_i 1582 1582_1598 4.67522e-10
r_2142_2158_e 2142 2158 836.944
r_2142_2158_i 2142_2158 2158 4256.89
c_2142_2158_i 2142 2142_2158 4.67522e-10
r_2702_2718_e 2702 2718 836.944
r_2702_2718_i 2702_2718 2718 4256.89
c_2702_2718_i 2702 2702_2718 4.67522e-10
r_3262_3278_e 3262 3278 13758.3
r_3262_3278_i 3262_3278 3278 95645.6
c_3262_3278_i 3262 3262_3278 9.36084e-12
r_3822_3838_e 3822 3838 13758.3
r_3822_3838_i 3822_3838 3838 95645.6
c_3822_3838_i 3822 3822_3838 9.36084e-12
r_463_479_e 463 479 13376.4
r_463_479_i 463_479 479 93218.1
c_463_479_i 463 463_479 2.08965e-09
r_1023_1039_e 1023 1039 13376.4
r_1023_1039_i 1023_1039 1039 93218.1
c_1023_1039_i 1023 1023_1039 2.08965e-09
r_1583_1599_e 1583 1599 836.944
r_1583_1599_i 1583_1599 1599 4256.89
c_1583_1599_i 1583 1583_1599 4.67522e-10
r_2143_2159_e 2143 2159 836.944
r_2143_2159_i 2143_2159 2159 4256.89
c_2143_2159_i 2143 2143_2159 4.67522e-10
r_2703_2719_e 2703 2719 836.944
r_2703_2719_i 2703_2719 2719 4256.89
c_2703_2719_i 2703 2703_2719 4.67522e-10
r_3263_3279_e 3263 3279 13758.3
r_3263_3279_i 3263_3279 3279 95645.6
c_3263_3279_i 3263 3263_3279 9.36084e-12
r_3823_3839_e 3823 3839 13758.3
r_3823_3839_i 3823_3839 3839 95645.6
c_3823_3839_i 3823 3823_3839 9.36084e-12
r_464_480_e 464 480 13376.4
r_464_480_i 464_480 480 93218.1
c_464_480_i 464 464_480 2.08965e-09
r_1024_1040_e 1024 1040 13376.4
r_1024_1040_i 1024_1040 1040 93218.1
c_1024_1040_i 1024 1024_1040 2.08965e-09
r_1584_1600_e 1584 1600 836.944
r_1584_1600_i 1584_1600 1600 4256.89
c_1584_1600_i 1584 1584_1600 4.67522e-10
r_2144_2160_e 2144 2160 836.944
r_2144_2160_i 2144_2160 2160 4256.89
c_2144_2160_i 2144 2144_2160 4.67522e-10
r_2704_2720_e 2704 2720 836.944
r_2704_2720_i 2704_2720 2720 4256.89
c_2704_2720_i 2704 2704_2720 4.67522e-10
r_3264_3280_e 3264 3280 13758.3
r_3264_3280_i 3264_3280 3280 95645.6
c_3264_3280_i 3264 3264_3280 9.36084e-12
r_3824_3840_e 3824 3840 13758.3
r_3824_3840_i 3824_3840 3840 95645.6
c_3824_3840_i 3824 3824_3840 9.36084e-12
r_465_481_e 465 481 13376.4
r_465_481_i 465_481 481 93218.1
c_465_481_i 465 465_481 2.08965e-09
r_1025_1041_e 1025 1041 13376.4
r_1025_1041_i 1025_1041 1041 93218.1
c_1025_1041_i 1025 1025_1041 2.08965e-09
r_1585_1601_e 1585 1601 13376.4
r_1585_1601_i 1585_1601 1601 93218.1
c_1585_1601_i 1585 1585_1601 2.08965e-09
r_2145_2161_e 2145 2161 13376.4
r_2145_2161_i 2145_2161 2161 93218.1
c_2145_2161_i 2145 2145_2161 2.08965e-09
r_2705_2721_e 2705 2721 13376.4
r_2705_2721_i 2705_2721 2721 93218.1
c_2705_2721_i 2705 2705_2721 2.08965e-09
r_3265_3281_e 3265 3281 13376.4
r_3265_3281_i 3265_3281 3281 93218.1
c_3265_3281_i 3265 3265_3281 2.08965e-09
r_3825_3841_e 3825 3841 13376.4
r_3825_3841_i 3825_3841 3841 93218.1
c_3825_3841_i 3825 3825_3841 2.08965e-09
r_466_482_e 466 482 13376.4
r_466_482_i 466_482 482 93218.1
c_466_482_i 466 466_482 2.08965e-09
r_1026_1042_e 1026 1042 13376.4
r_1026_1042_i 1026_1042 1042 93218.1
c_1026_1042_i 1026 1026_1042 2.08965e-09
r_1586_1602_e 1586 1602 13376.4
r_1586_1602_i 1586_1602 1602 93218.1
c_1586_1602_i 1586 1586_1602 2.08965e-09
r_2146_2162_e 2146 2162 13376.4
r_2146_2162_i 2146_2162 2162 93218.1
c_2146_2162_i 2146 2146_2162 2.08965e-09
r_2706_2722_e 2706 2722 13376.4
r_2706_2722_i 2706_2722 2722 93218.1
c_2706_2722_i 2706 2706_2722 2.08965e-09
r_3266_3282_e 3266 3282 13376.4
r_3266_3282_i 3266_3282 3282 93218.1
c_3266_3282_i 3266 3266_3282 2.08965e-09
r_3826_3842_e 3826 3842 13376.4
r_3826_3842_i 3826_3842 3842 93218.1
c_3826_3842_i 3826 3826_3842 2.08965e-09
r_467_483_e 467 483 13376.4
r_467_483_i 467_483 483 93218.1
c_467_483_i 467 467_483 2.08965e-09
r_1027_1043_e 1027 1043 13376.4
r_1027_1043_i 1027_1043 1043 93218.1
c_1027_1043_i 1027 1027_1043 2.08965e-09
r_1587_1603_e 1587 1603 836.944
r_1587_1603_i 1587_1603 1603 4256.89
c_1587_1603_i 1587 1587_1603 4.67522e-10
r_2147_2163_e 2147 2163 836.944
r_2147_2163_i 2147_2163 2163 4256.89
c_2147_2163_i 2147 2147_2163 4.67522e-10
r_2707_2723_e 2707 2723 836.944
r_2707_2723_i 2707_2723 2723 4256.89
c_2707_2723_i 2707 2707_2723 4.67522e-10
r_3267_3283_e 3267 3283 836.944
r_3267_3283_i 3267_3283 3283 4256.89
c_3267_3283_i 3267 3267_3283 4.67522e-10
r_3827_3843_e 3827 3843 836.944
r_3827_3843_i 3827_3843 3843 4256.89
c_3827_3843_i 3827 3827_3843 4.67522e-10
r_468_484_e 468 484 13376.4
r_468_484_i 468_484 484 93218.1
c_468_484_i 468 468_484 2.08965e-09
r_1028_1044_e 1028 1044 13376.4
r_1028_1044_i 1028_1044 1044 93218.1
c_1028_1044_i 1028 1028_1044 2.08965e-09
r_1588_1604_e 1588 1604 836.944
r_1588_1604_i 1588_1604 1604 4256.89
c_1588_1604_i 1588 1588_1604 4.67522e-10
r_2148_2164_e 2148 2164 836.944
r_2148_2164_i 2148_2164 2164 4256.89
c_2148_2164_i 2148 2148_2164 4.67522e-10
r_2708_2724_e 2708 2724 836.944
r_2708_2724_i 2708_2724 2724 4256.89
c_2708_2724_i 2708 2708_2724 4.67522e-10
r_3268_3284_e 3268 3284 13758.3
r_3268_3284_i 3268_3284 3284 95645.6
c_3268_3284_i 3268 3268_3284 9.36084e-12
r_3828_3844_e 3828 3844 13758.3
r_3828_3844_i 3828_3844 3844 95645.6
c_3828_3844_i 3828 3828_3844 9.36084e-12
r_469_485_e 469 485 13376.4
r_469_485_i 469_485 485 93218.1
c_469_485_i 469 469_485 2.08965e-09
r_1029_1045_e 1029 1045 13376.4
r_1029_1045_i 1029_1045 1045 93218.1
c_1029_1045_i 1029 1029_1045 2.08965e-09
r_1589_1605_e 1589 1605 836.944
r_1589_1605_i 1589_1605 1605 4256.89
c_1589_1605_i 1589 1589_1605 4.67522e-10
r_2149_2165_e 2149 2165 836.944
r_2149_2165_i 2149_2165 2165 4256.89
c_2149_2165_i 2149 2149_2165 4.67522e-10
r_2709_2725_e 2709 2725 836.944
r_2709_2725_i 2709_2725 2725 4256.89
c_2709_2725_i 2709 2709_2725 4.67522e-10
r_3269_3285_e 3269 3285 13758.3
r_3269_3285_i 3269_3285 3285 95645.6
c_3269_3285_i 3269 3269_3285 9.36084e-12
r_3829_3845_e 3829 3845 13758.3
r_3829_3845_i 3829_3845 3845 95645.6
c_3829_3845_i 3829 3829_3845 9.36084e-12
r_470_486_e 470 486 13376.4
r_470_486_i 470_486 486 93218.1
c_470_486_i 470 470_486 2.08965e-09
r_1030_1046_e 1030 1046 13376.4
r_1030_1046_i 1030_1046 1046 93218.1
c_1030_1046_i 1030 1030_1046 2.08965e-09
r_1590_1606_e 1590 1606 836.944
r_1590_1606_i 1590_1606 1606 4256.89
c_1590_1606_i 1590 1590_1606 4.67522e-10
r_2150_2166_e 2150 2166 836.944
r_2150_2166_i 2150_2166 2166 4256.89
c_2150_2166_i 2150 2150_2166 4.67522e-10
r_2710_2726_e 2710 2726 836.944
r_2710_2726_i 2710_2726 2726 4256.89
c_2710_2726_i 2710 2710_2726 4.67522e-10
r_3270_3286_e 3270 3286 13758.3
r_3270_3286_i 3270_3286 3286 95645.6
c_3270_3286_i 3270 3270_3286 9.36084e-12
r_3830_3846_e 3830 3846 13758.3
r_3830_3846_i 3830_3846 3846 95645.6
c_3830_3846_i 3830 3830_3846 9.36084e-12
r_471_487_e 471 487 13376.4
r_471_487_i 471_487 487 93218.1
c_471_487_i 471 471_487 2.08965e-09
r_1031_1047_e 1031 1047 13376.4
r_1031_1047_i 1031_1047 1047 93218.1
c_1031_1047_i 1031 1031_1047 2.08965e-09
r_1591_1607_e 1591 1607 836.944
r_1591_1607_i 1591_1607 1607 4256.89
c_1591_1607_i 1591 1591_1607 4.67522e-10
r_2151_2167_e 2151 2167 836.944
r_2151_2167_i 2151_2167 2167 4256.89
c_2151_2167_i 2151 2151_2167 4.67522e-10
r_2711_2727_e 2711 2727 836.944
r_2711_2727_i 2711_2727 2727 4256.89
c_2711_2727_i 2711 2711_2727 4.67522e-10
r_3271_3287_e 3271 3287 13758.3
r_3271_3287_i 3271_3287 3287 95645.6
c_3271_3287_i 3271 3271_3287 9.36084e-12
r_3831_3847_e 3831 3847 13758.3
r_3831_3847_i 3831_3847 3847 95645.6
c_3831_3847_i 3831 3831_3847 9.36084e-12
r_472_488_e 472 488 13376.4
r_472_488_i 472_488 488 93218.1
c_472_488_i 472 472_488 2.08965e-09
r_1032_1048_e 1032 1048 13376.4
r_1032_1048_i 1032_1048 1048 93218.1
c_1032_1048_i 1032 1032_1048 2.08965e-09
r_1592_1608_e 1592 1608 836.944
r_1592_1608_i 1592_1608 1608 4256.89
c_1592_1608_i 1592 1592_1608 4.67522e-10
r_2152_2168_e 2152 2168 836.944
r_2152_2168_i 2152_2168 2168 4256.89
c_2152_2168_i 2152 2152_2168 4.67522e-10
r_2712_2728_e 2712 2728 836.944
r_2712_2728_i 2712_2728 2728 4256.89
c_2712_2728_i 2712 2712_2728 4.67522e-10
r_3272_3288_e 3272 3288 13758.3
r_3272_3288_i 3272_3288 3288 95645.6
c_3272_3288_i 3272 3272_3288 9.36084e-12
r_3832_3848_e 3832 3848 13758.3
r_3832_3848_i 3832_3848 3848 95645.6
c_3832_3848_i 3832 3832_3848 9.36084e-12
r_473_489_e 473 489 13376.4
r_473_489_i 473_489 489 93218.1
c_473_489_i 473 473_489 2.08965e-09
r_1033_1049_e 1033 1049 13376.4
r_1033_1049_i 1033_1049 1049 93218.1
c_1033_1049_i 1033 1033_1049 2.08965e-09
r_1593_1609_e 1593 1609 836.944
r_1593_1609_i 1593_1609 1609 4256.89
c_1593_1609_i 1593 1593_1609 4.67522e-10
r_2153_2169_e 2153 2169 836.944
r_2153_2169_i 2153_2169 2169 4256.89
c_2153_2169_i 2153 2153_2169 4.67522e-10
r_2713_2729_e 2713 2729 836.944
r_2713_2729_i 2713_2729 2729 4256.89
c_2713_2729_i 2713 2713_2729 4.67522e-10
r_3273_3289_e 3273 3289 13758.3
r_3273_3289_i 3273_3289 3289 95645.6
c_3273_3289_i 3273 3273_3289 9.36084e-12
r_3833_3849_e 3833 3849 13758.3
r_3833_3849_i 3833_3849 3849 95645.6
c_3833_3849_i 3833 3833_3849 9.36084e-12
r_474_490_e 474 490 13376.4
r_474_490_i 474_490 490 93218.1
c_474_490_i 474 474_490 2.08965e-09
r_1034_1050_e 1034 1050 13376.4
r_1034_1050_i 1034_1050 1050 93218.1
c_1034_1050_i 1034 1034_1050 2.08965e-09
r_1594_1610_e 1594 1610 836.944
r_1594_1610_i 1594_1610 1610 4256.89
c_1594_1610_i 1594 1594_1610 4.67522e-10
r_2154_2170_e 2154 2170 836.944
r_2154_2170_i 2154_2170 2170 4256.89
c_2154_2170_i 2154 2154_2170 4.67522e-10
r_2714_2730_e 2714 2730 836.944
r_2714_2730_i 2714_2730 2730 4256.89
c_2714_2730_i 2714 2714_2730 4.67522e-10
r_3274_3290_e 3274 3290 13758.3
r_3274_3290_i 3274_3290 3290 95645.6
c_3274_3290_i 3274 3274_3290 9.36084e-12
r_3834_3850_e 3834 3850 13758.3
r_3834_3850_i 3834_3850 3850 95645.6
c_3834_3850_i 3834 3834_3850 9.36084e-12
r_475_491_e 475 491 13376.4
r_475_491_i 475_491 491 93218.1
c_475_491_i 475 475_491 2.08965e-09
r_1035_1051_e 1035 1051 396.518
r_1035_1051_i 1035_1051 1051 1004.81
c_1035_1051_i 1035 1035_1051 1.65869e-10
r_1595_1611_e 1595 1611 396.518
r_1595_1611_i 1595_1611 1611 1004.81
c_1595_1611_i 1595 1595_1611 1.65869e-10
r_2155_2171_e 2155 2171 836.944
r_2155_2171_i 2155_2171 2171 4256.89
c_2155_2171_i 2155 2155_2171 4.67522e-10
r_2715_2731_e 2715 2731 836.944
r_2715_2731_i 2715_2731 2731 4256.89
c_2715_2731_i 2715 2715_2731 4.67522e-10
r_3275_3291_e 3275 3291 13758.3
r_3275_3291_i 3275_3291 3291 95645.6
c_3275_3291_i 3275 3275_3291 9.36084e-12
r_3835_3851_e 3835 3851 13758.3
r_3835_3851_i 3835_3851 3851 95645.6
c_3835_3851_i 3835 3835_3851 9.36084e-12
r_476_492_e 476 492 13376.4
r_476_492_i 476_492 492 93218.1
c_476_492_i 476 476_492 2.08965e-09
r_1036_1052_e 1036 1052 396.518
r_1036_1052_i 1036_1052 1052 1004.81
c_1036_1052_i 1036 1036_1052 1.65869e-10
r_1596_1612_e 1596 1612 396.518
r_1596_1612_i 1596_1612 1612 1004.81
c_1596_1612_i 1596 1596_1612 1.65869e-10
r_2156_2172_e 2156 2172 836.944
r_2156_2172_i 2156_2172 2172 4256.89
c_2156_2172_i 2156 2156_2172 4.67522e-10
r_2716_2732_e 2716 2732 836.944
r_2716_2732_i 2716_2732 2732 4256.89
c_2716_2732_i 2716 2716_2732 4.67522e-10
r_3276_3292_e 3276 3292 13758.3
r_3276_3292_i 3276_3292 3292 95645.6
c_3276_3292_i 3276 3276_3292 9.36084e-12
r_3836_3852_e 3836 3852 13758.3
r_3836_3852_i 3836_3852 3852 95645.6
c_3836_3852_i 3836 3836_3852 9.36084e-12
r_477_493_e 477 493 13376.4
r_477_493_i 477_493 493 93218.1
c_477_493_i 477 477_493 2.08965e-09
r_1037_1053_e 1037 1053 13376.4
r_1037_1053_i 1037_1053 1053 93218.1
c_1037_1053_i 1037 1037_1053 2.08965e-09
r_1597_1613_e 1597 1613 836.944
r_1597_1613_i 1597_1613 1613 4256.89
c_1597_1613_i 1597 1597_1613 4.67522e-10
r_2157_2173_e 2157 2173 836.944
r_2157_2173_i 2157_2173 2173 4256.89
c_2157_2173_i 2157 2157_2173 4.67522e-10
r_2717_2733_e 2717 2733 836.944
r_2717_2733_i 2717_2733 2733 4256.89
c_2717_2733_i 2717 2717_2733 4.67522e-10
r_3277_3293_e 3277 3293 13758.3
r_3277_3293_i 3277_3293 3293 95645.6
c_3277_3293_i 3277 3277_3293 9.36084e-12
r_3837_3853_e 3837 3853 13758.3
r_3837_3853_i 3837_3853 3853 95645.6
c_3837_3853_i 3837 3837_3853 9.36084e-12
r_478_494_e 478 494 13376.4
r_478_494_i 478_494 494 93218.1
c_478_494_i 478 478_494 2.08965e-09
r_1038_1054_e 1038 1054 13376.4
r_1038_1054_i 1038_1054 1054 93218.1
c_1038_1054_i 1038 1038_1054 2.08965e-09
r_1598_1614_e 1598 1614 836.944
r_1598_1614_i 1598_1614 1614 4256.89
c_1598_1614_i 1598 1598_1614 4.67522e-10
r_2158_2174_e 2158 2174 836.944
r_2158_2174_i 2158_2174 2174 4256.89
c_2158_2174_i 2158 2158_2174 4.67522e-10
r_2718_2734_e 2718 2734 836.944
r_2718_2734_i 2718_2734 2734 4256.89
c_2718_2734_i 2718 2718_2734 4.67522e-10
r_3278_3294_e 3278 3294 13758.3
r_3278_3294_i 3278_3294 3294 95645.6
c_3278_3294_i 3278 3278_3294 9.36084e-12
r_3838_3854_e 3838 3854 13758.3
r_3838_3854_i 3838_3854 3854 95645.6
c_3838_3854_i 3838 3838_3854 9.36084e-12
r_479_495_e 479 495 13376.4
r_479_495_i 479_495 495 93218.1
c_479_495_i 479 479_495 2.08965e-09
r_1039_1055_e 1039 1055 13376.4
r_1039_1055_i 1039_1055 1055 93218.1
c_1039_1055_i 1039 1039_1055 2.08965e-09
r_1599_1615_e 1599 1615 836.944
r_1599_1615_i 1599_1615 1615 4256.89
c_1599_1615_i 1599 1599_1615 4.67522e-10
r_2159_2175_e 2159 2175 836.944
r_2159_2175_i 2159_2175 2175 4256.89
c_2159_2175_i 2159 2159_2175 4.67522e-10
r_2719_2735_e 2719 2735 836.944
r_2719_2735_i 2719_2735 2735 4256.89
c_2719_2735_i 2719 2719_2735 4.67522e-10
r_3279_3295_e 3279 3295 13758.3
r_3279_3295_i 3279_3295 3295 95645.6
c_3279_3295_i 3279 3279_3295 9.36084e-12
r_3839_3855_e 3839 3855 13758.3
r_3839_3855_i 3839_3855 3855 95645.6
c_3839_3855_i 3839 3839_3855 9.36084e-12
r_480_496_e 480 496 13376.4
r_480_496_i 480_496 496 93218.1
c_480_496_i 480 480_496 2.08965e-09
r_1040_1056_e 1040 1056 13376.4
r_1040_1056_i 1040_1056 1056 93218.1
c_1040_1056_i 1040 1040_1056 2.08965e-09
r_1600_1616_e 1600 1616 836.944
r_1600_1616_i 1600_1616 1616 4256.89
c_1600_1616_i 1600 1600_1616 4.67522e-10
r_2160_2176_e 2160 2176 836.944
r_2160_2176_i 2160_2176 2176 4256.89
c_2160_2176_i 2160 2160_2176 4.67522e-10
r_2720_2736_e 2720 2736 836.944
r_2720_2736_i 2720_2736 2736 4256.89
c_2720_2736_i 2720 2720_2736 4.67522e-10
r_3280_3296_e 3280 3296 13758.3
r_3280_3296_i 3280_3296 3296 95645.6
c_3280_3296_i 3280 3280_3296 9.36084e-12
r_3840_3856_e 3840 3856 13758.3
r_3840_3856_i 3840_3856 3856 95645.6
c_3840_3856_i 3840 3840_3856 9.36084e-12
r_481_497_e 481 497 13376.4
r_481_497_i 481_497 497 93218.1
c_481_497_i 481 481_497 2.08965e-09
r_1041_1057_e 1041 1057 13376.4
r_1041_1057_i 1041_1057 1057 93218.1
c_1041_1057_i 1041 1041_1057 2.08965e-09
r_1601_1617_e 1601 1617 13376.4
r_1601_1617_i 1601_1617 1617 93218.1
c_1601_1617_i 1601 1601_1617 2.08965e-09
r_2161_2177_e 2161 2177 13376.4
r_2161_2177_i 2161_2177 2177 93218.1
c_2161_2177_i 2161 2161_2177 2.08965e-09
r_2721_2737_e 2721 2737 13376.4
r_2721_2737_i 2721_2737 2737 93218.1
c_2721_2737_i 2721 2721_2737 2.08965e-09
r_3281_3297_e 3281 3297 13376.4
r_3281_3297_i 3281_3297 3297 93218.1
c_3281_3297_i 3281 3281_3297 2.08965e-09
r_3841_3857_e 3841 3857 13376.4
r_3841_3857_i 3841_3857 3857 93218.1
c_3841_3857_i 3841 3841_3857 2.08965e-09
r_482_498_e 482 498 13376.4
r_482_498_i 482_498 498 93218.1
c_482_498_i 482 482_498 2.08965e-09
r_1042_1058_e 1042 1058 13376.4
r_1042_1058_i 1042_1058 1058 93218.1
c_1042_1058_i 1042 1042_1058 2.08965e-09
r_1602_1618_e 1602 1618 13376.4
r_1602_1618_i 1602_1618 1618 93218.1
c_1602_1618_i 1602 1602_1618 2.08965e-09
r_2162_2178_e 2162 2178 13376.4
r_2162_2178_i 2162_2178 2178 93218.1
c_2162_2178_i 2162 2162_2178 2.08965e-09
r_2722_2738_e 2722 2738 13376.4
r_2722_2738_i 2722_2738 2738 93218.1
c_2722_2738_i 2722 2722_2738 2.08965e-09
r_3282_3298_e 3282 3298 13376.4
r_3282_3298_i 3282_3298 3298 93218.1
c_3282_3298_i 3282 3282_3298 2.08965e-09
r_3842_3858_e 3842 3858 13376.4
r_3842_3858_i 3842_3858 3858 93218.1
c_3842_3858_i 3842 3842_3858 2.08965e-09
r_483_499_e 483 499 13376.4
r_483_499_i 483_499 499 93218.1
c_483_499_i 483 483_499 2.08965e-09
r_1043_1059_e 1043 1059 13376.4
r_1043_1059_i 1043_1059 1059 93218.1
c_1043_1059_i 1043 1043_1059 2.08965e-09
r_1603_1619_e 1603 1619 836.944
r_1603_1619_i 1603_1619 1619 4256.89
c_1603_1619_i 1603 1603_1619 4.67522e-10
r_2163_2179_e 2163 2179 836.944
r_2163_2179_i 2163_2179 2179 4256.89
c_2163_2179_i 2163 2163_2179 4.67522e-10
r_2723_2739_e 2723 2739 836.944
r_2723_2739_i 2723_2739 2739 4256.89
c_2723_2739_i 2723 2723_2739 4.67522e-10
r_3283_3299_e 3283 3299 836.944
r_3283_3299_i 3283_3299 3299 4256.89
c_3283_3299_i 3283 3283_3299 4.67522e-10
r_3843_3859_e 3843 3859 836.944
r_3843_3859_i 3843_3859 3859 4256.89
c_3843_3859_i 3843 3843_3859 4.67522e-10
r_484_500_e 484 500 13376.4
r_484_500_i 484_500 500 93218.1
c_484_500_i 484 484_500 2.08965e-09
r_1044_1060_e 1044 1060 13376.4
r_1044_1060_i 1044_1060 1060 93218.1
c_1044_1060_i 1044 1044_1060 2.08965e-09
r_1604_1620_e 1604 1620 836.944
r_1604_1620_i 1604_1620 1620 4256.89
c_1604_1620_i 1604 1604_1620 4.67522e-10
r_2164_2180_e 2164 2180 836.944
r_2164_2180_i 2164_2180 2180 4256.89
c_2164_2180_i 2164 2164_2180 4.67522e-10
r_2724_2740_e 2724 2740 836.944
r_2724_2740_i 2724_2740 2740 4256.89
c_2724_2740_i 2724 2724_2740 4.67522e-10
r_3284_3300_e 3284 3300 13758.3
r_3284_3300_i 3284_3300 3300 95645.6
c_3284_3300_i 3284 3284_3300 9.36084e-12
r_3844_3860_e 3844 3860 13758.3
r_3844_3860_i 3844_3860 3860 95645.6
c_3844_3860_i 3844 3844_3860 9.36084e-12
r_485_501_e 485 501 13376.4
r_485_501_i 485_501 501 93218.1
c_485_501_i 485 485_501 2.08965e-09
r_1045_1061_e 1045 1061 13376.4
r_1045_1061_i 1045_1061 1061 93218.1
c_1045_1061_i 1045 1045_1061 2.08965e-09
r_1605_1621_e 1605 1621 836.944
r_1605_1621_i 1605_1621 1621 4256.89
c_1605_1621_i 1605 1605_1621 4.67522e-10
r_2165_2181_e 2165 2181 836.944
r_2165_2181_i 2165_2181 2181 4256.89
c_2165_2181_i 2165 2165_2181 4.67522e-10
r_2725_2741_e 2725 2741 836.944
r_2725_2741_i 2725_2741 2741 4256.89
c_2725_2741_i 2725 2725_2741 4.67522e-10
r_3285_3301_e 3285 3301 13758.3
r_3285_3301_i 3285_3301 3301 95645.6
c_3285_3301_i 3285 3285_3301 9.36084e-12
r_3845_3861_e 3845 3861 13758.3
r_3845_3861_i 3845_3861 3861 95645.6
c_3845_3861_i 3845 3845_3861 9.36084e-12
r_486_502_e 486 502 13376.4
r_486_502_i 486_502 502 93218.1
c_486_502_i 486 486_502 2.08965e-09
r_1046_1062_e 1046 1062 13376.4
r_1046_1062_i 1046_1062 1062 93218.1
c_1046_1062_i 1046 1046_1062 2.08965e-09
r_1606_1622_e 1606 1622 836.944
r_1606_1622_i 1606_1622 1622 4256.89
c_1606_1622_i 1606 1606_1622 4.67522e-10
r_2166_2182_e 2166 2182 836.944
r_2166_2182_i 2166_2182 2182 4256.89
c_2166_2182_i 2166 2166_2182 4.67522e-10
r_2726_2742_e 2726 2742 836.944
r_2726_2742_i 2726_2742 2742 4256.89
c_2726_2742_i 2726 2726_2742 4.67522e-10
r_3286_3302_e 3286 3302 13758.3
r_3286_3302_i 3286_3302 3302 95645.6
c_3286_3302_i 3286 3286_3302 9.36084e-12
r_3846_3862_e 3846 3862 13758.3
r_3846_3862_i 3846_3862 3862 95645.6
c_3846_3862_i 3846 3846_3862 9.36084e-12
r_487_503_e 487 503 13376.4
r_487_503_i 487_503 503 93218.1
c_487_503_i 487 487_503 2.08965e-09
r_1047_1063_e 1047 1063 13376.4
r_1047_1063_i 1047_1063 1063 93218.1
c_1047_1063_i 1047 1047_1063 2.08965e-09
r_1607_1623_e 1607 1623 836.944
r_1607_1623_i 1607_1623 1623 4256.89
c_1607_1623_i 1607 1607_1623 4.67522e-10
r_2167_2183_e 2167 2183 836.944
r_2167_2183_i 2167_2183 2183 4256.89
c_2167_2183_i 2167 2167_2183 4.67522e-10
r_2727_2743_e 2727 2743 836.944
r_2727_2743_i 2727_2743 2743 4256.89
c_2727_2743_i 2727 2727_2743 4.67522e-10
r_3287_3303_e 3287 3303 13758.3
r_3287_3303_i 3287_3303 3303 95645.6
c_3287_3303_i 3287 3287_3303 9.36084e-12
r_3847_3863_e 3847 3863 13758.3
r_3847_3863_i 3847_3863 3863 95645.6
c_3847_3863_i 3847 3847_3863 9.36084e-12
r_488_504_e 488 504 13376.4
r_488_504_i 488_504 504 93218.1
c_488_504_i 488 488_504 2.08965e-09
r_1048_1064_e 1048 1064 13376.4
r_1048_1064_i 1048_1064 1064 93218.1
c_1048_1064_i 1048 1048_1064 2.08965e-09
r_1608_1624_e 1608 1624 836.944
r_1608_1624_i 1608_1624 1624 4256.89
c_1608_1624_i 1608 1608_1624 4.67522e-10
r_2168_2184_e 2168 2184 836.944
r_2168_2184_i 2168_2184 2184 4256.89
c_2168_2184_i 2168 2168_2184 4.67522e-10
r_2728_2744_e 2728 2744 836.944
r_2728_2744_i 2728_2744 2744 4256.89
c_2728_2744_i 2728 2728_2744 4.67522e-10
r_3288_3304_e 3288 3304 13758.3
r_3288_3304_i 3288_3304 3304 95645.6
c_3288_3304_i 3288 3288_3304 9.36084e-12
r_3848_3864_e 3848 3864 13758.3
r_3848_3864_i 3848_3864 3864 95645.6
c_3848_3864_i 3848 3848_3864 9.36084e-12
r_489_505_e 489 505 13376.4
r_489_505_i 489_505 505 93218.1
c_489_505_i 489 489_505 2.08965e-09
r_1049_1065_e 1049 1065 13376.4
r_1049_1065_i 1049_1065 1065 93218.1
c_1049_1065_i 1049 1049_1065 2.08965e-09
r_1609_1625_e 1609 1625 836.944
r_1609_1625_i 1609_1625 1625 4256.89
c_1609_1625_i 1609 1609_1625 4.67522e-10
r_2169_2185_e 2169 2185 836.944
r_2169_2185_i 2169_2185 2185 4256.89
c_2169_2185_i 2169 2169_2185 4.67522e-10
r_2729_2745_e 2729 2745 836.944
r_2729_2745_i 2729_2745 2745 4256.89
c_2729_2745_i 2729 2729_2745 4.67522e-10
r_3289_3305_e 3289 3305 13758.3
r_3289_3305_i 3289_3305 3305 95645.6
c_3289_3305_i 3289 3289_3305 9.36084e-12
r_3849_3865_e 3849 3865 13758.3
r_3849_3865_i 3849_3865 3865 95645.6
c_3849_3865_i 3849 3849_3865 9.36084e-12
r_490_506_e 490 506 13376.4
r_490_506_i 490_506 506 93218.1
c_490_506_i 490 490_506 2.08965e-09
r_1050_1066_e 1050 1066 13376.4
r_1050_1066_i 1050_1066 1066 93218.1
c_1050_1066_i 1050 1050_1066 2.08965e-09
r_1610_1626_e 1610 1626 836.944
r_1610_1626_i 1610_1626 1626 4256.89
c_1610_1626_i 1610 1610_1626 4.67522e-10
r_2170_2186_e 2170 2186 836.944
r_2170_2186_i 2170_2186 2186 4256.89
c_2170_2186_i 2170 2170_2186 4.67522e-10
r_2730_2746_e 2730 2746 836.944
r_2730_2746_i 2730_2746 2746 4256.89
c_2730_2746_i 2730 2730_2746 4.67522e-10
r_3290_3306_e 3290 3306 13758.3
r_3290_3306_i 3290_3306 3306 95645.6
c_3290_3306_i 3290 3290_3306 9.36084e-12
r_3850_3866_e 3850 3866 13758.3
r_3850_3866_i 3850_3866 3866 95645.6
c_3850_3866_i 3850 3850_3866 9.36084e-12
r_491_507_e 491 507 13376.4
r_491_507_i 491_507 507 93218.1
c_491_507_i 491 491_507 2.08965e-09
r_1051_1067_e 1051 1067 396.51
r_1051_1067_i 1051_1067 1067 1004.79
c_1051_1067_i 1051 1051_1067 1.65873e-10
r_1611_1627_e 1611 1627 396.51
r_1611_1627_i 1611_1627 1627 1004.79
c_1611_1627_i 1611 1611_1627 1.65873e-10
r_2171_2187_e 2171 2187 836.944
r_2171_2187_i 2171_2187 2187 4256.89
c_2171_2187_i 2171 2171_2187 4.67522e-10
r_2731_2747_e 2731 2747 836.944
r_2731_2747_i 2731_2747 2747 4256.89
c_2731_2747_i 2731 2731_2747 4.67522e-10
r_3291_3307_e 3291 3307 13758.3
r_3291_3307_i 3291_3307 3307 95645.6
c_3291_3307_i 3291 3291_3307 9.36084e-12
r_3851_3867_e 3851 3867 13758.3
r_3851_3867_i 3851_3867 3867 95645.6
c_3851_3867_i 3851 3851_3867 9.36084e-12
r_492_508_e 492 508 13376.4
r_492_508_i 492_508 508 93218.1
c_492_508_i 492 492_508 2.08965e-09
r_1052_1068_e 1052 1068 396.51
r_1052_1068_i 1052_1068 1068 1004.79
c_1052_1068_i 1052 1052_1068 1.65873e-10
r_1612_1628_e 1612 1628 396.51
r_1612_1628_i 1612_1628 1628 1004.79
c_1612_1628_i 1612 1612_1628 1.65873e-10
r_2172_2188_e 2172 2188 836.944
r_2172_2188_i 2172_2188 2188 4256.89
c_2172_2188_i 2172 2172_2188 4.67522e-10
r_2732_2748_e 2732 2748 836.944
r_2732_2748_i 2732_2748 2748 4256.89
c_2732_2748_i 2732 2732_2748 4.67522e-10
r_3292_3308_e 3292 3308 13758.3
r_3292_3308_i 3292_3308 3308 95645.6
c_3292_3308_i 3292 3292_3308 9.36084e-12
r_3852_3868_e 3852 3868 13758.3
r_3852_3868_i 3852_3868 3868 95645.6
c_3852_3868_i 3852 3852_3868 9.36084e-12
r_493_509_e 493 509 13376.4
r_493_509_i 493_509 509 93218.1
c_493_509_i 493 493_509 2.08965e-09
r_1053_1069_e 1053 1069 13376.4
r_1053_1069_i 1053_1069 1069 93218.1
c_1053_1069_i 1053 1053_1069 2.08965e-09
r_1613_1629_e 1613 1629 836.944
r_1613_1629_i 1613_1629 1629 4256.89
c_1613_1629_i 1613 1613_1629 4.67522e-10
r_2173_2189_e 2173 2189 836.944
r_2173_2189_i 2173_2189 2189 4256.89
c_2173_2189_i 2173 2173_2189 4.67522e-10
r_2733_2749_e 2733 2749 836.944
r_2733_2749_i 2733_2749 2749 4256.89
c_2733_2749_i 2733 2733_2749 4.67522e-10
r_3293_3309_e 3293 3309 13758.3
r_3293_3309_i 3293_3309 3309 95645.6
c_3293_3309_i 3293 3293_3309 9.36084e-12
r_3853_3869_e 3853 3869 13758.3
r_3853_3869_i 3853_3869 3869 95645.6
c_3853_3869_i 3853 3853_3869 9.36084e-12
r_494_510_e 494 510 13376.4
r_494_510_i 494_510 510 93218.1
c_494_510_i 494 494_510 2.08965e-09
r_1054_1070_e 1054 1070 13376.4
r_1054_1070_i 1054_1070 1070 93218.1
c_1054_1070_i 1054 1054_1070 2.08965e-09
r_1614_1630_e 1614 1630 836.944
r_1614_1630_i 1614_1630 1630 4256.89
c_1614_1630_i 1614 1614_1630 4.67522e-10
r_2174_2190_e 2174 2190 836.944
r_2174_2190_i 2174_2190 2190 4256.89
c_2174_2190_i 2174 2174_2190 4.67522e-10
r_2734_2750_e 2734 2750 836.944
r_2734_2750_i 2734_2750 2750 4256.89
c_2734_2750_i 2734 2734_2750 4.67522e-10
r_3294_3310_e 3294 3310 13758.3
r_3294_3310_i 3294_3310 3310 95645.6
c_3294_3310_i 3294 3294_3310 9.36084e-12
r_3854_3870_e 3854 3870 13758.3
r_3854_3870_i 3854_3870 3870 95645.6
c_3854_3870_i 3854 3854_3870 9.36084e-12
r_495_511_e 495 511 13376.4
r_495_511_i 495_511 511 93218.1
c_495_511_i 495 495_511 2.08965e-09
r_1055_1071_e 1055 1071 13376.4
r_1055_1071_i 1055_1071 1071 93218.1
c_1055_1071_i 1055 1055_1071 2.08965e-09
r_1615_1631_e 1615 1631 836.944
r_1615_1631_i 1615_1631 1631 4256.89
c_1615_1631_i 1615 1615_1631 4.67522e-10
r_2175_2191_e 2175 2191 836.944
r_2175_2191_i 2175_2191 2191 4256.89
c_2175_2191_i 2175 2175_2191 4.67522e-10
r_2735_2751_e 2735 2751 836.944
r_2735_2751_i 2735_2751 2751 4256.89
c_2735_2751_i 2735 2735_2751 4.67522e-10
r_3295_3311_e 3295 3311 13758.3
r_3295_3311_i 3295_3311 3311 95645.6
c_3295_3311_i 3295 3295_3311 9.36084e-12
r_3855_3871_e 3855 3871 13758.3
r_3855_3871_i 3855_3871 3871 95645.6
c_3855_3871_i 3855 3855_3871 9.36084e-12
r_496_512_e 496 512 13376.4
r_496_512_i 496_512 512 93218.1
c_496_512_i 496 496_512 2.08965e-09
r_1056_1072_e 1056 1072 13376.4
r_1056_1072_i 1056_1072 1072 93218.1
c_1056_1072_i 1056 1056_1072 2.08965e-09
r_1616_1632_e 1616 1632 836.944
r_1616_1632_i 1616_1632 1632 4256.89
c_1616_1632_i 1616 1616_1632 4.67522e-10
r_2176_2192_e 2176 2192 836.944
r_2176_2192_i 2176_2192 2192 4256.89
c_2176_2192_i 2176 2176_2192 4.67522e-10
r_2736_2752_e 2736 2752 836.944
r_2736_2752_i 2736_2752 2752 4256.89
c_2736_2752_i 2736 2736_2752 4.67522e-10
r_3296_3312_e 3296 3312 13758.3
r_3296_3312_i 3296_3312 3312 95645.6
c_3296_3312_i 3296 3296_3312 9.36084e-12
r_3856_3872_e 3856 3872 13758.3
r_3856_3872_i 3856_3872 3872 95645.6
c_3856_3872_i 3856 3856_3872 9.36084e-12
r_497_513_e 497 513 13376.4
r_497_513_i 497_513 513 93218.1
c_497_513_i 497 497_513 2.08965e-09
r_1057_1073_e 1057 1073 13376.4
r_1057_1073_i 1057_1073 1073 93218.1
c_1057_1073_i 1057 1057_1073 2.08965e-09
r_1617_1633_e 1617 1633 13376.4
r_1617_1633_i 1617_1633 1633 93218.1
c_1617_1633_i 1617 1617_1633 2.08965e-09
r_2177_2193_e 2177 2193 13376.4
r_2177_2193_i 2177_2193 2193 93218.1
c_2177_2193_i 2177 2177_2193 2.08965e-09
r_2737_2753_e 2737 2753 13376.4
r_2737_2753_i 2737_2753 2753 93218.1
c_2737_2753_i 2737 2737_2753 2.08965e-09
r_3297_3313_e 3297 3313 13376.4
r_3297_3313_i 3297_3313 3313 93218.1
c_3297_3313_i 3297 3297_3313 2.08965e-09
r_3857_3873_e 3857 3873 13376.4
r_3857_3873_i 3857_3873 3873 93218.1
c_3857_3873_i 3857 3857_3873 2.08965e-09
r_498_514_e 498 514 13376.4
r_498_514_i 498_514 514 93218.1
c_498_514_i 498 498_514 2.08965e-09
r_1058_1074_e 1058 1074 13376.4
r_1058_1074_i 1058_1074 1074 93218.1
c_1058_1074_i 1058 1058_1074 2.08965e-09
r_1618_1634_e 1618 1634 13376.4
r_1618_1634_i 1618_1634 1634 93218.1
c_1618_1634_i 1618 1618_1634 2.08965e-09
r_2178_2194_e 2178 2194 13376.4
r_2178_2194_i 2178_2194 2194 93218.1
c_2178_2194_i 2178 2178_2194 2.08965e-09
r_2738_2754_e 2738 2754 13376.4
r_2738_2754_i 2738_2754 2754 93218.1
c_2738_2754_i 2738 2738_2754 2.08965e-09
r_3298_3314_e 3298 3314 13376.4
r_3298_3314_i 3298_3314 3314 93218.1
c_3298_3314_i 3298 3298_3314 2.08965e-09
r_3858_3874_e 3858 3874 13376.4
r_3858_3874_i 3858_3874 3874 93218.1
c_3858_3874_i 3858 3858_3874 2.08965e-09
r_499_515_e 499 515 13376.4
r_499_515_i 499_515 515 93218.1
c_499_515_i 499 499_515 2.08965e-09
r_1059_1075_e 1059 1075 13376.4
r_1059_1075_i 1059_1075 1075 93218.1
c_1059_1075_i 1059 1059_1075 2.08965e-09
r_1619_1635_e 1619 1635 836.944
r_1619_1635_i 1619_1635 1635 4256.89
c_1619_1635_i 1619 1619_1635 4.67522e-10
r_2179_2195_e 2179 2195 836.944
r_2179_2195_i 2179_2195 2195 4256.89
c_2179_2195_i 2179 2179_2195 4.67522e-10
r_2739_2755_e 2739 2755 836.944
r_2739_2755_i 2739_2755 2755 4256.89
c_2739_2755_i 2739 2739_2755 4.67522e-10
r_3299_3315_e 3299 3315 836.944
r_3299_3315_i 3299_3315 3315 4256.89
c_3299_3315_i 3299 3299_3315 4.67522e-10
r_3859_3875_e 3859 3875 836.944
r_3859_3875_i 3859_3875 3875 4256.89
c_3859_3875_i 3859 3859_3875 4.67522e-10
r_500_516_e 500 516 13376.4
r_500_516_i 500_516 516 93218.1
c_500_516_i 500 500_516 2.08965e-09
r_1060_1076_e 1060 1076 13376.4
r_1060_1076_i 1060_1076 1076 93218.1
c_1060_1076_i 1060 1060_1076 2.08965e-09
r_1620_1636_e 1620 1636 836.944
r_1620_1636_i 1620_1636 1636 4256.89
c_1620_1636_i 1620 1620_1636 4.67522e-10
r_2180_2196_e 2180 2196 836.944
r_2180_2196_i 2180_2196 2196 4256.89
c_2180_2196_i 2180 2180_2196 4.67522e-10
r_2740_2756_e 2740 2756 836.944
r_2740_2756_i 2740_2756 2756 4256.89
c_2740_2756_i 2740 2740_2756 4.67522e-10
r_3300_3316_e 3300 3316 13758.3
r_3300_3316_i 3300_3316 3316 95645.6
c_3300_3316_i 3300 3300_3316 9.36084e-12
r_3860_3876_e 3860 3876 13758.3
r_3860_3876_i 3860_3876 3876 95645.6
c_3860_3876_i 3860 3860_3876 9.36084e-12
r_501_517_e 501 517 13376.4
r_501_517_i 501_517 517 93218.1
c_501_517_i 501 501_517 2.08965e-09
r_1061_1077_e 1061 1077 13376.4
r_1061_1077_i 1061_1077 1077 93218.1
c_1061_1077_i 1061 1061_1077 2.08965e-09
r_1621_1637_e 1621 1637 836.944
r_1621_1637_i 1621_1637 1637 4256.89
c_1621_1637_i 1621 1621_1637 4.67522e-10
r_2181_2197_e 2181 2197 836.944
r_2181_2197_i 2181_2197 2197 4256.89
c_2181_2197_i 2181 2181_2197 4.67522e-10
r_2741_2757_e 2741 2757 836.944
r_2741_2757_i 2741_2757 2757 4256.89
c_2741_2757_i 2741 2741_2757 4.67522e-10
r_3301_3317_e 3301 3317 13758.3
r_3301_3317_i 3301_3317 3317 95645.6
c_3301_3317_i 3301 3301_3317 9.36084e-12
r_3861_3877_e 3861 3877 13758.3
r_3861_3877_i 3861_3877 3877 95645.6
c_3861_3877_i 3861 3861_3877 9.36084e-12
r_502_518_e 502 518 13376.4
r_502_518_i 502_518 518 93218.1
c_502_518_i 502 502_518 2.08965e-09
r_1062_1078_e 1062 1078 13376.4
r_1062_1078_i 1062_1078 1078 93218.1
c_1062_1078_i 1062 1062_1078 2.08965e-09
r_1622_1638_e 1622 1638 836.944
r_1622_1638_i 1622_1638 1638 4256.89
c_1622_1638_i 1622 1622_1638 4.67522e-10
r_2182_2198_e 2182 2198 836.944
r_2182_2198_i 2182_2198 2198 4256.89
c_2182_2198_i 2182 2182_2198 4.67522e-10
r_2742_2758_e 2742 2758 836.944
r_2742_2758_i 2742_2758 2758 4256.89
c_2742_2758_i 2742 2742_2758 4.67522e-10
r_3302_3318_e 3302 3318 13758.3
r_3302_3318_i 3302_3318 3318 95645.6
c_3302_3318_i 3302 3302_3318 9.36084e-12
r_3862_3878_e 3862 3878 13758.3
r_3862_3878_i 3862_3878 3878 95645.6
c_3862_3878_i 3862 3862_3878 9.36084e-12
r_503_519_e 503 519 13376.4
r_503_519_i 503_519 519 93218.1
c_503_519_i 503 503_519 2.08965e-09
r_1063_1079_e 1063 1079 13376.4
r_1063_1079_i 1063_1079 1079 93218.1
c_1063_1079_i 1063 1063_1079 2.08965e-09
r_1623_1639_e 1623 1639 836.944
r_1623_1639_i 1623_1639 1639 4256.89
c_1623_1639_i 1623 1623_1639 4.67522e-10
r_2183_2199_e 2183 2199 836.944
r_2183_2199_i 2183_2199 2199 4256.89
c_2183_2199_i 2183 2183_2199 4.67522e-10
r_2743_2759_e 2743 2759 836.944
r_2743_2759_i 2743_2759 2759 4256.89
c_2743_2759_i 2743 2743_2759 4.67522e-10
r_3303_3319_e 3303 3319 13758.3
r_3303_3319_i 3303_3319 3319 95645.6
c_3303_3319_i 3303 3303_3319 9.36084e-12
r_3863_3879_e 3863 3879 13758.3
r_3863_3879_i 3863_3879 3879 95645.6
c_3863_3879_i 3863 3863_3879 9.36084e-12
r_504_520_e 504 520 13376.4
r_504_520_i 504_520 520 93218.1
c_504_520_i 504 504_520 2.08965e-09
r_1064_1080_e 1064 1080 13376.4
r_1064_1080_i 1064_1080 1080 93218.1
c_1064_1080_i 1064 1064_1080 2.08965e-09
r_1624_1640_e 1624 1640 836.944
r_1624_1640_i 1624_1640 1640 4256.89
c_1624_1640_i 1624 1624_1640 4.67522e-10
r_2184_2200_e 2184 2200 836.944
r_2184_2200_i 2184_2200 2200 4256.89
c_2184_2200_i 2184 2184_2200 4.67522e-10
r_2744_2760_e 2744 2760 836.944
r_2744_2760_i 2744_2760 2760 4256.89
c_2744_2760_i 2744 2744_2760 4.67522e-10
r_3304_3320_e 3304 3320 13758.3
r_3304_3320_i 3304_3320 3320 95645.6
c_3304_3320_i 3304 3304_3320 9.36084e-12
r_3864_3880_e 3864 3880 13758.3
r_3864_3880_i 3864_3880 3880 95645.6
c_3864_3880_i 3864 3864_3880 9.36084e-12
r_505_521_e 505 521 13376.4
r_505_521_i 505_521 521 93218.1
c_505_521_i 505 505_521 2.08965e-09
r_1065_1081_e 1065 1081 13376.4
r_1065_1081_i 1065_1081 1081 93218.1
c_1065_1081_i 1065 1065_1081 2.08965e-09
r_1625_1641_e 1625 1641 836.944
r_1625_1641_i 1625_1641 1641 4256.89
c_1625_1641_i 1625 1625_1641 4.67522e-10
r_2185_2201_e 2185 2201 836.944
r_2185_2201_i 2185_2201 2201 4256.89
c_2185_2201_i 2185 2185_2201 4.67522e-10
r_2745_2761_e 2745 2761 836.944
r_2745_2761_i 2745_2761 2761 4256.89
c_2745_2761_i 2745 2745_2761 4.67522e-10
r_3305_3321_e 3305 3321 13758.3
r_3305_3321_i 3305_3321 3321 95645.6
c_3305_3321_i 3305 3305_3321 9.36084e-12
r_3865_3881_e 3865 3881 13758.3
r_3865_3881_i 3865_3881 3881 95645.6
c_3865_3881_i 3865 3865_3881 9.36084e-12
r_506_522_e 506 522 13376.4
r_506_522_i 506_522 522 93218.1
c_506_522_i 506 506_522 2.08965e-09
r_1066_1082_e 1066 1082 13376.4
r_1066_1082_i 1066_1082 1082 93218.1
c_1066_1082_i 1066 1066_1082 2.08965e-09
r_1626_1642_e 1626 1642 836.944
r_1626_1642_i 1626_1642 1642 4256.89
c_1626_1642_i 1626 1626_1642 4.67522e-10
r_2186_2202_e 2186 2202 836.944
r_2186_2202_i 2186_2202 2202 4256.89
c_2186_2202_i 2186 2186_2202 4.67522e-10
r_2746_2762_e 2746 2762 836.944
r_2746_2762_i 2746_2762 2762 4256.89
c_2746_2762_i 2746 2746_2762 4.67522e-10
r_3306_3322_e 3306 3322 13758.3
r_3306_3322_i 3306_3322 3322 95645.6
c_3306_3322_i 3306 3306_3322 9.36084e-12
r_3866_3882_e 3866 3882 13758.3
r_3866_3882_i 3866_3882 3882 95645.6
c_3866_3882_i 3866 3866_3882 9.36084e-12
r_507_523_e 507 523 13376.4
r_507_523_i 507_523 523 93218.1
c_507_523_i 507 507_523 2.08965e-09
r_1067_1083_e 1067 1083 396.501
r_1067_1083_i 1067_1083 1083 1004.77
c_1067_1083_i 1067 1067_1083 1.65876e-10
r_1627_1643_e 1627 1643 396.501
r_1627_1643_i 1627_1643 1643 1004.77
c_1627_1643_i 1627 1627_1643 1.65876e-10
r_2187_2203_e 2187 2203 836.944
r_2187_2203_i 2187_2203 2203 4256.89
c_2187_2203_i 2187 2187_2203 4.67522e-10
r_2747_2763_e 2747 2763 836.944
r_2747_2763_i 2747_2763 2763 4256.89
c_2747_2763_i 2747 2747_2763 4.67522e-10
r_3307_3323_e 3307 3323 13758.3
r_3307_3323_i 3307_3323 3323 95645.6
c_3307_3323_i 3307 3307_3323 9.36084e-12
r_3867_3883_e 3867 3883 13758.3
r_3867_3883_i 3867_3883 3883 95645.6
c_3867_3883_i 3867 3867_3883 9.36084e-12
r_508_524_e 508 524 13376.4
r_508_524_i 508_524 524 93218.1
c_508_524_i 508 508_524 2.08965e-09
r_1068_1084_e 1068 1084 396.501
r_1068_1084_i 1068_1084 1084 1004.77
c_1068_1084_i 1068 1068_1084 1.65876e-10
r_1628_1644_e 1628 1644 396.501
r_1628_1644_i 1628_1644 1644 1004.77
c_1628_1644_i 1628 1628_1644 1.65876e-10
r_2188_2204_e 2188 2204 836.944
r_2188_2204_i 2188_2204 2204 4256.89
c_2188_2204_i 2188 2188_2204 4.67522e-10
r_2748_2764_e 2748 2764 836.944
r_2748_2764_i 2748_2764 2764 4256.89
c_2748_2764_i 2748 2748_2764 4.67522e-10
r_3308_3324_e 3308 3324 13758.3
r_3308_3324_i 3308_3324 3324 95645.6
c_3308_3324_i 3308 3308_3324 9.36084e-12
r_3868_3884_e 3868 3884 13758.3
r_3868_3884_i 3868_3884 3884 95645.6
c_3868_3884_i 3868 3868_3884 9.36084e-12
r_509_525_e 509 525 13376.4
r_509_525_i 509_525 525 93218.1
c_509_525_i 509 509_525 2.08965e-09
r_1069_1085_e 1069 1085 13376.4
r_1069_1085_i 1069_1085 1085 93218.1
c_1069_1085_i 1069 1069_1085 2.08965e-09
r_1629_1645_e 1629 1645 836.944
r_1629_1645_i 1629_1645 1645 4256.89
c_1629_1645_i 1629 1629_1645 4.67522e-10
r_2189_2205_e 2189 2205 836.944
r_2189_2205_i 2189_2205 2205 4256.89
c_2189_2205_i 2189 2189_2205 4.67522e-10
r_2749_2765_e 2749 2765 836.944
r_2749_2765_i 2749_2765 2765 4256.89
c_2749_2765_i 2749 2749_2765 4.67522e-10
r_3309_3325_e 3309 3325 13758.3
r_3309_3325_i 3309_3325 3325 95645.6
c_3309_3325_i 3309 3309_3325 9.36084e-12
r_3869_3885_e 3869 3885 13758.3
r_3869_3885_i 3869_3885 3885 95645.6
c_3869_3885_i 3869 3869_3885 9.36084e-12
r_510_526_e 510 526 13376.4
r_510_526_i 510_526 526 93218.1
c_510_526_i 510 510_526 2.08965e-09
r_1070_1086_e 1070 1086 13376.4
r_1070_1086_i 1070_1086 1086 93218.1
c_1070_1086_i 1070 1070_1086 2.08965e-09
r_1630_1646_e 1630 1646 836.944
r_1630_1646_i 1630_1646 1646 4256.89
c_1630_1646_i 1630 1630_1646 4.67522e-10
r_2190_2206_e 2190 2206 836.944
r_2190_2206_i 2190_2206 2206 4256.89
c_2190_2206_i 2190 2190_2206 4.67522e-10
r_2750_2766_e 2750 2766 836.944
r_2750_2766_i 2750_2766 2766 4256.89
c_2750_2766_i 2750 2750_2766 4.67522e-10
r_3310_3326_e 3310 3326 13758.3
r_3310_3326_i 3310_3326 3326 95645.6
c_3310_3326_i 3310 3310_3326 9.36084e-12
r_3870_3886_e 3870 3886 13758.3
r_3870_3886_i 3870_3886 3886 95645.6
c_3870_3886_i 3870 3870_3886 9.36084e-12
r_511_527_e 511 527 13376.4
r_511_527_i 511_527 527 93218.1
c_511_527_i 511 511_527 2.08965e-09
r_1071_1087_e 1071 1087 13376.4
r_1071_1087_i 1071_1087 1087 93218.1
c_1071_1087_i 1071 1071_1087 2.08965e-09
r_1631_1647_e 1631 1647 836.944
r_1631_1647_i 1631_1647 1647 4256.89
c_1631_1647_i 1631 1631_1647 4.67522e-10
r_2191_2207_e 2191 2207 836.944
r_2191_2207_i 2191_2207 2207 4256.89
c_2191_2207_i 2191 2191_2207 4.67522e-10
r_2751_2767_e 2751 2767 836.944
r_2751_2767_i 2751_2767 2767 4256.89
c_2751_2767_i 2751 2751_2767 4.67522e-10
r_3311_3327_e 3311 3327 13758.3
r_3311_3327_i 3311_3327 3327 95645.6
c_3311_3327_i 3311 3311_3327 9.36084e-12
r_3871_3887_e 3871 3887 13758.3
r_3871_3887_i 3871_3887 3887 95645.6
c_3871_3887_i 3871 3871_3887 9.36084e-12
r_512_528_e 512 528 13376.4
r_512_528_i 512_528 528 93218.1
c_512_528_i 512 512_528 2.08965e-09
r_1072_1088_e 1072 1088 13376.4
r_1072_1088_i 1072_1088 1088 93218.1
c_1072_1088_i 1072 1072_1088 2.08965e-09
r_1632_1648_e 1632 1648 836.944
r_1632_1648_i 1632_1648 1648 4256.89
c_1632_1648_i 1632 1632_1648 4.67522e-10
r_2192_2208_e 2192 2208 836.944
r_2192_2208_i 2192_2208 2208 4256.89
c_2192_2208_i 2192 2192_2208 4.67522e-10
r_2752_2768_e 2752 2768 836.944
r_2752_2768_i 2752_2768 2768 4256.89
c_2752_2768_i 2752 2752_2768 4.67522e-10
r_3312_3328_e 3312 3328 13758.3
r_3312_3328_i 3312_3328 3328 95645.6
c_3312_3328_i 3312 3312_3328 9.36084e-12
r_3872_3888_e 3872 3888 13758.3
r_3872_3888_i 3872_3888 3888 95645.6
c_3872_3888_i 3872 3872_3888 9.36084e-12
r_513_529_e 513 529 13376.4
r_513_529_i 513_529 529 93218.1
c_513_529_i 513 513_529 2.08965e-09
r_1073_1089_e 1073 1089 13376.4
r_1073_1089_i 1073_1089 1089 93218.1
c_1073_1089_i 1073 1073_1089 2.08965e-09
r_1633_1649_e 1633 1649 13376.4
r_1633_1649_i 1633_1649 1649 93218.1
c_1633_1649_i 1633 1633_1649 2.08965e-09
r_2193_2209_e 2193 2209 13376.4
r_2193_2209_i 2193_2209 2209 93218.1
c_2193_2209_i 2193 2193_2209 2.08965e-09
r_2753_2769_e 2753 2769 13376.4
r_2753_2769_i 2753_2769 2769 93218.1
c_2753_2769_i 2753 2753_2769 2.08965e-09
r_3313_3329_e 3313 3329 13376.4
r_3313_3329_i 3313_3329 3329 93218.1
c_3313_3329_i 3313 3313_3329 2.08965e-09
r_3873_3889_e 3873 3889 13376.4
r_3873_3889_i 3873_3889 3889 93218.1
c_3873_3889_i 3873 3873_3889 2.08965e-09
r_514_530_e 514 530 13376.4
r_514_530_i 514_530 530 93218.1
c_514_530_i 514 514_530 2.08965e-09
r_1074_1090_e 1074 1090 13376.4
r_1074_1090_i 1074_1090 1090 93218.1
c_1074_1090_i 1074 1074_1090 2.08965e-09
r_1634_1650_e 1634 1650 13376.4
r_1634_1650_i 1634_1650 1650 93218.1
c_1634_1650_i 1634 1634_1650 2.08965e-09
r_2194_2210_e 2194 2210 13376.4
r_2194_2210_i 2194_2210 2210 93218.1
c_2194_2210_i 2194 2194_2210 2.08965e-09
r_2754_2770_e 2754 2770 13376.4
r_2754_2770_i 2754_2770 2770 93218.1
c_2754_2770_i 2754 2754_2770 2.08965e-09
r_3314_3330_e 3314 3330 13376.4
r_3314_3330_i 3314_3330 3330 93218.1
c_3314_3330_i 3314 3314_3330 2.08965e-09
r_3874_3890_e 3874 3890 13376.4
r_3874_3890_i 3874_3890 3890 93218.1
c_3874_3890_i 3874 3874_3890 2.08965e-09
r_515_531_e 515 531 13376.4
r_515_531_i 515_531 531 93218.1
c_515_531_i 515 515_531 2.08965e-09
r_1075_1091_e 1075 1091 13376.4
r_1075_1091_i 1075_1091 1091 93218.1
c_1075_1091_i 1075 1075_1091 2.08965e-09
r_1635_1651_e 1635 1651 836.944
r_1635_1651_i 1635_1651 1651 4256.89
c_1635_1651_i 1635 1635_1651 4.67522e-10
r_2195_2211_e 2195 2211 836.944
r_2195_2211_i 2195_2211 2211 4256.89
c_2195_2211_i 2195 2195_2211 4.67522e-10
r_2755_2771_e 2755 2771 836.944
r_2755_2771_i 2755_2771 2771 4256.89
c_2755_2771_i 2755 2755_2771 4.67522e-10
r_3315_3331_e 3315 3331 836.944
r_3315_3331_i 3315_3331 3331 4256.89
c_3315_3331_i 3315 3315_3331 4.67522e-10
r_3875_3891_e 3875 3891 836.944
r_3875_3891_i 3875_3891 3891 4256.89
c_3875_3891_i 3875 3875_3891 4.67522e-10
r_516_532_e 516 532 13376.4
r_516_532_i 516_532 532 93218.1
c_516_532_i 516 516_532 2.08965e-09
r_1076_1092_e 1076 1092 13376.4
r_1076_1092_i 1076_1092 1092 93218.1
c_1076_1092_i 1076 1076_1092 2.08965e-09
r_1636_1652_e 1636 1652 836.944
r_1636_1652_i 1636_1652 1652 4256.89
c_1636_1652_i 1636 1636_1652 4.67522e-10
r_2196_2212_e 2196 2212 836.944
r_2196_2212_i 2196_2212 2212 4256.89
c_2196_2212_i 2196 2196_2212 4.67522e-10
r_2756_2772_e 2756 2772 836.944
r_2756_2772_i 2756_2772 2772 4256.89
c_2756_2772_i 2756 2756_2772 4.67522e-10
r_3316_3332_e 3316 3332 13758.3
r_3316_3332_i 3316_3332 3332 95645.6
c_3316_3332_i 3316 3316_3332 9.36084e-12
r_3876_3892_e 3876 3892 13758.3
r_3876_3892_i 3876_3892 3892 95645.6
c_3876_3892_i 3876 3876_3892 9.36084e-12
r_517_533_e 517 533 13376.4
r_517_533_i 517_533 533 93218.1
c_517_533_i 517 517_533 2.08965e-09
r_1077_1093_e 1077 1093 13376.4
r_1077_1093_i 1077_1093 1093 93218.1
c_1077_1093_i 1077 1077_1093 2.08965e-09
r_1637_1653_e 1637 1653 836.944
r_1637_1653_i 1637_1653 1653 4256.89
c_1637_1653_i 1637 1637_1653 4.67522e-10
r_2197_2213_e 2197 2213 836.944
r_2197_2213_i 2197_2213 2213 4256.89
c_2197_2213_i 2197 2197_2213 4.67522e-10
r_2757_2773_e 2757 2773 836.944
r_2757_2773_i 2757_2773 2773 4256.89
c_2757_2773_i 2757 2757_2773 4.67522e-10
r_3317_3333_e 3317 3333 13758.3
r_3317_3333_i 3317_3333 3333 95645.6
c_3317_3333_i 3317 3317_3333 9.36084e-12
r_3877_3893_e 3877 3893 13758.3
r_3877_3893_i 3877_3893 3893 95645.6
c_3877_3893_i 3877 3877_3893 9.36084e-12
r_518_534_e 518 534 13376.4
r_518_534_i 518_534 534 93218.1
c_518_534_i 518 518_534 2.08965e-09
r_1078_1094_e 1078 1094 13376.4
r_1078_1094_i 1078_1094 1094 93218.1
c_1078_1094_i 1078 1078_1094 2.08965e-09
r_1638_1654_e 1638 1654 836.944
r_1638_1654_i 1638_1654 1654 4256.89
c_1638_1654_i 1638 1638_1654 4.67522e-10
r_2198_2214_e 2198 2214 836.944
r_2198_2214_i 2198_2214 2214 4256.89
c_2198_2214_i 2198 2198_2214 4.67522e-10
r_2758_2774_e 2758 2774 836.944
r_2758_2774_i 2758_2774 2774 4256.89
c_2758_2774_i 2758 2758_2774 4.67522e-10
r_3318_3334_e 3318 3334 13758.3
r_3318_3334_i 3318_3334 3334 95645.6
c_3318_3334_i 3318 3318_3334 9.36084e-12
r_3878_3894_e 3878 3894 13758.3
r_3878_3894_i 3878_3894 3894 95645.6
c_3878_3894_i 3878 3878_3894 9.36084e-12
r_519_535_e 519 535 13376.4
r_519_535_i 519_535 535 93218.1
c_519_535_i 519 519_535 2.08965e-09
r_1079_1095_e 1079 1095 13376.4
r_1079_1095_i 1079_1095 1095 93218.1
c_1079_1095_i 1079 1079_1095 2.08965e-09
r_1639_1655_e 1639 1655 836.944
r_1639_1655_i 1639_1655 1655 4256.89
c_1639_1655_i 1639 1639_1655 4.67522e-10
r_2199_2215_e 2199 2215 836.944
r_2199_2215_i 2199_2215 2215 4256.89
c_2199_2215_i 2199 2199_2215 4.67522e-10
r_2759_2775_e 2759 2775 836.944
r_2759_2775_i 2759_2775 2775 4256.89
c_2759_2775_i 2759 2759_2775 4.67522e-10
r_3319_3335_e 3319 3335 13758.3
r_3319_3335_i 3319_3335 3335 95645.6
c_3319_3335_i 3319 3319_3335 9.36084e-12
r_3879_3895_e 3879 3895 13758.3
r_3879_3895_i 3879_3895 3895 95645.6
c_3879_3895_i 3879 3879_3895 9.36084e-12
r_520_536_e 520 536 13376.4
r_520_536_i 520_536 536 93218.1
c_520_536_i 520 520_536 2.08965e-09
r_1080_1096_e 1080 1096 13376.4
r_1080_1096_i 1080_1096 1096 93218.1
c_1080_1096_i 1080 1080_1096 2.08965e-09
r_1640_1656_e 1640 1656 836.944
r_1640_1656_i 1640_1656 1656 4256.89
c_1640_1656_i 1640 1640_1656 4.67522e-10
r_2200_2216_e 2200 2216 836.944
r_2200_2216_i 2200_2216 2216 4256.89
c_2200_2216_i 2200 2200_2216 4.67522e-10
r_2760_2776_e 2760 2776 836.944
r_2760_2776_i 2760_2776 2776 4256.89
c_2760_2776_i 2760 2760_2776 4.67522e-10
r_3320_3336_e 3320 3336 13758.3
r_3320_3336_i 3320_3336 3336 95645.6
c_3320_3336_i 3320 3320_3336 9.36084e-12
r_3880_3896_e 3880 3896 13758.3
r_3880_3896_i 3880_3896 3896 95645.6
c_3880_3896_i 3880 3880_3896 9.36084e-12
r_521_537_e 521 537 13376.4
r_521_537_i 521_537 537 93218.1
c_521_537_i 521 521_537 2.08965e-09
r_1081_1097_e 1081 1097 13376.4
r_1081_1097_i 1081_1097 1097 93218.1
c_1081_1097_i 1081 1081_1097 2.08965e-09
r_1641_1657_e 1641 1657 836.944
r_1641_1657_i 1641_1657 1657 4256.89
c_1641_1657_i 1641 1641_1657 4.67522e-10
r_2201_2217_e 2201 2217 836.944
r_2201_2217_i 2201_2217 2217 4256.89
c_2201_2217_i 2201 2201_2217 4.67522e-10
r_2761_2777_e 2761 2777 836.944
r_2761_2777_i 2761_2777 2777 4256.89
c_2761_2777_i 2761 2761_2777 4.67522e-10
r_3321_3337_e 3321 3337 13758.3
r_3321_3337_i 3321_3337 3337 95645.6
c_3321_3337_i 3321 3321_3337 9.36084e-12
r_3881_3897_e 3881 3897 13758.3
r_3881_3897_i 3881_3897 3897 95645.6
c_3881_3897_i 3881 3881_3897 9.36084e-12
r_522_538_e 522 538 13376.4
r_522_538_i 522_538 538 93218.1
c_522_538_i 522 522_538 2.08965e-09
r_1082_1098_e 1082 1098 13376.4
r_1082_1098_i 1082_1098 1098 93218.1
c_1082_1098_i 1082 1082_1098 2.08965e-09
r_1642_1658_e 1642 1658 836.944
r_1642_1658_i 1642_1658 1658 4256.89
c_1642_1658_i 1642 1642_1658 4.67522e-10
r_2202_2218_e 2202 2218 836.944
r_2202_2218_i 2202_2218 2218 4256.89
c_2202_2218_i 2202 2202_2218 4.67522e-10
r_2762_2778_e 2762 2778 836.944
r_2762_2778_i 2762_2778 2778 4256.89
c_2762_2778_i 2762 2762_2778 4.67522e-10
r_3322_3338_e 3322 3338 13758.3
r_3322_3338_i 3322_3338 3338 95645.6
c_3322_3338_i 3322 3322_3338 9.36084e-12
r_3882_3898_e 3882 3898 13758.3
r_3882_3898_i 3882_3898 3898 95645.6
c_3882_3898_i 3882 3882_3898 9.36084e-12
r_523_539_e 523 539 13376.4
r_523_539_i 523_539 539 93218.1
c_523_539_i 523 523_539 2.08965e-09
r_1083_1099_e 1083 1099 396.493
r_1083_1099_i 1083_1099 1099 1004.75
c_1083_1099_i 1083 1083_1099 1.6588e-10
r_1643_1659_e 1643 1659 396.493
r_1643_1659_i 1643_1659 1659 1004.75
c_1643_1659_i 1643 1643_1659 1.6588e-10
r_2203_2219_e 2203 2219 836.944
r_2203_2219_i 2203_2219 2219 4256.89
c_2203_2219_i 2203 2203_2219 4.67522e-10
r_2763_2779_e 2763 2779 836.944
r_2763_2779_i 2763_2779 2779 4256.89
c_2763_2779_i 2763 2763_2779 4.67522e-10
r_3323_3339_e 3323 3339 13758.3
r_3323_3339_i 3323_3339 3339 95645.6
c_3323_3339_i 3323 3323_3339 9.36084e-12
r_3883_3899_e 3883 3899 13758.3
r_3883_3899_i 3883_3899 3899 95645.6
c_3883_3899_i 3883 3883_3899 9.36084e-12
r_524_540_e 524 540 13376.4
r_524_540_i 524_540 540 93218.1
c_524_540_i 524 524_540 2.08965e-09
r_1084_1100_e 1084 1100 396.493
r_1084_1100_i 1084_1100 1100 1004.75
c_1084_1100_i 1084 1084_1100 1.6588e-10
r_1644_1660_e 1644 1660 396.493
r_1644_1660_i 1644_1660 1660 1004.75
c_1644_1660_i 1644 1644_1660 1.6588e-10
r_2204_2220_e 2204 2220 836.944
r_2204_2220_i 2204_2220 2220 4256.89
c_2204_2220_i 2204 2204_2220 4.67522e-10
r_2764_2780_e 2764 2780 836.944
r_2764_2780_i 2764_2780 2780 4256.89
c_2764_2780_i 2764 2764_2780 4.67522e-10
r_3324_3340_e 3324 3340 13758.3
r_3324_3340_i 3324_3340 3340 95645.6
c_3324_3340_i 3324 3324_3340 9.36084e-12
r_3884_3900_e 3884 3900 13758.3
r_3884_3900_i 3884_3900 3900 95645.6
c_3884_3900_i 3884 3884_3900 9.36084e-12
r_525_541_e 525 541 13376.4
r_525_541_i 525_541 541 93218.1
c_525_541_i 525 525_541 2.08965e-09
r_1085_1101_e 1085 1101 13376.4
r_1085_1101_i 1085_1101 1101 93218.1
c_1085_1101_i 1085 1085_1101 2.08965e-09
r_1645_1661_e 1645 1661 836.944
r_1645_1661_i 1645_1661 1661 4256.89
c_1645_1661_i 1645 1645_1661 4.67522e-10
r_2205_2221_e 2205 2221 836.944
r_2205_2221_i 2205_2221 2221 4256.89
c_2205_2221_i 2205 2205_2221 4.67522e-10
r_2765_2781_e 2765 2781 836.944
r_2765_2781_i 2765_2781 2781 4256.89
c_2765_2781_i 2765 2765_2781 4.67522e-10
r_3325_3341_e 3325 3341 13758.3
r_3325_3341_i 3325_3341 3341 95645.6
c_3325_3341_i 3325 3325_3341 9.36084e-12
r_3885_3901_e 3885 3901 13758.3
r_3885_3901_i 3885_3901 3901 95645.6
c_3885_3901_i 3885 3885_3901 9.36084e-12
r_526_542_e 526 542 13376.4
r_526_542_i 526_542 542 93218.1
c_526_542_i 526 526_542 2.08965e-09
r_1086_1102_e 1086 1102 13376.4
r_1086_1102_i 1086_1102 1102 93218.1
c_1086_1102_i 1086 1086_1102 2.08965e-09
r_1646_1662_e 1646 1662 836.944
r_1646_1662_i 1646_1662 1662 4256.89
c_1646_1662_i 1646 1646_1662 4.67522e-10
r_2206_2222_e 2206 2222 836.944
r_2206_2222_i 2206_2222 2222 4256.89
c_2206_2222_i 2206 2206_2222 4.67522e-10
r_2766_2782_e 2766 2782 836.944
r_2766_2782_i 2766_2782 2782 4256.89
c_2766_2782_i 2766 2766_2782 4.67522e-10
r_3326_3342_e 3326 3342 13758.3
r_3326_3342_i 3326_3342 3342 95645.6
c_3326_3342_i 3326 3326_3342 9.36084e-12
r_3886_3902_e 3886 3902 13758.3
r_3886_3902_i 3886_3902 3902 95645.6
c_3886_3902_i 3886 3886_3902 9.36084e-12
r_527_543_e 527 543 13376.4
r_527_543_i 527_543 543 93218.1
c_527_543_i 527 527_543 2.08965e-09
r_1087_1103_e 1087 1103 13376.4
r_1087_1103_i 1087_1103 1103 93218.1
c_1087_1103_i 1087 1087_1103 2.08965e-09
r_1647_1663_e 1647 1663 836.944
r_1647_1663_i 1647_1663 1663 4256.89
c_1647_1663_i 1647 1647_1663 4.67522e-10
r_2207_2223_e 2207 2223 836.944
r_2207_2223_i 2207_2223 2223 4256.89
c_2207_2223_i 2207 2207_2223 4.67522e-10
r_2767_2783_e 2767 2783 836.944
r_2767_2783_i 2767_2783 2783 4256.89
c_2767_2783_i 2767 2767_2783 4.67522e-10
r_3327_3343_e 3327 3343 13758.3
r_3327_3343_i 3327_3343 3343 95645.6
c_3327_3343_i 3327 3327_3343 9.36084e-12
r_3887_3903_e 3887 3903 13758.3
r_3887_3903_i 3887_3903 3903 95645.6
c_3887_3903_i 3887 3887_3903 9.36084e-12
r_528_544_e 528 544 13376.4
r_528_544_i 528_544 544 93218.1
c_528_544_i 528 528_544 2.08965e-09
r_1088_1104_e 1088 1104 13376.4
r_1088_1104_i 1088_1104 1104 93218.1
c_1088_1104_i 1088 1088_1104 2.08965e-09
r_1648_1664_e 1648 1664 836.944
r_1648_1664_i 1648_1664 1664 4256.89
c_1648_1664_i 1648 1648_1664 4.67522e-10
r_2208_2224_e 2208 2224 836.944
r_2208_2224_i 2208_2224 2224 4256.89
c_2208_2224_i 2208 2208_2224 4.67522e-10
r_2768_2784_e 2768 2784 836.944
r_2768_2784_i 2768_2784 2784 4256.89
c_2768_2784_i 2768 2768_2784 4.67522e-10
r_3328_3344_e 3328 3344 13758.3
r_3328_3344_i 3328_3344 3344 95645.6
c_3328_3344_i 3328 3328_3344 9.36084e-12
r_3888_3904_e 3888 3904 13758.3
r_3888_3904_i 3888_3904 3904 95645.6
c_3888_3904_i 3888 3888_3904 9.36084e-12
r_529_545_e 529 545 13376.4
r_529_545_i 529_545 545 93218.1
c_529_545_i 529 529_545 2.08965e-09
r_1089_1105_e 1089 1105 13376.4
r_1089_1105_i 1089_1105 1105 93218.1
c_1089_1105_i 1089 1089_1105 2.08965e-09
r_1649_1665_e 1649 1665 13376.4
r_1649_1665_i 1649_1665 1665 93218.1
c_1649_1665_i 1649 1649_1665 2.08965e-09
r_2209_2225_e 2209 2225 13376.4
r_2209_2225_i 2209_2225 2225 93218.1
c_2209_2225_i 2209 2209_2225 2.08965e-09
r_2769_2785_e 2769 2785 13376.4
r_2769_2785_i 2769_2785 2785 93218.1
c_2769_2785_i 2769 2769_2785 2.08965e-09
r_3329_3345_e 3329 3345 13376.4
r_3329_3345_i 3329_3345 3345 93218.1
c_3329_3345_i 3329 3329_3345 2.08965e-09
r_3889_3905_e 3889 3905 13376.4
r_3889_3905_i 3889_3905 3905 93218.1
c_3889_3905_i 3889 3889_3905 2.08965e-09
r_530_546_e 530 546 13376.4
r_530_546_i 530_546 546 93218.1
c_530_546_i 530 530_546 2.08965e-09
r_1090_1106_e 1090 1106 13376.4
r_1090_1106_i 1090_1106 1106 93218.1
c_1090_1106_i 1090 1090_1106 2.08965e-09
r_1650_1666_e 1650 1666 13376.4
r_1650_1666_i 1650_1666 1666 93218.1
c_1650_1666_i 1650 1650_1666 2.08965e-09
r_2210_2226_e 2210 2226 13376.4
r_2210_2226_i 2210_2226 2226 93218.1
c_2210_2226_i 2210 2210_2226 2.08965e-09
r_2770_2786_e 2770 2786 13376.4
r_2770_2786_i 2770_2786 2786 93218.1
c_2770_2786_i 2770 2770_2786 2.08965e-09
r_3330_3346_e 3330 3346 13376.4
r_3330_3346_i 3330_3346 3346 93218.1
c_3330_3346_i 3330 3330_3346 2.08965e-09
r_3890_3906_e 3890 3906 13376.4
r_3890_3906_i 3890_3906 3906 93218.1
c_3890_3906_i 3890 3890_3906 2.08965e-09
r_531_547_e 531 547 13376.4
r_531_547_i 531_547 547 93218.1
c_531_547_i 531 531_547 2.08965e-09
r_1091_1107_e 1091 1107 13376.4
r_1091_1107_i 1091_1107 1107 93218.1
c_1091_1107_i 1091 1091_1107 2.08965e-09
r_1651_1667_e 1651 1667 836.944
r_1651_1667_i 1651_1667 1667 4256.89
c_1651_1667_i 1651 1651_1667 4.67522e-10
r_2211_2227_e 2211 2227 836.944
r_2211_2227_i 2211_2227 2227 4256.89
c_2211_2227_i 2211 2211_2227 4.67522e-10
r_2771_2787_e 2771 2787 836.944
r_2771_2787_i 2771_2787 2787 4256.89
c_2771_2787_i 2771 2771_2787 4.67522e-10
r_3331_3347_e 3331 3347 836.944
r_3331_3347_i 3331_3347 3347 4256.89
c_3331_3347_i 3331 3331_3347 4.67522e-10
r_3891_3907_e 3891 3907 836.944
r_3891_3907_i 3891_3907 3907 4256.89
c_3891_3907_i 3891 3891_3907 4.67522e-10
r_532_548_e 532 548 13376.4
r_532_548_i 532_548 548 93218.1
c_532_548_i 532 532_548 2.08965e-09
r_1092_1108_e 1092 1108 13376.4
r_1092_1108_i 1092_1108 1108 93218.1
c_1092_1108_i 1092 1092_1108 2.08965e-09
r_1652_1668_e 1652 1668 836.944
r_1652_1668_i 1652_1668 1668 4256.89
c_1652_1668_i 1652 1652_1668 4.67522e-10
r_2212_2228_e 2212 2228 836.944
r_2212_2228_i 2212_2228 2228 4256.89
c_2212_2228_i 2212 2212_2228 4.67522e-10
r_2772_2788_e 2772 2788 836.944
r_2772_2788_i 2772_2788 2788 4256.89
c_2772_2788_i 2772 2772_2788 4.67522e-10
r_3332_3348_e 3332 3348 13758.3
r_3332_3348_i 3332_3348 3348 95645.6
c_3332_3348_i 3332 3332_3348 9.36084e-12
r_3892_3908_e 3892 3908 13758.3
r_3892_3908_i 3892_3908 3908 95645.6
c_3892_3908_i 3892 3892_3908 9.36084e-12
r_533_549_e 533 549 13376.4
r_533_549_i 533_549 549 93218.1
c_533_549_i 533 533_549 2.08965e-09
r_1093_1109_e 1093 1109 13376.4
r_1093_1109_i 1093_1109 1109 93218.1
c_1093_1109_i 1093 1093_1109 2.08965e-09
r_1653_1669_e 1653 1669 836.944
r_1653_1669_i 1653_1669 1669 4256.89
c_1653_1669_i 1653 1653_1669 4.67522e-10
r_2213_2229_e 2213 2229 836.944
r_2213_2229_i 2213_2229 2229 4256.89
c_2213_2229_i 2213 2213_2229 4.67522e-10
r_2773_2789_e 2773 2789 836.944
r_2773_2789_i 2773_2789 2789 4256.89
c_2773_2789_i 2773 2773_2789 4.67522e-10
r_3333_3349_e 3333 3349 13758.3
r_3333_3349_i 3333_3349 3349 95645.6
c_3333_3349_i 3333 3333_3349 9.36084e-12
r_3893_3909_e 3893 3909 13758.3
r_3893_3909_i 3893_3909 3909 95645.6
c_3893_3909_i 3893 3893_3909 9.36084e-12
r_534_550_e 534 550 13376.4
r_534_550_i 534_550 550 93218.1
c_534_550_i 534 534_550 2.08965e-09
r_1094_1110_e 1094 1110 13376.4
r_1094_1110_i 1094_1110 1110 93218.1
c_1094_1110_i 1094 1094_1110 2.08965e-09
r_1654_1670_e 1654 1670 836.944
r_1654_1670_i 1654_1670 1670 4256.89
c_1654_1670_i 1654 1654_1670 4.67522e-10
r_2214_2230_e 2214 2230 836.944
r_2214_2230_i 2214_2230 2230 4256.89
c_2214_2230_i 2214 2214_2230 4.67522e-10
r_2774_2790_e 2774 2790 836.944
r_2774_2790_i 2774_2790 2790 4256.89
c_2774_2790_i 2774 2774_2790 4.67522e-10
r_3334_3350_e 3334 3350 13758.3
r_3334_3350_i 3334_3350 3350 95645.6
c_3334_3350_i 3334 3334_3350 9.36084e-12
r_3894_3910_e 3894 3910 13758.3
r_3894_3910_i 3894_3910 3910 95645.6
c_3894_3910_i 3894 3894_3910 9.36084e-12
r_535_551_e 535 551 13376.4
r_535_551_i 535_551 551 93218.1
c_535_551_i 535 535_551 2.08965e-09
r_1095_1111_e 1095 1111 13376.4
r_1095_1111_i 1095_1111 1111 93218.1
c_1095_1111_i 1095 1095_1111 2.08965e-09
r_1655_1671_e 1655 1671 836.944
r_1655_1671_i 1655_1671 1671 4256.89
c_1655_1671_i 1655 1655_1671 4.67522e-10
r_2215_2231_e 2215 2231 836.944
r_2215_2231_i 2215_2231 2231 4256.89
c_2215_2231_i 2215 2215_2231 4.67522e-10
r_2775_2791_e 2775 2791 836.944
r_2775_2791_i 2775_2791 2791 4256.89
c_2775_2791_i 2775 2775_2791 4.67522e-10
r_3335_3351_e 3335 3351 13758.3
r_3335_3351_i 3335_3351 3351 95645.6
c_3335_3351_i 3335 3335_3351 9.36084e-12
r_3895_3911_e 3895 3911 13758.3
r_3895_3911_i 3895_3911 3911 95645.6
c_3895_3911_i 3895 3895_3911 9.36084e-12
r_536_552_e 536 552 13376.4
r_536_552_i 536_552 552 93218.1
c_536_552_i 536 536_552 2.08965e-09
r_1096_1112_e 1096 1112 13376.4
r_1096_1112_i 1096_1112 1112 93218.1
c_1096_1112_i 1096 1096_1112 2.08965e-09
r_1656_1672_e 1656 1672 836.944
r_1656_1672_i 1656_1672 1672 4256.89
c_1656_1672_i 1656 1656_1672 4.67522e-10
r_2216_2232_e 2216 2232 836.944
r_2216_2232_i 2216_2232 2232 4256.89
c_2216_2232_i 2216 2216_2232 4.67522e-10
r_2776_2792_e 2776 2792 836.944
r_2776_2792_i 2776_2792 2792 4256.89
c_2776_2792_i 2776 2776_2792 4.67522e-10
r_3336_3352_e 3336 3352 13758.3
r_3336_3352_i 3336_3352 3352 95645.6
c_3336_3352_i 3336 3336_3352 9.36084e-12
r_3896_3912_e 3896 3912 13758.3
r_3896_3912_i 3896_3912 3912 95645.6
c_3896_3912_i 3896 3896_3912 9.36084e-12
r_537_553_e 537 553 13376.4
r_537_553_i 537_553 553 93218.1
c_537_553_i 537 537_553 2.08965e-09
r_1097_1113_e 1097 1113 13376.4
r_1097_1113_i 1097_1113 1113 93218.1
c_1097_1113_i 1097 1097_1113 2.08965e-09
r_1657_1673_e 1657 1673 836.944
r_1657_1673_i 1657_1673 1673 4256.89
c_1657_1673_i 1657 1657_1673 4.67522e-10
r_2217_2233_e 2217 2233 836.944
r_2217_2233_i 2217_2233 2233 4256.89
c_2217_2233_i 2217 2217_2233 4.67522e-10
r_2777_2793_e 2777 2793 836.944
r_2777_2793_i 2777_2793 2793 4256.89
c_2777_2793_i 2777 2777_2793 4.67522e-10
r_3337_3353_e 3337 3353 13758.3
r_3337_3353_i 3337_3353 3353 95645.6
c_3337_3353_i 3337 3337_3353 9.36084e-12
r_3897_3913_e 3897 3913 13758.3
r_3897_3913_i 3897_3913 3913 95645.6
c_3897_3913_i 3897 3897_3913 9.36084e-12
r_538_554_e 538 554 13376.4
r_538_554_i 538_554 554 93218.1
c_538_554_i 538 538_554 2.08965e-09
r_1098_1114_e 1098 1114 13376.4
r_1098_1114_i 1098_1114 1114 93218.1
c_1098_1114_i 1098 1098_1114 2.08965e-09
r_1658_1674_e 1658 1674 836.944
r_1658_1674_i 1658_1674 1674 4256.89
c_1658_1674_i 1658 1658_1674 4.67522e-10
r_2218_2234_e 2218 2234 836.944
r_2218_2234_i 2218_2234 2234 4256.89
c_2218_2234_i 2218 2218_2234 4.67522e-10
r_2778_2794_e 2778 2794 836.944
r_2778_2794_i 2778_2794 2794 4256.89
c_2778_2794_i 2778 2778_2794 4.67522e-10
r_3338_3354_e 3338 3354 13758.3
r_3338_3354_i 3338_3354 3354 95645.6
c_3338_3354_i 3338 3338_3354 9.36084e-12
r_3898_3914_e 3898 3914 13758.3
r_3898_3914_i 3898_3914 3914 95645.6
c_3898_3914_i 3898 3898_3914 9.36084e-12
r_539_555_e 539 555 13376.4
r_539_555_i 539_555 555 93218.1
c_539_555_i 539 539_555 2.08965e-09
r_1099_1115_e 1099 1115 396.485
r_1099_1115_i 1099_1115 1115 1004.73
c_1099_1115_i 1099 1099_1115 1.65883e-10
r_1659_1675_e 1659 1675 396.485
r_1659_1675_i 1659_1675 1675 1004.73
c_1659_1675_i 1659 1659_1675 1.65883e-10
r_2219_2235_e 2219 2235 836.944
r_2219_2235_i 2219_2235 2235 4256.89
c_2219_2235_i 2219 2219_2235 4.67522e-10
r_2779_2795_e 2779 2795 836.944
r_2779_2795_i 2779_2795 2795 4256.89
c_2779_2795_i 2779 2779_2795 4.67522e-10
r_3339_3355_e 3339 3355 13758.3
r_3339_3355_i 3339_3355 3355 95645.6
c_3339_3355_i 3339 3339_3355 9.36084e-12
r_3899_3915_e 3899 3915 13758.3
r_3899_3915_i 3899_3915 3915 95645.6
c_3899_3915_i 3899 3899_3915 9.36084e-12
r_540_556_e 540 556 13376.4
r_540_556_i 540_556 556 93218.1
c_540_556_i 540 540_556 2.08965e-09
r_1100_1116_e 1100 1116 396.485
r_1100_1116_i 1100_1116 1116 1004.73
c_1100_1116_i 1100 1100_1116 1.65883e-10
r_1660_1676_e 1660 1676 396.485
r_1660_1676_i 1660_1676 1676 1004.73
c_1660_1676_i 1660 1660_1676 1.65883e-10
r_2220_2236_e 2220 2236 836.944
r_2220_2236_i 2220_2236 2236 4256.89
c_2220_2236_i 2220 2220_2236 4.67522e-10
r_2780_2796_e 2780 2796 836.944
r_2780_2796_i 2780_2796 2796 4256.89
c_2780_2796_i 2780 2780_2796 4.67522e-10
r_3340_3356_e 3340 3356 13758.3
r_3340_3356_i 3340_3356 3356 95645.6
c_3340_3356_i 3340 3340_3356 9.36084e-12
r_3900_3916_e 3900 3916 13758.3
r_3900_3916_i 3900_3916 3916 95645.6
c_3900_3916_i 3900 3900_3916 9.36084e-12
r_541_557_e 541 557 13376.4
r_541_557_i 541_557 557 93218.1
c_541_557_i 541 541_557 2.08965e-09
r_1101_1117_e 1101 1117 13376.4
r_1101_1117_i 1101_1117 1117 93218.1
c_1101_1117_i 1101 1101_1117 2.08965e-09
r_1661_1677_e 1661 1677 836.944
r_1661_1677_i 1661_1677 1677 4256.89
c_1661_1677_i 1661 1661_1677 4.67522e-10
r_2221_2237_e 2221 2237 836.944
r_2221_2237_i 2221_2237 2237 4256.89
c_2221_2237_i 2221 2221_2237 4.67522e-10
r_2781_2797_e 2781 2797 836.944
r_2781_2797_i 2781_2797 2797 4256.89
c_2781_2797_i 2781 2781_2797 4.67522e-10
r_3341_3357_e 3341 3357 13758.3
r_3341_3357_i 3341_3357 3357 95645.6
c_3341_3357_i 3341 3341_3357 9.36084e-12
r_3901_3917_e 3901 3917 13758.3
r_3901_3917_i 3901_3917 3917 95645.6
c_3901_3917_i 3901 3901_3917 9.36084e-12
r_542_558_e 542 558 13376.4
r_542_558_i 542_558 558 93218.1
c_542_558_i 542 542_558 2.08965e-09
r_1102_1118_e 1102 1118 13376.4
r_1102_1118_i 1102_1118 1118 93218.1
c_1102_1118_i 1102 1102_1118 2.08965e-09
r_1662_1678_e 1662 1678 836.944
r_1662_1678_i 1662_1678 1678 4256.89
c_1662_1678_i 1662 1662_1678 4.67522e-10
r_2222_2238_e 2222 2238 836.944
r_2222_2238_i 2222_2238 2238 4256.89
c_2222_2238_i 2222 2222_2238 4.67522e-10
r_2782_2798_e 2782 2798 836.944
r_2782_2798_i 2782_2798 2798 4256.89
c_2782_2798_i 2782 2782_2798 4.67522e-10
r_3342_3358_e 3342 3358 13758.3
r_3342_3358_i 3342_3358 3358 95645.6
c_3342_3358_i 3342 3342_3358 9.36084e-12
r_3902_3918_e 3902 3918 13758.3
r_3902_3918_i 3902_3918 3918 95645.6
c_3902_3918_i 3902 3902_3918 9.36084e-12
r_543_559_e 543 559 13376.4
r_543_559_i 543_559 559 93218.1
c_543_559_i 543 543_559 2.08965e-09
r_1103_1119_e 1103 1119 13376.4
r_1103_1119_i 1103_1119 1119 93218.1
c_1103_1119_i 1103 1103_1119 2.08965e-09
r_1663_1679_e 1663 1679 836.944
r_1663_1679_i 1663_1679 1679 4256.89
c_1663_1679_i 1663 1663_1679 4.67522e-10
r_2223_2239_e 2223 2239 836.944
r_2223_2239_i 2223_2239 2239 4256.89
c_2223_2239_i 2223 2223_2239 4.67522e-10
r_2783_2799_e 2783 2799 836.944
r_2783_2799_i 2783_2799 2799 4256.89
c_2783_2799_i 2783 2783_2799 4.67522e-10
r_3343_3359_e 3343 3359 13758.3
r_3343_3359_i 3343_3359 3359 95645.6
c_3343_3359_i 3343 3343_3359 9.36084e-12
r_3903_3919_e 3903 3919 13758.3
r_3903_3919_i 3903_3919 3919 95645.6
c_3903_3919_i 3903 3903_3919 9.36084e-12
r_544_560_e 544 560 13376.4
r_544_560_i 544_560 560 93218.1
c_544_560_i 544 544_560 2.08965e-09
r_1104_1120_e 1104 1120 13376.4
r_1104_1120_i 1104_1120 1120 93218.1
c_1104_1120_i 1104 1104_1120 2.08965e-09
r_1664_1680_e 1664 1680 836.944
r_1664_1680_i 1664_1680 1680 4256.89
c_1664_1680_i 1664 1664_1680 4.67522e-10
r_2224_2240_e 2224 2240 836.944
r_2224_2240_i 2224_2240 2240 4256.89
c_2224_2240_i 2224 2224_2240 4.67522e-10
r_2784_2800_e 2784 2800 836.944
r_2784_2800_i 2784_2800 2800 4256.89
c_2784_2800_i 2784 2784_2800 4.67522e-10
r_3344_3360_e 3344 3360 13758.3
r_3344_3360_i 3344_3360 3360 95645.6
c_3344_3360_i 3344 3344_3360 9.36084e-12
r_3904_3920_e 3904 3920 13758.3
r_3904_3920_i 3904_3920 3920 95645.6
c_3904_3920_i 3904 3904_3920 9.36084e-12
r_1_561_e 1 561 13376.4
r_1_561_i 1_561 561 93218.1
c_1_561_i 1 1_561 2.08965e-09
r_561_1121_e 561 1121 13376.4
r_561_1121_i 561_1121 1121 93218.1
c_561_1121_i 561 561_1121 2.08965e-09
r_1121_1681_e 1121 1681 13376.4
r_1121_1681_i 1121_1681 1681 93218.1
c_1121_1681_i 1121 1121_1681 2.08965e-09
r_1681_2241_e 1681 2241 13376.4
r_1681_2241_i 1681_2241 2241 93218.1
c_1681_2241_i 1681 1681_2241 2.08965e-09
r_2241_2801_e 2241 2801 13376.4
r_2241_2801_i 2241_2801 2801 93218.1
c_2241_2801_i 2241 2241_2801 2.08965e-09
r_2801_3361_e 2801 3361 13376.4
r_2801_3361_i 2801_3361 3361 93218.1
c_2801_3361_i 2801 2801_3361 2.08965e-09
r_2_562_e 2 562 13376.4
r_2_562_i 2_562 562 93218.1
c_2_562_i 2 2_562 2.08965e-09
r_562_1122_e 562 1122 13376.4
r_562_1122_i 562_1122 1122 93218.1
c_562_1122_i 562 562_1122 2.08965e-09
r_1122_1682_e 1122 1682 13376.4
r_1122_1682_i 1122_1682 1682 93218.1
c_1122_1682_i 1122 1122_1682 2.08965e-09
r_1682_2242_e 1682 2242 13376.4
r_1682_2242_i 1682_2242 2242 93218.1
c_1682_2242_i 1682 1682_2242 2.08965e-09
r_2242_2802_e 2242 2802 13376.4
r_2242_2802_i 2242_2802 2802 93218.1
c_2242_2802_i 2242 2242_2802 2.08965e-09
r_2802_3362_e 2802 3362 13376.4
r_2802_3362_i 2802_3362 3362 93218.1
c_2802_3362_i 2802 2802_3362 2.08965e-09
r_3_563_e 3 563 13376.4
r_3_563_i 3_563 563 93218.1
c_3_563_i 3 3_563 2.08965e-09
r_563_1123_e 563 1123 13376.4
r_563_1123_i 563_1123 1123 93218.1
c_563_1123_i 563 563_1123 2.08965e-09
r_1123_1683_e 1123 1683 836.944
r_1123_1683_i 1123_1683 1683 4256.89
c_1123_1683_i 1123 1123_1683 4.67522e-10
r_1683_2243_e 1683 2243 836.944
r_1683_2243_i 1683_2243 2243 4256.89
c_1683_2243_i 1683 1683_2243 4.67522e-10
r_2243_2803_e 2243 2803 836.944
r_2243_2803_i 2243_2803 2803 4256.89
c_2243_2803_i 2243 2243_2803 4.67522e-10
r_2803_3363_e 2803 3363 836.944
r_2803_3363_i 2803_3363 3363 4256.89
c_2803_3363_i 2803 2803_3363 4.67522e-10
r_4_564_e 4 564 13376.4
r_4_564_i 4_564 564 93218.1
c_4_564_i 4 4_564 2.08965e-09
r_564_1124_e 564 1124 13376.4
r_564_1124_i 564_1124 1124 93218.1
c_564_1124_i 564 564_1124 2.08965e-09
r_1124_1684_e 1124 1684 836.944
r_1124_1684_i 1124_1684 1684 4256.89
c_1124_1684_i 1124 1124_1684 4.67522e-10
r_1684_2244_e 1684 2244 836.944
r_1684_2244_i 1684_2244 2244 4256.89
c_1684_2244_i 1684 1684_2244 4.67522e-10
r_2244_2804_e 2244 2804 836.944
r_2244_2804_i 2244_2804 2804 4256.89
c_2244_2804_i 2244 2244_2804 4.67522e-10
r_2804_3364_e 2804 3364 13758.3
r_2804_3364_i 2804_3364 3364 95645.6
c_2804_3364_i 2804 2804_3364 9.36084e-12
r_5_565_e 5 565 13376.4
r_5_565_i 5_565 565 93218.1
c_5_565_i 5 5_565 2.08965e-09
r_565_1125_e 565 1125 13376.4
r_565_1125_i 565_1125 1125 93218.1
c_565_1125_i 565 565_1125 2.08965e-09
r_1125_1685_e 1125 1685 836.944
r_1125_1685_i 1125_1685 1685 4256.89
c_1125_1685_i 1125 1125_1685 4.67522e-10
r_1685_2245_e 1685 2245 836.944
r_1685_2245_i 1685_2245 2245 4256.89
c_1685_2245_i 1685 1685_2245 4.67522e-10
r_2245_2805_e 2245 2805 836.944
r_2245_2805_i 2245_2805 2805 4256.89
c_2245_2805_i 2245 2245_2805 4.67522e-10
r_2805_3365_e 2805 3365 13758.3
r_2805_3365_i 2805_3365 3365 95645.6
c_2805_3365_i 2805 2805_3365 9.36084e-12
r_6_566_e 6 566 13376.4
r_6_566_i 6_566 566 93218.1
c_6_566_i 6 6_566 2.08965e-09
r_566_1126_e 566 1126 13376.4
r_566_1126_i 566_1126 1126 93218.1
c_566_1126_i 566 566_1126 2.08965e-09
r_1126_1686_e 1126 1686 836.944
r_1126_1686_i 1126_1686 1686 4256.89
c_1126_1686_i 1126 1126_1686 4.67522e-10
r_1686_2246_e 1686 2246 836.944
r_1686_2246_i 1686_2246 2246 4256.89
c_1686_2246_i 1686 1686_2246 4.67522e-10
r_2246_2806_e 2246 2806 836.944
r_2246_2806_i 2246_2806 2806 4256.89
c_2246_2806_i 2246 2246_2806 4.67522e-10
r_2806_3366_e 2806 3366 13758.3
r_2806_3366_i 2806_3366 3366 95645.6
c_2806_3366_i 2806 2806_3366 9.36084e-12
r_7_567_e 7 567 13376.4
r_7_567_i 7_567 567 93218.1
c_7_567_i 7 7_567 2.08965e-09
r_567_1127_e 567 1127 13376.4
r_567_1127_i 567_1127 1127 93218.1
c_567_1127_i 567 567_1127 2.08965e-09
r_1127_1687_e 1127 1687 836.944
r_1127_1687_i 1127_1687 1687 4256.89
c_1127_1687_i 1127 1127_1687 4.67522e-10
r_1687_2247_e 1687 2247 836.944
r_1687_2247_i 1687_2247 2247 4256.89
c_1687_2247_i 1687 1687_2247 4.67522e-10
r_2247_2807_e 2247 2807 836.944
r_2247_2807_i 2247_2807 2807 4256.89
c_2247_2807_i 2247 2247_2807 4.67522e-10
r_2807_3367_e 2807 3367 13758.3
r_2807_3367_i 2807_3367 3367 95645.6
c_2807_3367_i 2807 2807_3367 9.36084e-12
r_8_568_e 8 568 13376.4
r_8_568_i 8_568 568 93218.1
c_8_568_i 8 8_568 2.08965e-09
r_568_1128_e 568 1128 13376.4
r_568_1128_i 568_1128 1128 93218.1
c_568_1128_i 568 568_1128 2.08965e-09
r_1128_1688_e 1128 1688 836.944
r_1128_1688_i 1128_1688 1688 4256.89
c_1128_1688_i 1128 1128_1688 4.67522e-10
r_1688_2248_e 1688 2248 836.944
r_1688_2248_i 1688_2248 2248 4256.89
c_1688_2248_i 1688 1688_2248 4.67522e-10
r_2248_2808_e 2248 2808 836.944
r_2248_2808_i 2248_2808 2808 4256.89
c_2248_2808_i 2248 2248_2808 4.67522e-10
r_2808_3368_e 2808 3368 13758.3
r_2808_3368_i 2808_3368 3368 95645.6
c_2808_3368_i 2808 2808_3368 9.36084e-12
r_9_569_e 9 569 13376.4
r_9_569_i 9_569 569 93218.1
c_9_569_i 9 9_569 2.08965e-09
r_569_1129_e 569 1129 13376.4
r_569_1129_i 569_1129 1129 93218.1
c_569_1129_i 569 569_1129 2.08965e-09
r_1129_1689_e 1129 1689 836.944
r_1129_1689_i 1129_1689 1689 4256.89
c_1129_1689_i 1129 1129_1689 4.67522e-10
r_1689_2249_e 1689 2249 836.944
r_1689_2249_i 1689_2249 2249 4256.89
c_1689_2249_i 1689 1689_2249 4.67522e-10
r_2249_2809_e 2249 2809 836.944
r_2249_2809_i 2249_2809 2809 4256.89
c_2249_2809_i 2249 2249_2809 4.67522e-10
r_2809_3369_e 2809 3369 13758.3
r_2809_3369_i 2809_3369 3369 95645.6
c_2809_3369_i 2809 2809_3369 9.36084e-12
r_10_570_e 10 570 13376.4
r_10_570_i 10_570 570 93218.1
c_10_570_i 10 10_570 2.08965e-09
r_570_1130_e 570 1130 13376.4
r_570_1130_i 570_1130 1130 93218.1
c_570_1130_i 570 570_1130 2.08965e-09
r_1130_1690_e 1130 1690 836.944
r_1130_1690_i 1130_1690 1690 4256.89
c_1130_1690_i 1130 1130_1690 4.67522e-10
r_1690_2250_e 1690 2250 836.944
r_1690_2250_i 1690_2250 2250 4256.89
c_1690_2250_i 1690 1690_2250 4.67522e-10
r_2250_2810_e 2250 2810 836.944
r_2250_2810_i 2250_2810 2810 4256.89
c_2250_2810_i 2250 2250_2810 4.67522e-10
r_2810_3370_e 2810 3370 13758.3
r_2810_3370_i 2810_3370 3370 95645.6
c_2810_3370_i 2810 2810_3370 9.36084e-12
r_11_571_e 11 571 13376.4
r_11_571_i 11_571 571 93218.1
c_11_571_i 11 11_571 2.08965e-09
r_571_1131_e 571 1131 13376.4
r_571_1131_i 571_1131 1131 93218.1
c_571_1131_i 571 571_1131 2.08965e-09
r_1131_1691_e 1131 1691 396.769
r_1131_1691_i 1131_1691 1691 1005.45
c_1131_1691_i 1131 1131_1691 1.65766e-10
r_1691_2251_e 1691 2251 836.944
r_1691_2251_i 1691_2251 2251 4256.89
c_1691_2251_i 1691 1691_2251 4.67522e-10
r_2251_2811_e 2251 2811 836.944
r_2251_2811_i 2251_2811 2811 4256.89
c_2251_2811_i 2251 2251_2811 4.67522e-10
r_2811_3371_e 2811 3371 13758.3
r_2811_3371_i 2811_3371 3371 95645.6
c_2811_3371_i 2811 2811_3371 9.36084e-12
r_12_572_e 12 572 13376.4
r_12_572_i 12_572 572 93218.1
c_12_572_i 12 12_572 2.08965e-09
r_572_1132_e 572 1132 13376.4
r_572_1132_i 572_1132 1132 93218.1
c_572_1132_i 572 572_1132 2.08965e-09
r_1132_1692_e 1132 1692 396.769
r_1132_1692_i 1132_1692 1692 1005.45
c_1132_1692_i 1132 1132_1692 1.65766e-10
r_1692_2252_e 1692 2252 836.944
r_1692_2252_i 1692_2252 2252 4256.89
c_1692_2252_i 1692 1692_2252 4.67522e-10
r_2252_2812_e 2252 2812 836.944
r_2252_2812_i 2252_2812 2812 4256.89
c_2252_2812_i 2252 2252_2812 4.67522e-10
r_2812_3372_e 2812 3372 13758.3
r_2812_3372_i 2812_3372 3372 95645.6
c_2812_3372_i 2812 2812_3372 9.36084e-12
r_13_573_e 13 573 13376.4
r_13_573_i 13_573 573 93218.1
c_13_573_i 13 13_573 2.08965e-09
r_573_1133_e 573 1133 13376.4
r_573_1133_i 573_1133 1133 93218.1
c_573_1133_i 573 573_1133 2.08965e-09
r_1133_1693_e 1133 1693 836.944
r_1133_1693_i 1133_1693 1693 4256.89
c_1133_1693_i 1133 1133_1693 4.67522e-10
r_1693_2253_e 1693 2253 836.944
r_1693_2253_i 1693_2253 2253 4256.89
c_1693_2253_i 1693 1693_2253 4.67522e-10
r_2253_2813_e 2253 2813 836.944
r_2253_2813_i 2253_2813 2813 4256.89
c_2253_2813_i 2253 2253_2813 4.67522e-10
r_2813_3373_e 2813 3373 13758.3
r_2813_3373_i 2813_3373 3373 95645.6
c_2813_3373_i 2813 2813_3373 9.36084e-12
r_14_574_e 14 574 13376.4
r_14_574_i 14_574 574 93218.1
c_14_574_i 14 14_574 2.08965e-09
r_574_1134_e 574 1134 13376.4
r_574_1134_i 574_1134 1134 93218.1
c_574_1134_i 574 574_1134 2.08965e-09
r_1134_1694_e 1134 1694 836.944
r_1134_1694_i 1134_1694 1694 4256.89
c_1134_1694_i 1134 1134_1694 4.67522e-10
r_1694_2254_e 1694 2254 836.944
r_1694_2254_i 1694_2254 2254 4256.89
c_1694_2254_i 1694 1694_2254 4.67522e-10
r_2254_2814_e 2254 2814 836.944
r_2254_2814_i 2254_2814 2814 4256.89
c_2254_2814_i 2254 2254_2814 4.67522e-10
r_2814_3374_e 2814 3374 13758.3
r_2814_3374_i 2814_3374 3374 95645.6
c_2814_3374_i 2814 2814_3374 9.36084e-12
r_15_575_e 15 575 13376.4
r_15_575_i 15_575 575 93218.1
c_15_575_i 15 15_575 2.08965e-09
r_575_1135_e 575 1135 13376.4
r_575_1135_i 575_1135 1135 93218.1
c_575_1135_i 575 575_1135 2.08965e-09
r_1135_1695_e 1135 1695 836.944
r_1135_1695_i 1135_1695 1695 4256.89
c_1135_1695_i 1135 1135_1695 4.67522e-10
r_1695_2255_e 1695 2255 836.944
r_1695_2255_i 1695_2255 2255 4256.89
c_1695_2255_i 1695 1695_2255 4.67522e-10
r_2255_2815_e 2255 2815 836.944
r_2255_2815_i 2255_2815 2815 4256.89
c_2255_2815_i 2255 2255_2815 4.67522e-10
r_2815_3375_e 2815 3375 13758.3
r_2815_3375_i 2815_3375 3375 95645.6
c_2815_3375_i 2815 2815_3375 9.36084e-12
r_16_576_e 16 576 13376.4
r_16_576_i 16_576 576 93218.1
c_16_576_i 16 16_576 2.08965e-09
r_576_1136_e 576 1136 13376.4
r_576_1136_i 576_1136 1136 93218.1
c_576_1136_i 576 576_1136 2.08965e-09
r_1136_1696_e 1136 1696 836.944
r_1136_1696_i 1136_1696 1696 4256.89
c_1136_1696_i 1136 1136_1696 4.67522e-10
r_1696_2256_e 1696 2256 836.944
r_1696_2256_i 1696_2256 2256 4256.89
c_1696_2256_i 1696 1696_2256 4.67522e-10
r_2256_2816_e 2256 2816 836.944
r_2256_2816_i 2256_2816 2816 4256.89
c_2256_2816_i 2256 2256_2816 4.67522e-10
r_2816_3376_e 2816 3376 13758.3
r_2816_3376_i 2816_3376 3376 95645.6
c_2816_3376_i 2816 2816_3376 9.36084e-12
r_17_577_e 17 577 13376.4
r_17_577_i 17_577 577 93218.1
c_17_577_i 17 17_577 2.08965e-09
r_577_1137_e 577 1137 13376.4
r_577_1137_i 577_1137 1137 93218.1
c_577_1137_i 577 577_1137 2.08965e-09
r_1137_1697_e 1137 1697 13376.4
r_1137_1697_i 1137_1697 1697 93218.1
c_1137_1697_i 1137 1137_1697 2.08965e-09
r_1697_2257_e 1697 2257 13376.4
r_1697_2257_i 1697_2257 2257 93218.1
c_1697_2257_i 1697 1697_2257 2.08965e-09
r_2257_2817_e 2257 2817 13376.4
r_2257_2817_i 2257_2817 2817 93218.1
c_2257_2817_i 2257 2257_2817 2.08965e-09
r_2817_3377_e 2817 3377 13376.4
r_2817_3377_i 2817_3377 3377 93218.1
c_2817_3377_i 2817 2817_3377 2.08965e-09
r_18_578_e 18 578 13376.4
r_18_578_i 18_578 578 93218.1
c_18_578_i 18 18_578 2.08965e-09
r_578_1138_e 578 1138 13376.4
r_578_1138_i 578_1138 1138 93218.1
c_578_1138_i 578 578_1138 2.08965e-09
r_1138_1698_e 1138 1698 13376.4
r_1138_1698_i 1138_1698 1698 93218.1
c_1138_1698_i 1138 1138_1698 2.08965e-09
r_1698_2258_e 1698 2258 13376.4
r_1698_2258_i 1698_2258 2258 93218.1
c_1698_2258_i 1698 1698_2258 2.08965e-09
r_2258_2818_e 2258 2818 13376.4
r_2258_2818_i 2258_2818 2818 93218.1
c_2258_2818_i 2258 2258_2818 2.08965e-09
r_2818_3378_e 2818 3378 13376.4
r_2818_3378_i 2818_3378 3378 93218.1
c_2818_3378_i 2818 2818_3378 2.08965e-09
r_19_579_e 19 579 13376.4
r_19_579_i 19_579 579 93218.1
c_19_579_i 19 19_579 2.08965e-09
r_579_1139_e 579 1139 13376.4
r_579_1139_i 579_1139 1139 93218.1
c_579_1139_i 579 579_1139 2.08965e-09
r_1139_1699_e 1139 1699 836.944
r_1139_1699_i 1139_1699 1699 4256.89
c_1139_1699_i 1139 1139_1699 4.67522e-10
r_1699_2259_e 1699 2259 836.944
r_1699_2259_i 1699_2259 2259 4256.89
c_1699_2259_i 1699 1699_2259 4.67522e-10
r_2259_2819_e 2259 2819 836.944
r_2259_2819_i 2259_2819 2819 4256.89
c_2259_2819_i 2259 2259_2819 4.67522e-10
r_2819_3379_e 2819 3379 836.944
r_2819_3379_i 2819_3379 3379 4256.89
c_2819_3379_i 2819 2819_3379 4.67522e-10
r_20_580_e 20 580 13376.4
r_20_580_i 20_580 580 93218.1
c_20_580_i 20 20_580 2.08965e-09
r_580_1140_e 580 1140 13376.4
r_580_1140_i 580_1140 1140 93218.1
c_580_1140_i 580 580_1140 2.08965e-09
r_1140_1700_e 1140 1700 836.944
r_1140_1700_i 1140_1700 1700 4256.89
c_1140_1700_i 1140 1140_1700 4.67522e-10
r_1700_2260_e 1700 2260 836.944
r_1700_2260_i 1700_2260 2260 4256.89
c_1700_2260_i 1700 1700_2260 4.67522e-10
r_2260_2820_e 2260 2820 836.944
r_2260_2820_i 2260_2820 2820 4256.89
c_2260_2820_i 2260 2260_2820 4.67522e-10
r_2820_3380_e 2820 3380 13758.3
r_2820_3380_i 2820_3380 3380 95645.6
c_2820_3380_i 2820 2820_3380 9.36084e-12
r_21_581_e 21 581 13376.4
r_21_581_i 21_581 581 93218.1
c_21_581_i 21 21_581 2.08965e-09
r_581_1141_e 581 1141 13376.4
r_581_1141_i 581_1141 1141 93218.1
c_581_1141_i 581 581_1141 2.08965e-09
r_1141_1701_e 1141 1701 836.944
r_1141_1701_i 1141_1701 1701 4256.89
c_1141_1701_i 1141 1141_1701 4.67522e-10
r_1701_2261_e 1701 2261 836.944
r_1701_2261_i 1701_2261 2261 4256.89
c_1701_2261_i 1701 1701_2261 4.67522e-10
r_2261_2821_e 2261 2821 836.944
r_2261_2821_i 2261_2821 2821 4256.89
c_2261_2821_i 2261 2261_2821 4.67522e-10
r_2821_3381_e 2821 3381 13758.3
r_2821_3381_i 2821_3381 3381 95645.6
c_2821_3381_i 2821 2821_3381 9.36084e-12
r_22_582_e 22 582 13376.4
r_22_582_i 22_582 582 93218.1
c_22_582_i 22 22_582 2.08965e-09
r_582_1142_e 582 1142 13376.4
r_582_1142_i 582_1142 1142 93218.1
c_582_1142_i 582 582_1142 2.08965e-09
r_1142_1702_e 1142 1702 836.944
r_1142_1702_i 1142_1702 1702 4256.89
c_1142_1702_i 1142 1142_1702 4.67522e-10
r_1702_2262_e 1702 2262 836.944
r_1702_2262_i 1702_2262 2262 4256.89
c_1702_2262_i 1702 1702_2262 4.67522e-10
r_2262_2822_e 2262 2822 836.944
r_2262_2822_i 2262_2822 2822 4256.89
c_2262_2822_i 2262 2262_2822 4.67522e-10
r_2822_3382_e 2822 3382 13758.3
r_2822_3382_i 2822_3382 3382 95645.6
c_2822_3382_i 2822 2822_3382 9.36084e-12
r_23_583_e 23 583 13376.4
r_23_583_i 23_583 583 93218.1
c_23_583_i 23 23_583 2.08965e-09
r_583_1143_e 583 1143 13376.4
r_583_1143_i 583_1143 1143 93218.1
c_583_1143_i 583 583_1143 2.08965e-09
r_1143_1703_e 1143 1703 836.944
r_1143_1703_i 1143_1703 1703 4256.89
c_1143_1703_i 1143 1143_1703 4.67522e-10
r_1703_2263_e 1703 2263 836.944
r_1703_2263_i 1703_2263 2263 4256.89
c_1703_2263_i 1703 1703_2263 4.67522e-10
r_2263_2823_e 2263 2823 836.944
r_2263_2823_i 2263_2823 2823 4256.89
c_2263_2823_i 2263 2263_2823 4.67522e-10
r_2823_3383_e 2823 3383 13758.3
r_2823_3383_i 2823_3383 3383 95645.6
c_2823_3383_i 2823 2823_3383 9.36084e-12
r_24_584_e 24 584 13376.4
r_24_584_i 24_584 584 93218.1
c_24_584_i 24 24_584 2.08965e-09
r_584_1144_e 584 1144 13376.4
r_584_1144_i 584_1144 1144 93218.1
c_584_1144_i 584 584_1144 2.08965e-09
r_1144_1704_e 1144 1704 836.944
r_1144_1704_i 1144_1704 1704 4256.89
c_1144_1704_i 1144 1144_1704 4.67522e-10
r_1704_2264_e 1704 2264 836.944
r_1704_2264_i 1704_2264 2264 4256.89
c_1704_2264_i 1704 1704_2264 4.67522e-10
r_2264_2824_e 2264 2824 836.944
r_2264_2824_i 2264_2824 2824 4256.89
c_2264_2824_i 2264 2264_2824 4.67522e-10
r_2824_3384_e 2824 3384 13758.3
r_2824_3384_i 2824_3384 3384 95645.6
c_2824_3384_i 2824 2824_3384 9.36084e-12
r_25_585_e 25 585 13376.4
r_25_585_i 25_585 585 93218.1
c_25_585_i 25 25_585 2.08965e-09
r_585_1145_e 585 1145 13376.4
r_585_1145_i 585_1145 1145 93218.1
c_585_1145_i 585 585_1145 2.08965e-09
r_1145_1705_e 1145 1705 836.944
r_1145_1705_i 1145_1705 1705 4256.89
c_1145_1705_i 1145 1145_1705 4.67522e-10
r_1705_2265_e 1705 2265 836.944
r_1705_2265_i 1705_2265 2265 4256.89
c_1705_2265_i 1705 1705_2265 4.67522e-10
r_2265_2825_e 2265 2825 836.944
r_2265_2825_i 2265_2825 2825 4256.89
c_2265_2825_i 2265 2265_2825 4.67522e-10
r_2825_3385_e 2825 3385 13758.3
r_2825_3385_i 2825_3385 3385 95645.6
c_2825_3385_i 2825 2825_3385 9.36084e-12
r_26_586_e 26 586 13376.4
r_26_586_i 26_586 586 93218.1
c_26_586_i 26 26_586 2.08965e-09
r_586_1146_e 586 1146 13376.4
r_586_1146_i 586_1146 1146 93218.1
c_586_1146_i 586 586_1146 2.08965e-09
r_1146_1706_e 1146 1706 836.944
r_1146_1706_i 1146_1706 1706 4256.89
c_1146_1706_i 1146 1146_1706 4.67522e-10
r_1706_2266_e 1706 2266 836.944
r_1706_2266_i 1706_2266 2266 4256.89
c_1706_2266_i 1706 1706_2266 4.67522e-10
r_2266_2826_e 2266 2826 836.944
r_2266_2826_i 2266_2826 2826 4256.89
c_2266_2826_i 2266 2266_2826 4.67522e-10
r_2826_3386_e 2826 3386 13758.3
r_2826_3386_i 2826_3386 3386 95645.6
c_2826_3386_i 2826 2826_3386 9.36084e-12
r_27_587_e 27 587 13376.4
r_27_587_i 27_587 587 93218.1
c_27_587_i 27 27_587 2.08965e-09
r_587_1147_e 587 1147 13376.4
r_587_1147_i 587_1147 1147 93218.1
c_587_1147_i 587 587_1147 2.08965e-09
r_1147_1707_e 1147 1707 396.769
r_1147_1707_i 1147_1707 1707 1005.45
c_1147_1707_i 1147 1147_1707 1.65766e-10
r_1707_2267_e 1707 2267 836.944
r_1707_2267_i 1707_2267 2267 4256.89
c_1707_2267_i 1707 1707_2267 4.67522e-10
r_2267_2827_e 2267 2827 836.944
r_2267_2827_i 2267_2827 2827 4256.89
c_2267_2827_i 2267 2267_2827 4.67522e-10
r_2827_3387_e 2827 3387 13758.3
r_2827_3387_i 2827_3387 3387 95645.6
c_2827_3387_i 2827 2827_3387 9.36084e-12
r_28_588_e 28 588 13376.4
r_28_588_i 28_588 588 93218.1
c_28_588_i 28 28_588 2.08965e-09
r_588_1148_e 588 1148 13376.4
r_588_1148_i 588_1148 1148 93218.1
c_588_1148_i 588 588_1148 2.08965e-09
r_1148_1708_e 1148 1708 396.769
r_1148_1708_i 1148_1708 1708 1005.45
c_1148_1708_i 1148 1148_1708 1.65766e-10
r_1708_2268_e 1708 2268 836.944
r_1708_2268_i 1708_2268 2268 4256.89
c_1708_2268_i 1708 1708_2268 4.67522e-10
r_2268_2828_e 2268 2828 836.944
r_2268_2828_i 2268_2828 2828 4256.89
c_2268_2828_i 2268 2268_2828 4.67522e-10
r_2828_3388_e 2828 3388 13758.3
r_2828_3388_i 2828_3388 3388 95645.6
c_2828_3388_i 2828 2828_3388 9.36084e-12
r_29_589_e 29 589 13376.4
r_29_589_i 29_589 589 93218.1
c_29_589_i 29 29_589 2.08965e-09
r_589_1149_e 589 1149 13376.4
r_589_1149_i 589_1149 1149 93218.1
c_589_1149_i 589 589_1149 2.08965e-09
r_1149_1709_e 1149 1709 836.944
r_1149_1709_i 1149_1709 1709 4256.89
c_1149_1709_i 1149 1149_1709 4.67522e-10
r_1709_2269_e 1709 2269 836.944
r_1709_2269_i 1709_2269 2269 4256.89
c_1709_2269_i 1709 1709_2269 4.67522e-10
r_2269_2829_e 2269 2829 836.944
r_2269_2829_i 2269_2829 2829 4256.89
c_2269_2829_i 2269 2269_2829 4.67522e-10
r_2829_3389_e 2829 3389 13758.3
r_2829_3389_i 2829_3389 3389 95645.6
c_2829_3389_i 2829 2829_3389 9.36084e-12
r_30_590_e 30 590 13376.4
r_30_590_i 30_590 590 93218.1
c_30_590_i 30 30_590 2.08965e-09
r_590_1150_e 590 1150 13376.4
r_590_1150_i 590_1150 1150 93218.1
c_590_1150_i 590 590_1150 2.08965e-09
r_1150_1710_e 1150 1710 836.944
r_1150_1710_i 1150_1710 1710 4256.89
c_1150_1710_i 1150 1150_1710 4.67522e-10
r_1710_2270_e 1710 2270 836.944
r_1710_2270_i 1710_2270 2270 4256.89
c_1710_2270_i 1710 1710_2270 4.67522e-10
r_2270_2830_e 2270 2830 836.944
r_2270_2830_i 2270_2830 2830 4256.89
c_2270_2830_i 2270 2270_2830 4.67522e-10
r_2830_3390_e 2830 3390 13758.3
r_2830_3390_i 2830_3390 3390 95645.6
c_2830_3390_i 2830 2830_3390 9.36084e-12
r_31_591_e 31 591 13376.4
r_31_591_i 31_591 591 93218.1
c_31_591_i 31 31_591 2.08965e-09
r_591_1151_e 591 1151 13376.4
r_591_1151_i 591_1151 1151 93218.1
c_591_1151_i 591 591_1151 2.08965e-09
r_1151_1711_e 1151 1711 836.944
r_1151_1711_i 1151_1711 1711 4256.89
c_1151_1711_i 1151 1151_1711 4.67522e-10
r_1711_2271_e 1711 2271 836.944
r_1711_2271_i 1711_2271 2271 4256.89
c_1711_2271_i 1711 1711_2271 4.67522e-10
r_2271_2831_e 2271 2831 836.944
r_2271_2831_i 2271_2831 2831 4256.89
c_2271_2831_i 2271 2271_2831 4.67522e-10
r_2831_3391_e 2831 3391 13758.3
r_2831_3391_i 2831_3391 3391 95645.6
c_2831_3391_i 2831 2831_3391 9.36084e-12
r_32_592_e 32 592 13376.4
r_32_592_i 32_592 592 93218.1
c_32_592_i 32 32_592 2.08965e-09
r_592_1152_e 592 1152 13376.4
r_592_1152_i 592_1152 1152 93218.1
c_592_1152_i 592 592_1152 2.08965e-09
r_1152_1712_e 1152 1712 836.944
r_1152_1712_i 1152_1712 1712 4256.89
c_1152_1712_i 1152 1152_1712 4.67522e-10
r_1712_2272_e 1712 2272 836.944
r_1712_2272_i 1712_2272 2272 4256.89
c_1712_2272_i 1712 1712_2272 4.67522e-10
r_2272_2832_e 2272 2832 836.944
r_2272_2832_i 2272_2832 2832 4256.89
c_2272_2832_i 2272 2272_2832 4.67522e-10
r_2832_3392_e 2832 3392 13758.3
r_2832_3392_i 2832_3392 3392 95645.6
c_2832_3392_i 2832 2832_3392 9.36084e-12
r_33_593_e 33 593 13376.4
r_33_593_i 33_593 593 93218.1
c_33_593_i 33 33_593 2.08965e-09
r_593_1153_e 593 1153 13376.4
r_593_1153_i 593_1153 1153 93218.1
c_593_1153_i 593 593_1153 2.08965e-09
r_1153_1713_e 1153 1713 13376.4
r_1153_1713_i 1153_1713 1713 93218.1
c_1153_1713_i 1153 1153_1713 2.08965e-09
r_1713_2273_e 1713 2273 13376.4
r_1713_2273_i 1713_2273 2273 93218.1
c_1713_2273_i 1713 1713_2273 2.08965e-09
r_2273_2833_e 2273 2833 13376.4
r_2273_2833_i 2273_2833 2833 93218.1
c_2273_2833_i 2273 2273_2833 2.08965e-09
r_2833_3393_e 2833 3393 13376.4
r_2833_3393_i 2833_3393 3393 93218.1
c_2833_3393_i 2833 2833_3393 2.08965e-09
r_34_594_e 34 594 13376.4
r_34_594_i 34_594 594 93218.1
c_34_594_i 34 34_594 2.08965e-09
r_594_1154_e 594 1154 13376.4
r_594_1154_i 594_1154 1154 93218.1
c_594_1154_i 594 594_1154 2.08965e-09
r_1154_1714_e 1154 1714 13376.4
r_1154_1714_i 1154_1714 1714 93218.1
c_1154_1714_i 1154 1154_1714 2.08965e-09
r_1714_2274_e 1714 2274 13376.4
r_1714_2274_i 1714_2274 2274 93218.1
c_1714_2274_i 1714 1714_2274 2.08965e-09
r_2274_2834_e 2274 2834 13376.4
r_2274_2834_i 2274_2834 2834 93218.1
c_2274_2834_i 2274 2274_2834 2.08965e-09
r_2834_3394_e 2834 3394 13376.4
r_2834_3394_i 2834_3394 3394 93218.1
c_2834_3394_i 2834 2834_3394 2.08965e-09
r_35_595_e 35 595 13376.4
r_35_595_i 35_595 595 93218.1
c_35_595_i 35 35_595 2.08965e-09
r_595_1155_e 595 1155 13376.4
r_595_1155_i 595_1155 1155 93218.1
c_595_1155_i 595 595_1155 2.08965e-09
r_1155_1715_e 1155 1715 836.944
r_1155_1715_i 1155_1715 1715 4256.89
c_1155_1715_i 1155 1155_1715 4.67522e-10
r_1715_2275_e 1715 2275 836.944
r_1715_2275_i 1715_2275 2275 4256.89
c_1715_2275_i 1715 1715_2275 4.67522e-10
r_2275_2835_e 2275 2835 836.944
r_2275_2835_i 2275_2835 2835 4256.89
c_2275_2835_i 2275 2275_2835 4.67522e-10
r_2835_3395_e 2835 3395 836.944
r_2835_3395_i 2835_3395 3395 4256.89
c_2835_3395_i 2835 2835_3395 4.67522e-10
r_36_596_e 36 596 13376.4
r_36_596_i 36_596 596 93218.1
c_36_596_i 36 36_596 2.08965e-09
r_596_1156_e 596 1156 13376.4
r_596_1156_i 596_1156 1156 93218.1
c_596_1156_i 596 596_1156 2.08965e-09
r_1156_1716_e 1156 1716 836.944
r_1156_1716_i 1156_1716 1716 4256.89
c_1156_1716_i 1156 1156_1716 4.67522e-10
r_1716_2276_e 1716 2276 836.944
r_1716_2276_i 1716_2276 2276 4256.89
c_1716_2276_i 1716 1716_2276 4.67522e-10
r_2276_2836_e 2276 2836 836.944
r_2276_2836_i 2276_2836 2836 4256.89
c_2276_2836_i 2276 2276_2836 4.67522e-10
r_2836_3396_e 2836 3396 13758.3
r_2836_3396_i 2836_3396 3396 95645.6
c_2836_3396_i 2836 2836_3396 9.36084e-12
r_37_597_e 37 597 13376.4
r_37_597_i 37_597 597 93218.1
c_37_597_i 37 37_597 2.08965e-09
r_597_1157_e 597 1157 13376.4
r_597_1157_i 597_1157 1157 93218.1
c_597_1157_i 597 597_1157 2.08965e-09
r_1157_1717_e 1157 1717 836.944
r_1157_1717_i 1157_1717 1717 4256.89
c_1157_1717_i 1157 1157_1717 4.67522e-10
r_1717_2277_e 1717 2277 836.944
r_1717_2277_i 1717_2277 2277 4256.89
c_1717_2277_i 1717 1717_2277 4.67522e-10
r_2277_2837_e 2277 2837 836.944
r_2277_2837_i 2277_2837 2837 4256.89
c_2277_2837_i 2277 2277_2837 4.67522e-10
r_2837_3397_e 2837 3397 13758.3
r_2837_3397_i 2837_3397 3397 95645.6
c_2837_3397_i 2837 2837_3397 9.36084e-12
r_38_598_e 38 598 13376.4
r_38_598_i 38_598 598 93218.1
c_38_598_i 38 38_598 2.08965e-09
r_598_1158_e 598 1158 13376.4
r_598_1158_i 598_1158 1158 93218.1
c_598_1158_i 598 598_1158 2.08965e-09
r_1158_1718_e 1158 1718 836.944
r_1158_1718_i 1158_1718 1718 4256.89
c_1158_1718_i 1158 1158_1718 4.67522e-10
r_1718_2278_e 1718 2278 836.944
r_1718_2278_i 1718_2278 2278 4256.89
c_1718_2278_i 1718 1718_2278 4.67522e-10
r_2278_2838_e 2278 2838 836.944
r_2278_2838_i 2278_2838 2838 4256.89
c_2278_2838_i 2278 2278_2838 4.67522e-10
r_2838_3398_e 2838 3398 13758.3
r_2838_3398_i 2838_3398 3398 95645.6
c_2838_3398_i 2838 2838_3398 9.36084e-12
r_39_599_e 39 599 13376.4
r_39_599_i 39_599 599 93218.1
c_39_599_i 39 39_599 2.08965e-09
r_599_1159_e 599 1159 13376.4
r_599_1159_i 599_1159 1159 93218.1
c_599_1159_i 599 599_1159 2.08965e-09
r_1159_1719_e 1159 1719 836.944
r_1159_1719_i 1159_1719 1719 4256.89
c_1159_1719_i 1159 1159_1719 4.67522e-10
r_1719_2279_e 1719 2279 836.944
r_1719_2279_i 1719_2279 2279 4256.89
c_1719_2279_i 1719 1719_2279 4.67522e-10
r_2279_2839_e 2279 2839 836.944
r_2279_2839_i 2279_2839 2839 4256.89
c_2279_2839_i 2279 2279_2839 4.67522e-10
r_2839_3399_e 2839 3399 13758.3
r_2839_3399_i 2839_3399 3399 95645.6
c_2839_3399_i 2839 2839_3399 9.36084e-12
r_40_600_e 40 600 13376.4
r_40_600_i 40_600 600 93218.1
c_40_600_i 40 40_600 2.08965e-09
r_600_1160_e 600 1160 13376.4
r_600_1160_i 600_1160 1160 93218.1
c_600_1160_i 600 600_1160 2.08965e-09
r_1160_1720_e 1160 1720 836.944
r_1160_1720_i 1160_1720 1720 4256.89
c_1160_1720_i 1160 1160_1720 4.67522e-10
r_1720_2280_e 1720 2280 836.944
r_1720_2280_i 1720_2280 2280 4256.89
c_1720_2280_i 1720 1720_2280 4.67522e-10
r_2280_2840_e 2280 2840 836.944
r_2280_2840_i 2280_2840 2840 4256.89
c_2280_2840_i 2280 2280_2840 4.67522e-10
r_2840_3400_e 2840 3400 13758.3
r_2840_3400_i 2840_3400 3400 95645.6
c_2840_3400_i 2840 2840_3400 9.36084e-12
r_41_601_e 41 601 13376.4
r_41_601_i 41_601 601 93218.1
c_41_601_i 41 41_601 2.08965e-09
r_601_1161_e 601 1161 13376.4
r_601_1161_i 601_1161 1161 93218.1
c_601_1161_i 601 601_1161 2.08965e-09
r_1161_1721_e 1161 1721 836.944
r_1161_1721_i 1161_1721 1721 4256.89
c_1161_1721_i 1161 1161_1721 4.67522e-10
r_1721_2281_e 1721 2281 836.944
r_1721_2281_i 1721_2281 2281 4256.89
c_1721_2281_i 1721 1721_2281 4.67522e-10
r_2281_2841_e 2281 2841 836.944
r_2281_2841_i 2281_2841 2841 4256.89
c_2281_2841_i 2281 2281_2841 4.67522e-10
r_2841_3401_e 2841 3401 13758.3
r_2841_3401_i 2841_3401 3401 95645.6
c_2841_3401_i 2841 2841_3401 9.36084e-12
r_42_602_e 42 602 13376.4
r_42_602_i 42_602 602 93218.1
c_42_602_i 42 42_602 2.08965e-09
r_602_1162_e 602 1162 13376.4
r_602_1162_i 602_1162 1162 93218.1
c_602_1162_i 602 602_1162 2.08965e-09
r_1162_1722_e 1162 1722 836.944
r_1162_1722_i 1162_1722 1722 4256.89
c_1162_1722_i 1162 1162_1722 4.67522e-10
r_1722_2282_e 1722 2282 836.944
r_1722_2282_i 1722_2282 2282 4256.89
c_1722_2282_i 1722 1722_2282 4.67522e-10
r_2282_2842_e 2282 2842 836.944
r_2282_2842_i 2282_2842 2842 4256.89
c_2282_2842_i 2282 2282_2842 4.67522e-10
r_2842_3402_e 2842 3402 13758.3
r_2842_3402_i 2842_3402 3402 95645.6
c_2842_3402_i 2842 2842_3402 9.36084e-12
r_43_603_e 43 603 13376.4
r_43_603_i 43_603 603 93218.1
c_43_603_i 43 43_603 2.08965e-09
r_603_1163_e 603 1163 13376.4
r_603_1163_i 603_1163 1163 93218.1
c_603_1163_i 603 603_1163 2.08965e-09
r_1163_1723_e 1163 1723 396.76
r_1163_1723_i 1163_1723 1723 1005.43
c_1163_1723_i 1163 1163_1723 1.6577e-10
r_1723_2283_e 1723 2283 836.944
r_1723_2283_i 1723_2283 2283 4256.89
c_1723_2283_i 1723 1723_2283 4.67522e-10
r_2283_2843_e 2283 2843 836.944
r_2283_2843_i 2283_2843 2843 4256.89
c_2283_2843_i 2283 2283_2843 4.67522e-10
r_2843_3403_e 2843 3403 13758.3
r_2843_3403_i 2843_3403 3403 95645.6
c_2843_3403_i 2843 2843_3403 9.36084e-12
r_44_604_e 44 604 13376.4
r_44_604_i 44_604 604 93218.1
c_44_604_i 44 44_604 2.08965e-09
r_604_1164_e 604 1164 13376.4
r_604_1164_i 604_1164 1164 93218.1
c_604_1164_i 604 604_1164 2.08965e-09
r_1164_1724_e 1164 1724 396.76
r_1164_1724_i 1164_1724 1724 1005.43
c_1164_1724_i 1164 1164_1724 1.6577e-10
r_1724_2284_e 1724 2284 836.944
r_1724_2284_i 1724_2284 2284 4256.89
c_1724_2284_i 1724 1724_2284 4.67522e-10
r_2284_2844_e 2284 2844 836.944
r_2284_2844_i 2284_2844 2844 4256.89
c_2284_2844_i 2284 2284_2844 4.67522e-10
r_2844_3404_e 2844 3404 13758.3
r_2844_3404_i 2844_3404 3404 95645.6
c_2844_3404_i 2844 2844_3404 9.36084e-12
r_45_605_e 45 605 13376.4
r_45_605_i 45_605 605 93218.1
c_45_605_i 45 45_605 2.08965e-09
r_605_1165_e 605 1165 13376.4
r_605_1165_i 605_1165 1165 93218.1
c_605_1165_i 605 605_1165 2.08965e-09
r_1165_1725_e 1165 1725 836.944
r_1165_1725_i 1165_1725 1725 4256.89
c_1165_1725_i 1165 1165_1725 4.67522e-10
r_1725_2285_e 1725 2285 836.944
r_1725_2285_i 1725_2285 2285 4256.89
c_1725_2285_i 1725 1725_2285 4.67522e-10
r_2285_2845_e 2285 2845 836.944
r_2285_2845_i 2285_2845 2845 4256.89
c_2285_2845_i 2285 2285_2845 4.67522e-10
r_2845_3405_e 2845 3405 13758.3
r_2845_3405_i 2845_3405 3405 95645.6
c_2845_3405_i 2845 2845_3405 9.36084e-12
r_46_606_e 46 606 13376.4
r_46_606_i 46_606 606 93218.1
c_46_606_i 46 46_606 2.08965e-09
r_606_1166_e 606 1166 13376.4
r_606_1166_i 606_1166 1166 93218.1
c_606_1166_i 606 606_1166 2.08965e-09
r_1166_1726_e 1166 1726 836.944
r_1166_1726_i 1166_1726 1726 4256.89
c_1166_1726_i 1166 1166_1726 4.67522e-10
r_1726_2286_e 1726 2286 836.944
r_1726_2286_i 1726_2286 2286 4256.89
c_1726_2286_i 1726 1726_2286 4.67522e-10
r_2286_2846_e 2286 2846 836.944
r_2286_2846_i 2286_2846 2846 4256.89
c_2286_2846_i 2286 2286_2846 4.67522e-10
r_2846_3406_e 2846 3406 13758.3
r_2846_3406_i 2846_3406 3406 95645.6
c_2846_3406_i 2846 2846_3406 9.36084e-12
r_47_607_e 47 607 13376.4
r_47_607_i 47_607 607 93218.1
c_47_607_i 47 47_607 2.08965e-09
r_607_1167_e 607 1167 13376.4
r_607_1167_i 607_1167 1167 93218.1
c_607_1167_i 607 607_1167 2.08965e-09
r_1167_1727_e 1167 1727 836.944
r_1167_1727_i 1167_1727 1727 4256.89
c_1167_1727_i 1167 1167_1727 4.67522e-10
r_1727_2287_e 1727 2287 836.944
r_1727_2287_i 1727_2287 2287 4256.89
c_1727_2287_i 1727 1727_2287 4.67522e-10
r_2287_2847_e 2287 2847 836.944
r_2287_2847_i 2287_2847 2847 4256.89
c_2287_2847_i 2287 2287_2847 4.67522e-10
r_2847_3407_e 2847 3407 13758.3
r_2847_3407_i 2847_3407 3407 95645.6
c_2847_3407_i 2847 2847_3407 9.36084e-12
r_48_608_e 48 608 13376.4
r_48_608_i 48_608 608 93218.1
c_48_608_i 48 48_608 2.08965e-09
r_608_1168_e 608 1168 13376.4
r_608_1168_i 608_1168 1168 93218.1
c_608_1168_i 608 608_1168 2.08965e-09
r_1168_1728_e 1168 1728 836.944
r_1168_1728_i 1168_1728 1728 4256.89
c_1168_1728_i 1168 1168_1728 4.67522e-10
r_1728_2288_e 1728 2288 836.944
r_1728_2288_i 1728_2288 2288 4256.89
c_1728_2288_i 1728 1728_2288 4.67522e-10
r_2288_2848_e 2288 2848 836.944
r_2288_2848_i 2288_2848 2848 4256.89
c_2288_2848_i 2288 2288_2848 4.67522e-10
r_2848_3408_e 2848 3408 13758.3
r_2848_3408_i 2848_3408 3408 95645.6
c_2848_3408_i 2848 2848_3408 9.36084e-12
r_49_609_e 49 609 13376.4
r_49_609_i 49_609 609 93218.1
c_49_609_i 49 49_609 2.08965e-09
r_609_1169_e 609 1169 13376.4
r_609_1169_i 609_1169 1169 93218.1
c_609_1169_i 609 609_1169 2.08965e-09
r_1169_1729_e 1169 1729 13376.4
r_1169_1729_i 1169_1729 1729 93218.1
c_1169_1729_i 1169 1169_1729 2.08965e-09
r_1729_2289_e 1729 2289 13376.4
r_1729_2289_i 1729_2289 2289 93218.1
c_1729_2289_i 1729 1729_2289 2.08965e-09
r_2289_2849_e 2289 2849 13376.4
r_2289_2849_i 2289_2849 2849 93218.1
c_2289_2849_i 2289 2289_2849 2.08965e-09
r_2849_3409_e 2849 3409 13376.4
r_2849_3409_i 2849_3409 3409 93218.1
c_2849_3409_i 2849 2849_3409 2.08965e-09
r_50_610_e 50 610 13376.4
r_50_610_i 50_610 610 93218.1
c_50_610_i 50 50_610 2.08965e-09
r_610_1170_e 610 1170 13376.4
r_610_1170_i 610_1170 1170 93218.1
c_610_1170_i 610 610_1170 2.08965e-09
r_1170_1730_e 1170 1730 13376.4
r_1170_1730_i 1170_1730 1730 93218.1
c_1170_1730_i 1170 1170_1730 2.08965e-09
r_1730_2290_e 1730 2290 13376.4
r_1730_2290_i 1730_2290 2290 93218.1
c_1730_2290_i 1730 1730_2290 2.08965e-09
r_2290_2850_e 2290 2850 13376.4
r_2290_2850_i 2290_2850 2850 93218.1
c_2290_2850_i 2290 2290_2850 2.08965e-09
r_2850_3410_e 2850 3410 13376.4
r_2850_3410_i 2850_3410 3410 93218.1
c_2850_3410_i 2850 2850_3410 2.08965e-09
r_51_611_e 51 611 13376.4
r_51_611_i 51_611 611 93218.1
c_51_611_i 51 51_611 2.08965e-09
r_611_1171_e 611 1171 13376.4
r_611_1171_i 611_1171 1171 93218.1
c_611_1171_i 611 611_1171 2.08965e-09
r_1171_1731_e 1171 1731 836.944
r_1171_1731_i 1171_1731 1731 4256.89
c_1171_1731_i 1171 1171_1731 4.67522e-10
r_1731_2291_e 1731 2291 836.944
r_1731_2291_i 1731_2291 2291 4256.89
c_1731_2291_i 1731 1731_2291 4.67522e-10
r_2291_2851_e 2291 2851 836.944
r_2291_2851_i 2291_2851 2851 4256.89
c_2291_2851_i 2291 2291_2851 4.67522e-10
r_2851_3411_e 2851 3411 836.944
r_2851_3411_i 2851_3411 3411 4256.89
c_2851_3411_i 2851 2851_3411 4.67522e-10
r_52_612_e 52 612 13376.4
r_52_612_i 52_612 612 93218.1
c_52_612_i 52 52_612 2.08965e-09
r_612_1172_e 612 1172 13376.4
r_612_1172_i 612_1172 1172 93218.1
c_612_1172_i 612 612_1172 2.08965e-09
r_1172_1732_e 1172 1732 836.944
r_1172_1732_i 1172_1732 1732 4256.89
c_1172_1732_i 1172 1172_1732 4.67522e-10
r_1732_2292_e 1732 2292 836.944
r_1732_2292_i 1732_2292 2292 4256.89
c_1732_2292_i 1732 1732_2292 4.67522e-10
r_2292_2852_e 2292 2852 836.944
r_2292_2852_i 2292_2852 2852 4256.89
c_2292_2852_i 2292 2292_2852 4.67522e-10
r_2852_3412_e 2852 3412 13758.3
r_2852_3412_i 2852_3412 3412 95645.6
c_2852_3412_i 2852 2852_3412 9.36084e-12
r_53_613_e 53 613 13376.4
r_53_613_i 53_613 613 93218.1
c_53_613_i 53 53_613 2.08965e-09
r_613_1173_e 613 1173 13376.4
r_613_1173_i 613_1173 1173 93218.1
c_613_1173_i 613 613_1173 2.08965e-09
r_1173_1733_e 1173 1733 836.944
r_1173_1733_i 1173_1733 1733 4256.89
c_1173_1733_i 1173 1173_1733 4.67522e-10
r_1733_2293_e 1733 2293 836.944
r_1733_2293_i 1733_2293 2293 4256.89
c_1733_2293_i 1733 1733_2293 4.67522e-10
r_2293_2853_e 2293 2853 836.944
r_2293_2853_i 2293_2853 2853 4256.89
c_2293_2853_i 2293 2293_2853 4.67522e-10
r_2853_3413_e 2853 3413 13758.3
r_2853_3413_i 2853_3413 3413 95645.6
c_2853_3413_i 2853 2853_3413 9.36084e-12
r_54_614_e 54 614 13376.4
r_54_614_i 54_614 614 93218.1
c_54_614_i 54 54_614 2.08965e-09
r_614_1174_e 614 1174 13376.4
r_614_1174_i 614_1174 1174 93218.1
c_614_1174_i 614 614_1174 2.08965e-09
r_1174_1734_e 1174 1734 836.944
r_1174_1734_i 1174_1734 1734 4256.89
c_1174_1734_i 1174 1174_1734 4.67522e-10
r_1734_2294_e 1734 2294 836.944
r_1734_2294_i 1734_2294 2294 4256.89
c_1734_2294_i 1734 1734_2294 4.67522e-10
r_2294_2854_e 2294 2854 836.944
r_2294_2854_i 2294_2854 2854 4256.89
c_2294_2854_i 2294 2294_2854 4.67522e-10
r_2854_3414_e 2854 3414 13758.3
r_2854_3414_i 2854_3414 3414 95645.6
c_2854_3414_i 2854 2854_3414 9.36084e-12
r_55_615_e 55 615 13376.4
r_55_615_i 55_615 615 93218.1
c_55_615_i 55 55_615 2.08965e-09
r_615_1175_e 615 1175 13376.4
r_615_1175_i 615_1175 1175 93218.1
c_615_1175_i 615 615_1175 2.08965e-09
r_1175_1735_e 1175 1735 836.944
r_1175_1735_i 1175_1735 1735 4256.89
c_1175_1735_i 1175 1175_1735 4.67522e-10
r_1735_2295_e 1735 2295 836.944
r_1735_2295_i 1735_2295 2295 4256.89
c_1735_2295_i 1735 1735_2295 4.67522e-10
r_2295_2855_e 2295 2855 836.944
r_2295_2855_i 2295_2855 2855 4256.89
c_2295_2855_i 2295 2295_2855 4.67522e-10
r_2855_3415_e 2855 3415 13758.3
r_2855_3415_i 2855_3415 3415 95645.6
c_2855_3415_i 2855 2855_3415 9.36084e-12
r_56_616_e 56 616 13376.4
r_56_616_i 56_616 616 93218.1
c_56_616_i 56 56_616 2.08965e-09
r_616_1176_e 616 1176 13376.4
r_616_1176_i 616_1176 1176 93218.1
c_616_1176_i 616 616_1176 2.08965e-09
r_1176_1736_e 1176 1736 836.944
r_1176_1736_i 1176_1736 1736 4256.89
c_1176_1736_i 1176 1176_1736 4.67522e-10
r_1736_2296_e 1736 2296 836.944
r_1736_2296_i 1736_2296 2296 4256.89
c_1736_2296_i 1736 1736_2296 4.67522e-10
r_2296_2856_e 2296 2856 836.944
r_2296_2856_i 2296_2856 2856 4256.89
c_2296_2856_i 2296 2296_2856 4.67522e-10
r_2856_3416_e 2856 3416 13758.3
r_2856_3416_i 2856_3416 3416 95645.6
c_2856_3416_i 2856 2856_3416 9.36084e-12
r_57_617_e 57 617 13376.4
r_57_617_i 57_617 617 93218.1
c_57_617_i 57 57_617 2.08965e-09
r_617_1177_e 617 1177 13376.4
r_617_1177_i 617_1177 1177 93218.1
c_617_1177_i 617 617_1177 2.08965e-09
r_1177_1737_e 1177 1737 836.944
r_1177_1737_i 1177_1737 1737 4256.89
c_1177_1737_i 1177 1177_1737 4.67522e-10
r_1737_2297_e 1737 2297 836.944
r_1737_2297_i 1737_2297 2297 4256.89
c_1737_2297_i 1737 1737_2297 4.67522e-10
r_2297_2857_e 2297 2857 836.944
r_2297_2857_i 2297_2857 2857 4256.89
c_2297_2857_i 2297 2297_2857 4.67522e-10
r_2857_3417_e 2857 3417 13758.3
r_2857_3417_i 2857_3417 3417 95645.6
c_2857_3417_i 2857 2857_3417 9.36084e-12
r_58_618_e 58 618 13376.4
r_58_618_i 58_618 618 93218.1
c_58_618_i 58 58_618 2.08965e-09
r_618_1178_e 618 1178 13376.4
r_618_1178_i 618_1178 1178 93218.1
c_618_1178_i 618 618_1178 2.08965e-09
r_1178_1738_e 1178 1738 836.944
r_1178_1738_i 1178_1738 1738 4256.89
c_1178_1738_i 1178 1178_1738 4.67522e-10
r_1738_2298_e 1738 2298 836.944
r_1738_2298_i 1738_2298 2298 4256.89
c_1738_2298_i 1738 1738_2298 4.67522e-10
r_2298_2858_e 2298 2858 836.944
r_2298_2858_i 2298_2858 2858 4256.89
c_2298_2858_i 2298 2298_2858 4.67522e-10
r_2858_3418_e 2858 3418 13758.3
r_2858_3418_i 2858_3418 3418 95645.6
c_2858_3418_i 2858 2858_3418 9.36084e-12
r_59_619_e 59 619 13376.4
r_59_619_i 59_619 619 93218.1
c_59_619_i 59 59_619 2.08965e-09
r_619_1179_e 619 1179 13376.4
r_619_1179_i 619_1179 1179 93218.1
c_619_1179_i 619 619_1179 2.08965e-09
r_1179_1739_e 1179 1739 396.751
r_1179_1739_i 1179_1739 1739 1005.4
c_1179_1739_i 1179 1179_1739 1.65774e-10
r_1739_2299_e 1739 2299 836.944
r_1739_2299_i 1739_2299 2299 4256.89
c_1739_2299_i 1739 1739_2299 4.67522e-10
r_2299_2859_e 2299 2859 836.944
r_2299_2859_i 2299_2859 2859 4256.89
c_2299_2859_i 2299 2299_2859 4.67522e-10
r_2859_3419_e 2859 3419 13758.3
r_2859_3419_i 2859_3419 3419 95645.6
c_2859_3419_i 2859 2859_3419 9.36084e-12
r_60_620_e 60 620 13376.4
r_60_620_i 60_620 620 93218.1
c_60_620_i 60 60_620 2.08965e-09
r_620_1180_e 620 1180 13376.4
r_620_1180_i 620_1180 1180 93218.1
c_620_1180_i 620 620_1180 2.08965e-09
r_1180_1740_e 1180 1740 396.751
r_1180_1740_i 1180_1740 1740 1005.4
c_1180_1740_i 1180 1180_1740 1.65774e-10
r_1740_2300_e 1740 2300 836.944
r_1740_2300_i 1740_2300 2300 4256.89
c_1740_2300_i 1740 1740_2300 4.67522e-10
r_2300_2860_e 2300 2860 836.944
r_2300_2860_i 2300_2860 2860 4256.89
c_2300_2860_i 2300 2300_2860 4.67522e-10
r_2860_3420_e 2860 3420 13758.3
r_2860_3420_i 2860_3420 3420 95645.6
c_2860_3420_i 2860 2860_3420 9.36084e-12
r_61_621_e 61 621 13376.4
r_61_621_i 61_621 621 93218.1
c_61_621_i 61 61_621 2.08965e-09
r_621_1181_e 621 1181 13376.4
r_621_1181_i 621_1181 1181 93218.1
c_621_1181_i 621 621_1181 2.08965e-09
r_1181_1741_e 1181 1741 836.944
r_1181_1741_i 1181_1741 1741 4256.89
c_1181_1741_i 1181 1181_1741 4.67522e-10
r_1741_2301_e 1741 2301 836.944
r_1741_2301_i 1741_2301 2301 4256.89
c_1741_2301_i 1741 1741_2301 4.67522e-10
r_2301_2861_e 2301 2861 836.944
r_2301_2861_i 2301_2861 2861 4256.89
c_2301_2861_i 2301 2301_2861 4.67522e-10
r_2861_3421_e 2861 3421 13758.3
r_2861_3421_i 2861_3421 3421 95645.6
c_2861_3421_i 2861 2861_3421 9.36084e-12
r_62_622_e 62 622 13376.4
r_62_622_i 62_622 622 93218.1
c_62_622_i 62 62_622 2.08965e-09
r_622_1182_e 622 1182 13376.4
r_622_1182_i 622_1182 1182 93218.1
c_622_1182_i 622 622_1182 2.08965e-09
r_1182_1742_e 1182 1742 836.944
r_1182_1742_i 1182_1742 1742 4256.89
c_1182_1742_i 1182 1182_1742 4.67522e-10
r_1742_2302_e 1742 2302 836.944
r_1742_2302_i 1742_2302 2302 4256.89
c_1742_2302_i 1742 1742_2302 4.67522e-10
r_2302_2862_e 2302 2862 836.944
r_2302_2862_i 2302_2862 2862 4256.89
c_2302_2862_i 2302 2302_2862 4.67522e-10
r_2862_3422_e 2862 3422 13758.3
r_2862_3422_i 2862_3422 3422 95645.6
c_2862_3422_i 2862 2862_3422 9.36084e-12
r_63_623_e 63 623 13376.4
r_63_623_i 63_623 623 93218.1
c_63_623_i 63 63_623 2.08965e-09
r_623_1183_e 623 1183 13376.4
r_623_1183_i 623_1183 1183 93218.1
c_623_1183_i 623 623_1183 2.08965e-09
r_1183_1743_e 1183 1743 836.944
r_1183_1743_i 1183_1743 1743 4256.89
c_1183_1743_i 1183 1183_1743 4.67522e-10
r_1743_2303_e 1743 2303 836.944
r_1743_2303_i 1743_2303 2303 4256.89
c_1743_2303_i 1743 1743_2303 4.67522e-10
r_2303_2863_e 2303 2863 836.944
r_2303_2863_i 2303_2863 2863 4256.89
c_2303_2863_i 2303 2303_2863 4.67522e-10
r_2863_3423_e 2863 3423 13758.3
r_2863_3423_i 2863_3423 3423 95645.6
c_2863_3423_i 2863 2863_3423 9.36084e-12
r_64_624_e 64 624 13376.4
r_64_624_i 64_624 624 93218.1
c_64_624_i 64 64_624 2.08965e-09
r_624_1184_e 624 1184 13376.4
r_624_1184_i 624_1184 1184 93218.1
c_624_1184_i 624 624_1184 2.08965e-09
r_1184_1744_e 1184 1744 836.944
r_1184_1744_i 1184_1744 1744 4256.89
c_1184_1744_i 1184 1184_1744 4.67522e-10
r_1744_2304_e 1744 2304 836.944
r_1744_2304_i 1744_2304 2304 4256.89
c_1744_2304_i 1744 1744_2304 4.67522e-10
r_2304_2864_e 2304 2864 836.944
r_2304_2864_i 2304_2864 2864 4256.89
c_2304_2864_i 2304 2304_2864 4.67522e-10
r_2864_3424_e 2864 3424 13758.3
r_2864_3424_i 2864_3424 3424 95645.6
c_2864_3424_i 2864 2864_3424 9.36084e-12
r_65_625_e 65 625 13376.4
r_65_625_i 65_625 625 93218.1
c_65_625_i 65 65_625 2.08965e-09
r_625_1185_e 625 1185 13376.4
r_625_1185_i 625_1185 1185 93218.1
c_625_1185_i 625 625_1185 2.08965e-09
r_1185_1745_e 1185 1745 13376.4
r_1185_1745_i 1185_1745 1745 93218.1
c_1185_1745_i 1185 1185_1745 2.08965e-09
r_1745_2305_e 1745 2305 13376.4
r_1745_2305_i 1745_2305 2305 93218.1
c_1745_2305_i 1745 1745_2305 2.08965e-09
r_2305_2865_e 2305 2865 13376.4
r_2305_2865_i 2305_2865 2865 93218.1
c_2305_2865_i 2305 2305_2865 2.08965e-09
r_2865_3425_e 2865 3425 13376.4
r_2865_3425_i 2865_3425 3425 93218.1
c_2865_3425_i 2865 2865_3425 2.08965e-09
r_66_626_e 66 626 13376.4
r_66_626_i 66_626 626 93218.1
c_66_626_i 66 66_626 2.08965e-09
r_626_1186_e 626 1186 13376.4
r_626_1186_i 626_1186 1186 93218.1
c_626_1186_i 626 626_1186 2.08965e-09
r_1186_1746_e 1186 1746 13376.4
r_1186_1746_i 1186_1746 1746 93218.1
c_1186_1746_i 1186 1186_1746 2.08965e-09
r_1746_2306_e 1746 2306 13376.4
r_1746_2306_i 1746_2306 2306 93218.1
c_1746_2306_i 1746 1746_2306 2.08965e-09
r_2306_2866_e 2306 2866 13376.4
r_2306_2866_i 2306_2866 2866 93218.1
c_2306_2866_i 2306 2306_2866 2.08965e-09
r_2866_3426_e 2866 3426 13376.4
r_2866_3426_i 2866_3426 3426 93218.1
c_2866_3426_i 2866 2866_3426 2.08965e-09
r_67_627_e 67 627 13376.4
r_67_627_i 67_627 627 93218.1
c_67_627_i 67 67_627 2.08965e-09
r_627_1187_e 627 1187 13376.4
r_627_1187_i 627_1187 1187 93218.1
c_627_1187_i 627 627_1187 2.08965e-09
r_1187_1747_e 1187 1747 836.944
r_1187_1747_i 1187_1747 1747 4256.89
c_1187_1747_i 1187 1187_1747 4.67522e-10
r_1747_2307_e 1747 2307 836.944
r_1747_2307_i 1747_2307 2307 4256.89
c_1747_2307_i 1747 1747_2307 4.67522e-10
r_2307_2867_e 2307 2867 836.944
r_2307_2867_i 2307_2867 2867 4256.89
c_2307_2867_i 2307 2307_2867 4.67522e-10
r_2867_3427_e 2867 3427 836.944
r_2867_3427_i 2867_3427 3427 4256.89
c_2867_3427_i 2867 2867_3427 4.67522e-10
r_68_628_e 68 628 13376.4
r_68_628_i 68_628 628 93218.1
c_68_628_i 68 68_628 2.08965e-09
r_628_1188_e 628 1188 13376.4
r_628_1188_i 628_1188 1188 93218.1
c_628_1188_i 628 628_1188 2.08965e-09
r_1188_1748_e 1188 1748 836.944
r_1188_1748_i 1188_1748 1748 4256.89
c_1188_1748_i 1188 1188_1748 4.67522e-10
r_1748_2308_e 1748 2308 836.944
r_1748_2308_i 1748_2308 2308 4256.89
c_1748_2308_i 1748 1748_2308 4.67522e-10
r_2308_2868_e 2308 2868 836.944
r_2308_2868_i 2308_2868 2868 4256.89
c_2308_2868_i 2308 2308_2868 4.67522e-10
r_2868_3428_e 2868 3428 13758.3
r_2868_3428_i 2868_3428 3428 95645.6
c_2868_3428_i 2868 2868_3428 9.36084e-12
r_69_629_e 69 629 13376.4
r_69_629_i 69_629 629 93218.1
c_69_629_i 69 69_629 2.08965e-09
r_629_1189_e 629 1189 13376.4
r_629_1189_i 629_1189 1189 93218.1
c_629_1189_i 629 629_1189 2.08965e-09
r_1189_1749_e 1189 1749 836.944
r_1189_1749_i 1189_1749 1749 4256.89
c_1189_1749_i 1189 1189_1749 4.67522e-10
r_1749_2309_e 1749 2309 836.944
r_1749_2309_i 1749_2309 2309 4256.89
c_1749_2309_i 1749 1749_2309 4.67522e-10
r_2309_2869_e 2309 2869 836.944
r_2309_2869_i 2309_2869 2869 4256.89
c_2309_2869_i 2309 2309_2869 4.67522e-10
r_2869_3429_e 2869 3429 13758.3
r_2869_3429_i 2869_3429 3429 95645.6
c_2869_3429_i 2869 2869_3429 9.36084e-12
r_70_630_e 70 630 13376.4
r_70_630_i 70_630 630 93218.1
c_70_630_i 70 70_630 2.08965e-09
r_630_1190_e 630 1190 13376.4
r_630_1190_i 630_1190 1190 93218.1
c_630_1190_i 630 630_1190 2.08965e-09
r_1190_1750_e 1190 1750 836.944
r_1190_1750_i 1190_1750 1750 4256.89
c_1190_1750_i 1190 1190_1750 4.67522e-10
r_1750_2310_e 1750 2310 836.944
r_1750_2310_i 1750_2310 2310 4256.89
c_1750_2310_i 1750 1750_2310 4.67522e-10
r_2310_2870_e 2310 2870 836.944
r_2310_2870_i 2310_2870 2870 4256.89
c_2310_2870_i 2310 2310_2870 4.67522e-10
r_2870_3430_e 2870 3430 13758.3
r_2870_3430_i 2870_3430 3430 95645.6
c_2870_3430_i 2870 2870_3430 9.36084e-12
r_71_631_e 71 631 13376.4
r_71_631_i 71_631 631 93218.1
c_71_631_i 71 71_631 2.08965e-09
r_631_1191_e 631 1191 13376.4
r_631_1191_i 631_1191 1191 93218.1
c_631_1191_i 631 631_1191 2.08965e-09
r_1191_1751_e 1191 1751 836.944
r_1191_1751_i 1191_1751 1751 4256.89
c_1191_1751_i 1191 1191_1751 4.67522e-10
r_1751_2311_e 1751 2311 836.944
r_1751_2311_i 1751_2311 2311 4256.89
c_1751_2311_i 1751 1751_2311 4.67522e-10
r_2311_2871_e 2311 2871 836.944
r_2311_2871_i 2311_2871 2871 4256.89
c_2311_2871_i 2311 2311_2871 4.67522e-10
r_2871_3431_e 2871 3431 13758.3
r_2871_3431_i 2871_3431 3431 95645.6
c_2871_3431_i 2871 2871_3431 9.36084e-12
r_72_632_e 72 632 13376.4
r_72_632_i 72_632 632 93218.1
c_72_632_i 72 72_632 2.08965e-09
r_632_1192_e 632 1192 13376.4
r_632_1192_i 632_1192 1192 93218.1
c_632_1192_i 632 632_1192 2.08965e-09
r_1192_1752_e 1192 1752 836.944
r_1192_1752_i 1192_1752 1752 4256.89
c_1192_1752_i 1192 1192_1752 4.67522e-10
r_1752_2312_e 1752 2312 836.944
r_1752_2312_i 1752_2312 2312 4256.89
c_1752_2312_i 1752 1752_2312 4.67522e-10
r_2312_2872_e 2312 2872 836.944
r_2312_2872_i 2312_2872 2872 4256.89
c_2312_2872_i 2312 2312_2872 4.67522e-10
r_2872_3432_e 2872 3432 13758.3
r_2872_3432_i 2872_3432 3432 95645.6
c_2872_3432_i 2872 2872_3432 9.36084e-12
r_73_633_e 73 633 13376.4
r_73_633_i 73_633 633 93218.1
c_73_633_i 73 73_633 2.08965e-09
r_633_1193_e 633 1193 13376.4
r_633_1193_i 633_1193 1193 93218.1
c_633_1193_i 633 633_1193 2.08965e-09
r_1193_1753_e 1193 1753 836.944
r_1193_1753_i 1193_1753 1753 4256.89
c_1193_1753_i 1193 1193_1753 4.67522e-10
r_1753_2313_e 1753 2313 836.944
r_1753_2313_i 1753_2313 2313 4256.89
c_1753_2313_i 1753 1753_2313 4.67522e-10
r_2313_2873_e 2313 2873 836.944
r_2313_2873_i 2313_2873 2873 4256.89
c_2313_2873_i 2313 2313_2873 4.67522e-10
r_2873_3433_e 2873 3433 13758.3
r_2873_3433_i 2873_3433 3433 95645.6
c_2873_3433_i 2873 2873_3433 9.36084e-12
r_74_634_e 74 634 13376.4
r_74_634_i 74_634 634 93218.1
c_74_634_i 74 74_634 2.08965e-09
r_634_1194_e 634 1194 13376.4
r_634_1194_i 634_1194 1194 93218.1
c_634_1194_i 634 634_1194 2.08965e-09
r_1194_1754_e 1194 1754 836.944
r_1194_1754_i 1194_1754 1754 4256.89
c_1194_1754_i 1194 1194_1754 4.67522e-10
r_1754_2314_e 1754 2314 836.944
r_1754_2314_i 1754_2314 2314 4256.89
c_1754_2314_i 1754 1754_2314 4.67522e-10
r_2314_2874_e 2314 2874 836.944
r_2314_2874_i 2314_2874 2874 4256.89
c_2314_2874_i 2314 2314_2874 4.67522e-10
r_2874_3434_e 2874 3434 13758.3
r_2874_3434_i 2874_3434 3434 95645.6
c_2874_3434_i 2874 2874_3434 9.36084e-12
r_75_635_e 75 635 13376.4
r_75_635_i 75_635 635 93218.1
c_75_635_i 75 75_635 2.08965e-09
r_635_1195_e 635 1195 13376.4
r_635_1195_i 635_1195 1195 93218.1
c_635_1195_i 635 635_1195 2.08965e-09
r_1195_1755_e 1195 1755 396.742
r_1195_1755_i 1195_1755 1755 1005.38
c_1195_1755_i 1195 1195_1755 1.65777e-10
r_1755_2315_e 1755 2315 836.944
r_1755_2315_i 1755_2315 2315 4256.89
c_1755_2315_i 1755 1755_2315 4.67522e-10
r_2315_2875_e 2315 2875 836.944
r_2315_2875_i 2315_2875 2875 4256.89
c_2315_2875_i 2315 2315_2875 4.67522e-10
r_2875_3435_e 2875 3435 13758.3
r_2875_3435_i 2875_3435 3435 95645.6
c_2875_3435_i 2875 2875_3435 9.36084e-12
r_76_636_e 76 636 13376.4
r_76_636_i 76_636 636 93218.1
c_76_636_i 76 76_636 2.08965e-09
r_636_1196_e 636 1196 13376.4
r_636_1196_i 636_1196 1196 93218.1
c_636_1196_i 636 636_1196 2.08965e-09
r_1196_1756_e 1196 1756 396.742
r_1196_1756_i 1196_1756 1756 1005.38
c_1196_1756_i 1196 1196_1756 1.65777e-10
r_1756_2316_e 1756 2316 836.944
r_1756_2316_i 1756_2316 2316 4256.89
c_1756_2316_i 1756 1756_2316 4.67522e-10
r_2316_2876_e 2316 2876 836.944
r_2316_2876_i 2316_2876 2876 4256.89
c_2316_2876_i 2316 2316_2876 4.67522e-10
r_2876_3436_e 2876 3436 13758.3
r_2876_3436_i 2876_3436 3436 95645.6
c_2876_3436_i 2876 2876_3436 9.36084e-12
r_77_637_e 77 637 13376.4
r_77_637_i 77_637 637 93218.1
c_77_637_i 77 77_637 2.08965e-09
r_637_1197_e 637 1197 13376.4
r_637_1197_i 637_1197 1197 93218.1
c_637_1197_i 637 637_1197 2.08965e-09
r_1197_1757_e 1197 1757 836.944
r_1197_1757_i 1197_1757 1757 4256.89
c_1197_1757_i 1197 1197_1757 4.67522e-10
r_1757_2317_e 1757 2317 836.944
r_1757_2317_i 1757_2317 2317 4256.89
c_1757_2317_i 1757 1757_2317 4.67522e-10
r_2317_2877_e 2317 2877 836.944
r_2317_2877_i 2317_2877 2877 4256.89
c_2317_2877_i 2317 2317_2877 4.67522e-10
r_2877_3437_e 2877 3437 13758.3
r_2877_3437_i 2877_3437 3437 95645.6
c_2877_3437_i 2877 2877_3437 9.36084e-12
r_78_638_e 78 638 13376.4
r_78_638_i 78_638 638 93218.1
c_78_638_i 78 78_638 2.08965e-09
r_638_1198_e 638 1198 13376.4
r_638_1198_i 638_1198 1198 93218.1
c_638_1198_i 638 638_1198 2.08965e-09
r_1198_1758_e 1198 1758 836.944
r_1198_1758_i 1198_1758 1758 4256.89
c_1198_1758_i 1198 1198_1758 4.67522e-10
r_1758_2318_e 1758 2318 836.944
r_1758_2318_i 1758_2318 2318 4256.89
c_1758_2318_i 1758 1758_2318 4.67522e-10
r_2318_2878_e 2318 2878 836.944
r_2318_2878_i 2318_2878 2878 4256.89
c_2318_2878_i 2318 2318_2878 4.67522e-10
r_2878_3438_e 2878 3438 13758.3
r_2878_3438_i 2878_3438 3438 95645.6
c_2878_3438_i 2878 2878_3438 9.36084e-12
r_79_639_e 79 639 13376.4
r_79_639_i 79_639 639 93218.1
c_79_639_i 79 79_639 2.08965e-09
r_639_1199_e 639 1199 13376.4
r_639_1199_i 639_1199 1199 93218.1
c_639_1199_i 639 639_1199 2.08965e-09
r_1199_1759_e 1199 1759 836.944
r_1199_1759_i 1199_1759 1759 4256.89
c_1199_1759_i 1199 1199_1759 4.67522e-10
r_1759_2319_e 1759 2319 836.944
r_1759_2319_i 1759_2319 2319 4256.89
c_1759_2319_i 1759 1759_2319 4.67522e-10
r_2319_2879_e 2319 2879 836.944
r_2319_2879_i 2319_2879 2879 4256.89
c_2319_2879_i 2319 2319_2879 4.67522e-10
r_2879_3439_e 2879 3439 13758.3
r_2879_3439_i 2879_3439 3439 95645.6
c_2879_3439_i 2879 2879_3439 9.36084e-12
r_80_640_e 80 640 13376.4
r_80_640_i 80_640 640 93218.1
c_80_640_i 80 80_640 2.08965e-09
r_640_1200_e 640 1200 13376.4
r_640_1200_i 640_1200 1200 93218.1
c_640_1200_i 640 640_1200 2.08965e-09
r_1200_1760_e 1200 1760 836.944
r_1200_1760_i 1200_1760 1760 4256.89
c_1200_1760_i 1200 1200_1760 4.67522e-10
r_1760_2320_e 1760 2320 836.944
r_1760_2320_i 1760_2320 2320 4256.89
c_1760_2320_i 1760 1760_2320 4.67522e-10
r_2320_2880_e 2320 2880 836.944
r_2320_2880_i 2320_2880 2880 4256.89
c_2320_2880_i 2320 2320_2880 4.67522e-10
r_2880_3440_e 2880 3440 13758.3
r_2880_3440_i 2880_3440 3440 95645.6
c_2880_3440_i 2880 2880_3440 9.36084e-12
r_81_641_e 81 641 13376.4
r_81_641_i 81_641 641 93218.1
c_81_641_i 81 81_641 2.08965e-09
r_641_1201_e 641 1201 13376.4
r_641_1201_i 641_1201 1201 93218.1
c_641_1201_i 641 641_1201 2.08965e-09
r_1201_1761_e 1201 1761 13376.4
r_1201_1761_i 1201_1761 1761 93218.1
c_1201_1761_i 1201 1201_1761 2.08965e-09
r_1761_2321_e 1761 2321 13376.4
r_1761_2321_i 1761_2321 2321 93218.1
c_1761_2321_i 1761 1761_2321 2.08965e-09
r_2321_2881_e 2321 2881 13376.4
r_2321_2881_i 2321_2881 2881 93218.1
c_2321_2881_i 2321 2321_2881 2.08965e-09
r_2881_3441_e 2881 3441 13376.4
r_2881_3441_i 2881_3441 3441 93218.1
c_2881_3441_i 2881 2881_3441 2.08965e-09
r_82_642_e 82 642 13376.4
r_82_642_i 82_642 642 93218.1
c_82_642_i 82 82_642 2.08965e-09
r_642_1202_e 642 1202 13376.4
r_642_1202_i 642_1202 1202 93218.1
c_642_1202_i 642 642_1202 2.08965e-09
r_1202_1762_e 1202 1762 13376.4
r_1202_1762_i 1202_1762 1762 93218.1
c_1202_1762_i 1202 1202_1762 2.08965e-09
r_1762_2322_e 1762 2322 13376.4
r_1762_2322_i 1762_2322 2322 93218.1
c_1762_2322_i 1762 1762_2322 2.08965e-09
r_2322_2882_e 2322 2882 13376.4
r_2322_2882_i 2322_2882 2882 93218.1
c_2322_2882_i 2322 2322_2882 2.08965e-09
r_2882_3442_e 2882 3442 13376.4
r_2882_3442_i 2882_3442 3442 93218.1
c_2882_3442_i 2882 2882_3442 2.08965e-09
r_83_643_e 83 643 13376.4
r_83_643_i 83_643 643 93218.1
c_83_643_i 83 83_643 2.08965e-09
r_643_1203_e 643 1203 13376.4
r_643_1203_i 643_1203 1203 93218.1
c_643_1203_i 643 643_1203 2.08965e-09
r_1203_1763_e 1203 1763 836.944
r_1203_1763_i 1203_1763 1763 4256.89
c_1203_1763_i 1203 1203_1763 4.67522e-10
r_1763_2323_e 1763 2323 836.944
r_1763_2323_i 1763_2323 2323 4256.89
c_1763_2323_i 1763 1763_2323 4.67522e-10
r_2323_2883_e 2323 2883 836.944
r_2323_2883_i 2323_2883 2883 4256.89
c_2323_2883_i 2323 2323_2883 4.67522e-10
r_2883_3443_e 2883 3443 836.944
r_2883_3443_i 2883_3443 3443 4256.89
c_2883_3443_i 2883 2883_3443 4.67522e-10
r_84_644_e 84 644 13376.4
r_84_644_i 84_644 644 93218.1
c_84_644_i 84 84_644 2.08965e-09
r_644_1204_e 644 1204 13376.4
r_644_1204_i 644_1204 1204 93218.1
c_644_1204_i 644 644_1204 2.08965e-09
r_1204_1764_e 1204 1764 836.944
r_1204_1764_i 1204_1764 1764 4256.89
c_1204_1764_i 1204 1204_1764 4.67522e-10
r_1764_2324_e 1764 2324 836.944
r_1764_2324_i 1764_2324 2324 4256.89
c_1764_2324_i 1764 1764_2324 4.67522e-10
r_2324_2884_e 2324 2884 836.944
r_2324_2884_i 2324_2884 2884 4256.89
c_2324_2884_i 2324 2324_2884 4.67522e-10
r_2884_3444_e 2884 3444 13758.3
r_2884_3444_i 2884_3444 3444 95645.6
c_2884_3444_i 2884 2884_3444 9.36084e-12
r_85_645_e 85 645 13376.4
r_85_645_i 85_645 645 93218.1
c_85_645_i 85 85_645 2.08965e-09
r_645_1205_e 645 1205 13376.4
r_645_1205_i 645_1205 1205 93218.1
c_645_1205_i 645 645_1205 2.08965e-09
r_1205_1765_e 1205 1765 836.944
r_1205_1765_i 1205_1765 1765 4256.89
c_1205_1765_i 1205 1205_1765 4.67522e-10
r_1765_2325_e 1765 2325 836.944
r_1765_2325_i 1765_2325 2325 4256.89
c_1765_2325_i 1765 1765_2325 4.67522e-10
r_2325_2885_e 2325 2885 836.944
r_2325_2885_i 2325_2885 2885 4256.89
c_2325_2885_i 2325 2325_2885 4.67522e-10
r_2885_3445_e 2885 3445 13758.3
r_2885_3445_i 2885_3445 3445 95645.6
c_2885_3445_i 2885 2885_3445 9.36084e-12
r_86_646_e 86 646 13376.4
r_86_646_i 86_646 646 93218.1
c_86_646_i 86 86_646 2.08965e-09
r_646_1206_e 646 1206 13376.4
r_646_1206_i 646_1206 1206 93218.1
c_646_1206_i 646 646_1206 2.08965e-09
r_1206_1766_e 1206 1766 836.944
r_1206_1766_i 1206_1766 1766 4256.89
c_1206_1766_i 1206 1206_1766 4.67522e-10
r_1766_2326_e 1766 2326 836.944
r_1766_2326_i 1766_2326 2326 4256.89
c_1766_2326_i 1766 1766_2326 4.67522e-10
r_2326_2886_e 2326 2886 836.944
r_2326_2886_i 2326_2886 2886 4256.89
c_2326_2886_i 2326 2326_2886 4.67522e-10
r_2886_3446_e 2886 3446 13758.3
r_2886_3446_i 2886_3446 3446 95645.6
c_2886_3446_i 2886 2886_3446 9.36084e-12
r_87_647_e 87 647 13376.4
r_87_647_i 87_647 647 93218.1
c_87_647_i 87 87_647 2.08965e-09
r_647_1207_e 647 1207 13376.4
r_647_1207_i 647_1207 1207 93218.1
c_647_1207_i 647 647_1207 2.08965e-09
r_1207_1767_e 1207 1767 836.944
r_1207_1767_i 1207_1767 1767 4256.89
c_1207_1767_i 1207 1207_1767 4.67522e-10
r_1767_2327_e 1767 2327 836.944
r_1767_2327_i 1767_2327 2327 4256.89
c_1767_2327_i 1767 1767_2327 4.67522e-10
r_2327_2887_e 2327 2887 836.944
r_2327_2887_i 2327_2887 2887 4256.89
c_2327_2887_i 2327 2327_2887 4.67522e-10
r_2887_3447_e 2887 3447 13758.3
r_2887_3447_i 2887_3447 3447 95645.6
c_2887_3447_i 2887 2887_3447 9.36084e-12
r_88_648_e 88 648 13376.4
r_88_648_i 88_648 648 93218.1
c_88_648_i 88 88_648 2.08965e-09
r_648_1208_e 648 1208 13376.4
r_648_1208_i 648_1208 1208 93218.1
c_648_1208_i 648 648_1208 2.08965e-09
r_1208_1768_e 1208 1768 836.944
r_1208_1768_i 1208_1768 1768 4256.89
c_1208_1768_i 1208 1208_1768 4.67522e-10
r_1768_2328_e 1768 2328 836.944
r_1768_2328_i 1768_2328 2328 4256.89
c_1768_2328_i 1768 1768_2328 4.67522e-10
r_2328_2888_e 2328 2888 836.944
r_2328_2888_i 2328_2888 2888 4256.89
c_2328_2888_i 2328 2328_2888 4.67522e-10
r_2888_3448_e 2888 3448 13758.3
r_2888_3448_i 2888_3448 3448 95645.6
c_2888_3448_i 2888 2888_3448 9.36084e-12
r_89_649_e 89 649 13376.4
r_89_649_i 89_649 649 93218.1
c_89_649_i 89 89_649 2.08965e-09
r_649_1209_e 649 1209 13376.4
r_649_1209_i 649_1209 1209 93218.1
c_649_1209_i 649 649_1209 2.08965e-09
r_1209_1769_e 1209 1769 836.944
r_1209_1769_i 1209_1769 1769 4256.89
c_1209_1769_i 1209 1209_1769 4.67522e-10
r_1769_2329_e 1769 2329 836.944
r_1769_2329_i 1769_2329 2329 4256.89
c_1769_2329_i 1769 1769_2329 4.67522e-10
r_2329_2889_e 2329 2889 836.944
r_2329_2889_i 2329_2889 2889 4256.89
c_2329_2889_i 2329 2329_2889 4.67522e-10
r_2889_3449_e 2889 3449 13758.3
r_2889_3449_i 2889_3449 3449 95645.6
c_2889_3449_i 2889 2889_3449 9.36084e-12
r_90_650_e 90 650 13376.4
r_90_650_i 90_650 650 93218.1
c_90_650_i 90 90_650 2.08965e-09
r_650_1210_e 650 1210 13376.4
r_650_1210_i 650_1210 1210 93218.1
c_650_1210_i 650 650_1210 2.08965e-09
r_1210_1770_e 1210 1770 836.944
r_1210_1770_i 1210_1770 1770 4256.89
c_1210_1770_i 1210 1210_1770 4.67522e-10
r_1770_2330_e 1770 2330 836.944
r_1770_2330_i 1770_2330 2330 4256.89
c_1770_2330_i 1770 1770_2330 4.67522e-10
r_2330_2890_e 2330 2890 836.944
r_2330_2890_i 2330_2890 2890 4256.89
c_2330_2890_i 2330 2330_2890 4.67522e-10
r_2890_3450_e 2890 3450 13758.3
r_2890_3450_i 2890_3450 3450 95645.6
c_2890_3450_i 2890 2890_3450 9.36084e-12
r_91_651_e 91 651 13376.4
r_91_651_i 91_651 651 93218.1
c_91_651_i 91 91_651 2.08965e-09
r_651_1211_e 651 1211 13376.4
r_651_1211_i 651_1211 1211 93218.1
c_651_1211_i 651 651_1211 2.08965e-09
r_1211_1771_e 1211 1771 396.733
r_1211_1771_i 1211_1771 1771 1005.36
c_1211_1771_i 1211 1211_1771 1.65781e-10
r_1771_2331_e 1771 2331 836.944
r_1771_2331_i 1771_2331 2331 4256.89
c_1771_2331_i 1771 1771_2331 4.67522e-10
r_2331_2891_e 2331 2891 836.944
r_2331_2891_i 2331_2891 2891 4256.89
c_2331_2891_i 2331 2331_2891 4.67522e-10
r_2891_3451_e 2891 3451 13758.3
r_2891_3451_i 2891_3451 3451 95645.6
c_2891_3451_i 2891 2891_3451 9.36084e-12
r_92_652_e 92 652 13376.4
r_92_652_i 92_652 652 93218.1
c_92_652_i 92 92_652 2.08965e-09
r_652_1212_e 652 1212 13376.4
r_652_1212_i 652_1212 1212 93218.1
c_652_1212_i 652 652_1212 2.08965e-09
r_1212_1772_e 1212 1772 396.733
r_1212_1772_i 1212_1772 1772 1005.36
c_1212_1772_i 1212 1212_1772 1.65781e-10
r_1772_2332_e 1772 2332 836.944
r_1772_2332_i 1772_2332 2332 4256.89
c_1772_2332_i 1772 1772_2332 4.67522e-10
r_2332_2892_e 2332 2892 836.944
r_2332_2892_i 2332_2892 2892 4256.89
c_2332_2892_i 2332 2332_2892 4.67522e-10
r_2892_3452_e 2892 3452 13758.3
r_2892_3452_i 2892_3452 3452 95645.6
c_2892_3452_i 2892 2892_3452 9.36084e-12
r_93_653_e 93 653 13376.4
r_93_653_i 93_653 653 93218.1
c_93_653_i 93 93_653 2.08965e-09
r_653_1213_e 653 1213 13376.4
r_653_1213_i 653_1213 1213 93218.1
c_653_1213_i 653 653_1213 2.08965e-09
r_1213_1773_e 1213 1773 836.944
r_1213_1773_i 1213_1773 1773 4256.89
c_1213_1773_i 1213 1213_1773 4.67522e-10
r_1773_2333_e 1773 2333 836.944
r_1773_2333_i 1773_2333 2333 4256.89
c_1773_2333_i 1773 1773_2333 4.67522e-10
r_2333_2893_e 2333 2893 836.944
r_2333_2893_i 2333_2893 2893 4256.89
c_2333_2893_i 2333 2333_2893 4.67522e-10
r_2893_3453_e 2893 3453 13758.3
r_2893_3453_i 2893_3453 3453 95645.6
c_2893_3453_i 2893 2893_3453 9.36084e-12
r_94_654_e 94 654 13376.4
r_94_654_i 94_654 654 93218.1
c_94_654_i 94 94_654 2.08965e-09
r_654_1214_e 654 1214 13376.4
r_654_1214_i 654_1214 1214 93218.1
c_654_1214_i 654 654_1214 2.08965e-09
r_1214_1774_e 1214 1774 836.944
r_1214_1774_i 1214_1774 1774 4256.89
c_1214_1774_i 1214 1214_1774 4.67522e-10
r_1774_2334_e 1774 2334 836.944
r_1774_2334_i 1774_2334 2334 4256.89
c_1774_2334_i 1774 1774_2334 4.67522e-10
r_2334_2894_e 2334 2894 836.944
r_2334_2894_i 2334_2894 2894 4256.89
c_2334_2894_i 2334 2334_2894 4.67522e-10
r_2894_3454_e 2894 3454 13758.3
r_2894_3454_i 2894_3454 3454 95645.6
c_2894_3454_i 2894 2894_3454 9.36084e-12
r_95_655_e 95 655 13376.4
r_95_655_i 95_655 655 93218.1
c_95_655_i 95 95_655 2.08965e-09
r_655_1215_e 655 1215 13376.4
r_655_1215_i 655_1215 1215 93218.1
c_655_1215_i 655 655_1215 2.08965e-09
r_1215_1775_e 1215 1775 836.944
r_1215_1775_i 1215_1775 1775 4256.89
c_1215_1775_i 1215 1215_1775 4.67522e-10
r_1775_2335_e 1775 2335 836.944
r_1775_2335_i 1775_2335 2335 4256.89
c_1775_2335_i 1775 1775_2335 4.67522e-10
r_2335_2895_e 2335 2895 836.944
r_2335_2895_i 2335_2895 2895 4256.89
c_2335_2895_i 2335 2335_2895 4.67522e-10
r_2895_3455_e 2895 3455 13758.3
r_2895_3455_i 2895_3455 3455 95645.6
c_2895_3455_i 2895 2895_3455 9.36084e-12
r_96_656_e 96 656 13376.4
r_96_656_i 96_656 656 93218.1
c_96_656_i 96 96_656 2.08965e-09
r_656_1216_e 656 1216 13376.4
r_656_1216_i 656_1216 1216 93218.1
c_656_1216_i 656 656_1216 2.08965e-09
r_1216_1776_e 1216 1776 836.944
r_1216_1776_i 1216_1776 1776 4256.89
c_1216_1776_i 1216 1216_1776 4.67522e-10
r_1776_2336_e 1776 2336 836.944
r_1776_2336_i 1776_2336 2336 4256.89
c_1776_2336_i 1776 1776_2336 4.67522e-10
r_2336_2896_e 2336 2896 836.944
r_2336_2896_i 2336_2896 2896 4256.89
c_2336_2896_i 2336 2336_2896 4.67522e-10
r_2896_3456_e 2896 3456 13758.3
r_2896_3456_i 2896_3456 3456 95645.6
c_2896_3456_i 2896 2896_3456 9.36084e-12
r_97_657_e 97 657 13376.4
r_97_657_i 97_657 657 93218.1
c_97_657_i 97 97_657 2.08965e-09
r_657_1217_e 657 1217 13376.4
r_657_1217_i 657_1217 1217 93218.1
c_657_1217_i 657 657_1217 2.08965e-09
r_1217_1777_e 1217 1777 13376.4
r_1217_1777_i 1217_1777 1777 93218.1
c_1217_1777_i 1217 1217_1777 2.08965e-09
r_1777_2337_e 1777 2337 13376.4
r_1777_2337_i 1777_2337 2337 93218.1
c_1777_2337_i 1777 1777_2337 2.08965e-09
r_2337_2897_e 2337 2897 13376.4
r_2337_2897_i 2337_2897 2897 93218.1
c_2337_2897_i 2337 2337_2897 2.08965e-09
r_2897_3457_e 2897 3457 13376.4
r_2897_3457_i 2897_3457 3457 93218.1
c_2897_3457_i 2897 2897_3457 2.08965e-09
r_98_658_e 98 658 13376.4
r_98_658_i 98_658 658 93218.1
c_98_658_i 98 98_658 2.08965e-09
r_658_1218_e 658 1218 13376.4
r_658_1218_i 658_1218 1218 93218.1
c_658_1218_i 658 658_1218 2.08965e-09
r_1218_1778_e 1218 1778 13376.4
r_1218_1778_i 1218_1778 1778 93218.1
c_1218_1778_i 1218 1218_1778 2.08965e-09
r_1778_2338_e 1778 2338 13376.4
r_1778_2338_i 1778_2338 2338 93218.1
c_1778_2338_i 1778 1778_2338 2.08965e-09
r_2338_2898_e 2338 2898 13376.4
r_2338_2898_i 2338_2898 2898 93218.1
c_2338_2898_i 2338 2338_2898 2.08965e-09
r_2898_3458_e 2898 3458 13376.4
r_2898_3458_i 2898_3458 3458 93218.1
c_2898_3458_i 2898 2898_3458 2.08965e-09
r_99_659_e 99 659 13376.4
r_99_659_i 99_659 659 93218.1
c_99_659_i 99 99_659 2.08965e-09
r_659_1219_e 659 1219 13376.4
r_659_1219_i 659_1219 1219 93218.1
c_659_1219_i 659 659_1219 2.08965e-09
r_1219_1779_e 1219 1779 836.944
r_1219_1779_i 1219_1779 1779 4256.89
c_1219_1779_i 1219 1219_1779 4.67522e-10
r_1779_2339_e 1779 2339 836.944
r_1779_2339_i 1779_2339 2339 4256.89
c_1779_2339_i 1779 1779_2339 4.67522e-10
r_2339_2899_e 2339 2899 836.944
r_2339_2899_i 2339_2899 2899 4256.89
c_2339_2899_i 2339 2339_2899 4.67522e-10
r_2899_3459_e 2899 3459 836.944
r_2899_3459_i 2899_3459 3459 4256.89
c_2899_3459_i 2899 2899_3459 4.67522e-10
r_100_660_e 100 660 13376.4
r_100_660_i 100_660 660 93218.1
c_100_660_i 100 100_660 2.08965e-09
r_660_1220_e 660 1220 13376.4
r_660_1220_i 660_1220 1220 93218.1
c_660_1220_i 660 660_1220 2.08965e-09
r_1220_1780_e 1220 1780 836.944
r_1220_1780_i 1220_1780 1780 4256.89
c_1220_1780_i 1220 1220_1780 4.67522e-10
r_1780_2340_e 1780 2340 836.944
r_1780_2340_i 1780_2340 2340 4256.89
c_1780_2340_i 1780 1780_2340 4.67522e-10
r_2340_2900_e 2340 2900 836.944
r_2340_2900_i 2340_2900 2900 4256.89
c_2340_2900_i 2340 2340_2900 4.67522e-10
r_2900_3460_e 2900 3460 13758.3
r_2900_3460_i 2900_3460 3460 95645.6
c_2900_3460_i 2900 2900_3460 9.36084e-12
r_101_661_e 101 661 13376.4
r_101_661_i 101_661 661 93218.1
c_101_661_i 101 101_661 2.08965e-09
r_661_1221_e 661 1221 13376.4
r_661_1221_i 661_1221 1221 93218.1
c_661_1221_i 661 661_1221 2.08965e-09
r_1221_1781_e 1221 1781 836.944
r_1221_1781_i 1221_1781 1781 4256.89
c_1221_1781_i 1221 1221_1781 4.67522e-10
r_1781_2341_e 1781 2341 836.944
r_1781_2341_i 1781_2341 2341 4256.89
c_1781_2341_i 1781 1781_2341 4.67522e-10
r_2341_2901_e 2341 2901 836.944
r_2341_2901_i 2341_2901 2901 4256.89
c_2341_2901_i 2341 2341_2901 4.67522e-10
r_2901_3461_e 2901 3461 13758.3
r_2901_3461_i 2901_3461 3461 95645.6
c_2901_3461_i 2901 2901_3461 9.36084e-12
r_102_662_e 102 662 13376.4
r_102_662_i 102_662 662 93218.1
c_102_662_i 102 102_662 2.08965e-09
r_662_1222_e 662 1222 13376.4
r_662_1222_i 662_1222 1222 93218.1
c_662_1222_i 662 662_1222 2.08965e-09
r_1222_1782_e 1222 1782 836.944
r_1222_1782_i 1222_1782 1782 4256.89
c_1222_1782_i 1222 1222_1782 4.67522e-10
r_1782_2342_e 1782 2342 836.944
r_1782_2342_i 1782_2342 2342 4256.89
c_1782_2342_i 1782 1782_2342 4.67522e-10
r_2342_2902_e 2342 2902 836.944
r_2342_2902_i 2342_2902 2902 4256.89
c_2342_2902_i 2342 2342_2902 4.67522e-10
r_2902_3462_e 2902 3462 13758.3
r_2902_3462_i 2902_3462 3462 95645.6
c_2902_3462_i 2902 2902_3462 9.36084e-12
r_103_663_e 103 663 13376.4
r_103_663_i 103_663 663 93218.1
c_103_663_i 103 103_663 2.08965e-09
r_663_1223_e 663 1223 13376.4
r_663_1223_i 663_1223 1223 93218.1
c_663_1223_i 663 663_1223 2.08965e-09
r_1223_1783_e 1223 1783 836.944
r_1223_1783_i 1223_1783 1783 4256.89
c_1223_1783_i 1223 1223_1783 4.67522e-10
r_1783_2343_e 1783 2343 836.944
r_1783_2343_i 1783_2343 2343 4256.89
c_1783_2343_i 1783 1783_2343 4.67522e-10
r_2343_2903_e 2343 2903 836.944
r_2343_2903_i 2343_2903 2903 4256.89
c_2343_2903_i 2343 2343_2903 4.67522e-10
r_2903_3463_e 2903 3463 13758.3
r_2903_3463_i 2903_3463 3463 95645.6
c_2903_3463_i 2903 2903_3463 9.36084e-12
r_104_664_e 104 664 13376.4
r_104_664_i 104_664 664 93218.1
c_104_664_i 104 104_664 2.08965e-09
r_664_1224_e 664 1224 13376.4
r_664_1224_i 664_1224 1224 93218.1
c_664_1224_i 664 664_1224 2.08965e-09
r_1224_1784_e 1224 1784 836.944
r_1224_1784_i 1224_1784 1784 4256.89
c_1224_1784_i 1224 1224_1784 4.67522e-10
r_1784_2344_e 1784 2344 836.944
r_1784_2344_i 1784_2344 2344 4256.89
c_1784_2344_i 1784 1784_2344 4.67522e-10
r_2344_2904_e 2344 2904 836.944
r_2344_2904_i 2344_2904 2904 4256.89
c_2344_2904_i 2344 2344_2904 4.67522e-10
r_2904_3464_e 2904 3464 13758.3
r_2904_3464_i 2904_3464 3464 95645.6
c_2904_3464_i 2904 2904_3464 9.36084e-12
r_105_665_e 105 665 13376.4
r_105_665_i 105_665 665 93218.1
c_105_665_i 105 105_665 2.08965e-09
r_665_1225_e 665 1225 13376.4
r_665_1225_i 665_1225 1225 93218.1
c_665_1225_i 665 665_1225 2.08965e-09
r_1225_1785_e 1225 1785 836.944
r_1225_1785_i 1225_1785 1785 4256.89
c_1225_1785_i 1225 1225_1785 4.67522e-10
r_1785_2345_e 1785 2345 836.944
r_1785_2345_i 1785_2345 2345 4256.89
c_1785_2345_i 1785 1785_2345 4.67522e-10
r_2345_2905_e 2345 2905 836.944
r_2345_2905_i 2345_2905 2905 4256.89
c_2345_2905_i 2345 2345_2905 4.67522e-10
r_2905_3465_e 2905 3465 13758.3
r_2905_3465_i 2905_3465 3465 95645.6
c_2905_3465_i 2905 2905_3465 9.36084e-12
r_106_666_e 106 666 13376.4
r_106_666_i 106_666 666 93218.1
c_106_666_i 106 106_666 2.08965e-09
r_666_1226_e 666 1226 13376.4
r_666_1226_i 666_1226 1226 93218.1
c_666_1226_i 666 666_1226 2.08965e-09
r_1226_1786_e 1226 1786 836.944
r_1226_1786_i 1226_1786 1786 4256.89
c_1226_1786_i 1226 1226_1786 4.67522e-10
r_1786_2346_e 1786 2346 836.944
r_1786_2346_i 1786_2346 2346 4256.89
c_1786_2346_i 1786 1786_2346 4.67522e-10
r_2346_2906_e 2346 2906 836.944
r_2346_2906_i 2346_2906 2906 4256.89
c_2346_2906_i 2346 2346_2906 4.67522e-10
r_2906_3466_e 2906 3466 13758.3
r_2906_3466_i 2906_3466 3466 95645.6
c_2906_3466_i 2906 2906_3466 9.36084e-12
r_107_667_e 107 667 13376.4
r_107_667_i 107_667 667 93218.1
c_107_667_i 107 107_667 2.08965e-09
r_667_1227_e 667 1227 13376.4
r_667_1227_i 667_1227 1227 93218.1
c_667_1227_i 667 667_1227 2.08965e-09
r_1227_1787_e 1227 1787 396.724
r_1227_1787_i 1227_1787 1787 1005.34
c_1227_1787_i 1227 1227_1787 1.65785e-10
r_1787_2347_e 1787 2347 836.944
r_1787_2347_i 1787_2347 2347 4256.89
c_1787_2347_i 1787 1787_2347 4.67522e-10
r_2347_2907_e 2347 2907 836.944
r_2347_2907_i 2347_2907 2907 4256.89
c_2347_2907_i 2347 2347_2907 4.67522e-10
r_2907_3467_e 2907 3467 13758.3
r_2907_3467_i 2907_3467 3467 95645.6
c_2907_3467_i 2907 2907_3467 9.36084e-12
r_108_668_e 108 668 13376.4
r_108_668_i 108_668 668 93218.1
c_108_668_i 108 108_668 2.08965e-09
r_668_1228_e 668 1228 13376.4
r_668_1228_i 668_1228 1228 93218.1
c_668_1228_i 668 668_1228 2.08965e-09
r_1228_1788_e 1228 1788 396.724
r_1228_1788_i 1228_1788 1788 1005.34
c_1228_1788_i 1228 1228_1788 1.65785e-10
r_1788_2348_e 1788 2348 836.944
r_1788_2348_i 1788_2348 2348 4256.89
c_1788_2348_i 1788 1788_2348 4.67522e-10
r_2348_2908_e 2348 2908 836.944
r_2348_2908_i 2348_2908 2908 4256.89
c_2348_2908_i 2348 2348_2908 4.67522e-10
r_2908_3468_e 2908 3468 13758.3
r_2908_3468_i 2908_3468 3468 95645.6
c_2908_3468_i 2908 2908_3468 9.36084e-12
r_109_669_e 109 669 13376.4
r_109_669_i 109_669 669 93218.1
c_109_669_i 109 109_669 2.08965e-09
r_669_1229_e 669 1229 13376.4
r_669_1229_i 669_1229 1229 93218.1
c_669_1229_i 669 669_1229 2.08965e-09
r_1229_1789_e 1229 1789 836.944
r_1229_1789_i 1229_1789 1789 4256.89
c_1229_1789_i 1229 1229_1789 4.67522e-10
r_1789_2349_e 1789 2349 836.944
r_1789_2349_i 1789_2349 2349 4256.89
c_1789_2349_i 1789 1789_2349 4.67522e-10
r_2349_2909_e 2349 2909 836.944
r_2349_2909_i 2349_2909 2909 4256.89
c_2349_2909_i 2349 2349_2909 4.67522e-10
r_2909_3469_e 2909 3469 13758.3
r_2909_3469_i 2909_3469 3469 95645.6
c_2909_3469_i 2909 2909_3469 9.36084e-12
r_110_670_e 110 670 13376.4
r_110_670_i 110_670 670 93218.1
c_110_670_i 110 110_670 2.08965e-09
r_670_1230_e 670 1230 13376.4
r_670_1230_i 670_1230 1230 93218.1
c_670_1230_i 670 670_1230 2.08965e-09
r_1230_1790_e 1230 1790 836.944
r_1230_1790_i 1230_1790 1790 4256.89
c_1230_1790_i 1230 1230_1790 4.67522e-10
r_1790_2350_e 1790 2350 836.944
r_1790_2350_i 1790_2350 2350 4256.89
c_1790_2350_i 1790 1790_2350 4.67522e-10
r_2350_2910_e 2350 2910 836.944
r_2350_2910_i 2350_2910 2910 4256.89
c_2350_2910_i 2350 2350_2910 4.67522e-10
r_2910_3470_e 2910 3470 13758.3
r_2910_3470_i 2910_3470 3470 95645.6
c_2910_3470_i 2910 2910_3470 9.36084e-12
r_111_671_e 111 671 13376.4
r_111_671_i 111_671 671 93218.1
c_111_671_i 111 111_671 2.08965e-09
r_671_1231_e 671 1231 13376.4
r_671_1231_i 671_1231 1231 93218.1
c_671_1231_i 671 671_1231 2.08965e-09
r_1231_1791_e 1231 1791 836.944
r_1231_1791_i 1231_1791 1791 4256.89
c_1231_1791_i 1231 1231_1791 4.67522e-10
r_1791_2351_e 1791 2351 836.944
r_1791_2351_i 1791_2351 2351 4256.89
c_1791_2351_i 1791 1791_2351 4.67522e-10
r_2351_2911_e 2351 2911 836.944
r_2351_2911_i 2351_2911 2911 4256.89
c_2351_2911_i 2351 2351_2911 4.67522e-10
r_2911_3471_e 2911 3471 13758.3
r_2911_3471_i 2911_3471 3471 95645.6
c_2911_3471_i 2911 2911_3471 9.36084e-12
r_112_672_e 112 672 13376.4
r_112_672_i 112_672 672 93218.1
c_112_672_i 112 112_672 2.08965e-09
r_672_1232_e 672 1232 13376.4
r_672_1232_i 672_1232 1232 93218.1
c_672_1232_i 672 672_1232 2.08965e-09
r_1232_1792_e 1232 1792 836.944
r_1232_1792_i 1232_1792 1792 4256.89
c_1232_1792_i 1232 1232_1792 4.67522e-10
r_1792_2352_e 1792 2352 836.944
r_1792_2352_i 1792_2352 2352 4256.89
c_1792_2352_i 1792 1792_2352 4.67522e-10
r_2352_2912_e 2352 2912 836.944
r_2352_2912_i 2352_2912 2912 4256.89
c_2352_2912_i 2352 2352_2912 4.67522e-10
r_2912_3472_e 2912 3472 13758.3
r_2912_3472_i 2912_3472 3472 95645.6
c_2912_3472_i 2912 2912_3472 9.36084e-12
r_113_673_e 113 673 13376.4
r_113_673_i 113_673 673 93218.1
c_113_673_i 113 113_673 2.08965e-09
r_673_1233_e 673 1233 13376.4
r_673_1233_i 673_1233 1233 93218.1
c_673_1233_i 673 673_1233 2.08965e-09
r_1233_1793_e 1233 1793 13376.4
r_1233_1793_i 1233_1793 1793 93218.1
c_1233_1793_i 1233 1233_1793 2.08965e-09
r_1793_2353_e 1793 2353 13376.4
r_1793_2353_i 1793_2353 2353 93218.1
c_1793_2353_i 1793 1793_2353 2.08965e-09
r_2353_2913_e 2353 2913 13376.4
r_2353_2913_i 2353_2913 2913 93218.1
c_2353_2913_i 2353 2353_2913 2.08965e-09
r_2913_3473_e 2913 3473 13376.4
r_2913_3473_i 2913_3473 3473 93218.1
c_2913_3473_i 2913 2913_3473 2.08965e-09
r_114_674_e 114 674 13376.4
r_114_674_i 114_674 674 93218.1
c_114_674_i 114 114_674 2.08965e-09
r_674_1234_e 674 1234 13376.4
r_674_1234_i 674_1234 1234 93218.1
c_674_1234_i 674 674_1234 2.08965e-09
r_1234_1794_e 1234 1794 13376.4
r_1234_1794_i 1234_1794 1794 93218.1
c_1234_1794_i 1234 1234_1794 2.08965e-09
r_1794_2354_e 1794 2354 13376.4
r_1794_2354_i 1794_2354 2354 93218.1
c_1794_2354_i 1794 1794_2354 2.08965e-09
r_2354_2914_e 2354 2914 13376.4
r_2354_2914_i 2354_2914 2914 93218.1
c_2354_2914_i 2354 2354_2914 2.08965e-09
r_2914_3474_e 2914 3474 13376.4
r_2914_3474_i 2914_3474 3474 93218.1
c_2914_3474_i 2914 2914_3474 2.08965e-09
r_115_675_e 115 675 13376.4
r_115_675_i 115_675 675 93218.1
c_115_675_i 115 115_675 2.08965e-09
r_675_1235_e 675 1235 13376.4
r_675_1235_i 675_1235 1235 93218.1
c_675_1235_i 675 675_1235 2.08965e-09
r_1235_1795_e 1235 1795 836.944
r_1235_1795_i 1235_1795 1795 4256.89
c_1235_1795_i 1235 1235_1795 4.67522e-10
r_1795_2355_e 1795 2355 836.944
r_1795_2355_i 1795_2355 2355 4256.89
c_1795_2355_i 1795 1795_2355 4.67522e-10
r_2355_2915_e 2355 2915 836.944
r_2355_2915_i 2355_2915 2915 4256.89
c_2355_2915_i 2355 2355_2915 4.67522e-10
r_2915_3475_e 2915 3475 836.944
r_2915_3475_i 2915_3475 3475 4256.89
c_2915_3475_i 2915 2915_3475 4.67522e-10
r_116_676_e 116 676 13376.4
r_116_676_i 116_676 676 93218.1
c_116_676_i 116 116_676 2.08965e-09
r_676_1236_e 676 1236 13376.4
r_676_1236_i 676_1236 1236 93218.1
c_676_1236_i 676 676_1236 2.08965e-09
r_1236_1796_e 1236 1796 836.944
r_1236_1796_i 1236_1796 1796 4256.89
c_1236_1796_i 1236 1236_1796 4.67522e-10
r_1796_2356_e 1796 2356 836.944
r_1796_2356_i 1796_2356 2356 4256.89
c_1796_2356_i 1796 1796_2356 4.67522e-10
r_2356_2916_e 2356 2916 836.944
r_2356_2916_i 2356_2916 2916 4256.89
c_2356_2916_i 2356 2356_2916 4.67522e-10
r_2916_3476_e 2916 3476 13758.3
r_2916_3476_i 2916_3476 3476 95645.6
c_2916_3476_i 2916 2916_3476 9.36084e-12
r_117_677_e 117 677 13376.4
r_117_677_i 117_677 677 93218.1
c_117_677_i 117 117_677 2.08965e-09
r_677_1237_e 677 1237 13376.4
r_677_1237_i 677_1237 1237 93218.1
c_677_1237_i 677 677_1237 2.08965e-09
r_1237_1797_e 1237 1797 836.944
r_1237_1797_i 1237_1797 1797 4256.89
c_1237_1797_i 1237 1237_1797 4.67522e-10
r_1797_2357_e 1797 2357 836.944
r_1797_2357_i 1797_2357 2357 4256.89
c_1797_2357_i 1797 1797_2357 4.67522e-10
r_2357_2917_e 2357 2917 836.944
r_2357_2917_i 2357_2917 2917 4256.89
c_2357_2917_i 2357 2357_2917 4.67522e-10
r_2917_3477_e 2917 3477 13758.3
r_2917_3477_i 2917_3477 3477 95645.6
c_2917_3477_i 2917 2917_3477 9.36084e-12
r_118_678_e 118 678 13376.4
r_118_678_i 118_678 678 93218.1
c_118_678_i 118 118_678 2.08965e-09
r_678_1238_e 678 1238 13376.4
r_678_1238_i 678_1238 1238 93218.1
c_678_1238_i 678 678_1238 2.08965e-09
r_1238_1798_e 1238 1798 836.944
r_1238_1798_i 1238_1798 1798 4256.89
c_1238_1798_i 1238 1238_1798 4.67522e-10
r_1798_2358_e 1798 2358 836.944
r_1798_2358_i 1798_2358 2358 4256.89
c_1798_2358_i 1798 1798_2358 4.67522e-10
r_2358_2918_e 2358 2918 836.944
r_2358_2918_i 2358_2918 2918 4256.89
c_2358_2918_i 2358 2358_2918 4.67522e-10
r_2918_3478_e 2918 3478 13758.3
r_2918_3478_i 2918_3478 3478 95645.6
c_2918_3478_i 2918 2918_3478 9.36084e-12
r_119_679_e 119 679 13376.4
r_119_679_i 119_679 679 93218.1
c_119_679_i 119 119_679 2.08965e-09
r_679_1239_e 679 1239 13376.4
r_679_1239_i 679_1239 1239 93218.1
c_679_1239_i 679 679_1239 2.08965e-09
r_1239_1799_e 1239 1799 836.944
r_1239_1799_i 1239_1799 1799 4256.89
c_1239_1799_i 1239 1239_1799 4.67522e-10
r_1799_2359_e 1799 2359 836.944
r_1799_2359_i 1799_2359 2359 4256.89
c_1799_2359_i 1799 1799_2359 4.67522e-10
r_2359_2919_e 2359 2919 836.944
r_2359_2919_i 2359_2919 2919 4256.89
c_2359_2919_i 2359 2359_2919 4.67522e-10
r_2919_3479_e 2919 3479 13758.3
r_2919_3479_i 2919_3479 3479 95645.6
c_2919_3479_i 2919 2919_3479 9.36084e-12
r_120_680_e 120 680 13376.4
r_120_680_i 120_680 680 93218.1
c_120_680_i 120 120_680 2.08965e-09
r_680_1240_e 680 1240 13376.4
r_680_1240_i 680_1240 1240 93218.1
c_680_1240_i 680 680_1240 2.08965e-09
r_1240_1800_e 1240 1800 836.944
r_1240_1800_i 1240_1800 1800 4256.89
c_1240_1800_i 1240 1240_1800 4.67522e-10
r_1800_2360_e 1800 2360 836.944
r_1800_2360_i 1800_2360 2360 4256.89
c_1800_2360_i 1800 1800_2360 4.67522e-10
r_2360_2920_e 2360 2920 836.944
r_2360_2920_i 2360_2920 2920 4256.89
c_2360_2920_i 2360 2360_2920 4.67522e-10
r_2920_3480_e 2920 3480 13758.3
r_2920_3480_i 2920_3480 3480 95645.6
c_2920_3480_i 2920 2920_3480 9.36084e-12
r_121_681_e 121 681 13376.4
r_121_681_i 121_681 681 93218.1
c_121_681_i 121 121_681 2.08965e-09
r_681_1241_e 681 1241 13376.4
r_681_1241_i 681_1241 1241 93218.1
c_681_1241_i 681 681_1241 2.08965e-09
r_1241_1801_e 1241 1801 836.944
r_1241_1801_i 1241_1801 1801 4256.89
c_1241_1801_i 1241 1241_1801 4.67522e-10
r_1801_2361_e 1801 2361 836.944
r_1801_2361_i 1801_2361 2361 4256.89
c_1801_2361_i 1801 1801_2361 4.67522e-10
r_2361_2921_e 2361 2921 836.944
r_2361_2921_i 2361_2921 2921 4256.89
c_2361_2921_i 2361 2361_2921 4.67522e-10
r_2921_3481_e 2921 3481 13758.3
r_2921_3481_i 2921_3481 3481 95645.6
c_2921_3481_i 2921 2921_3481 9.36084e-12
r_122_682_e 122 682 13376.4
r_122_682_i 122_682 682 93218.1
c_122_682_i 122 122_682 2.08965e-09
r_682_1242_e 682 1242 13376.4
r_682_1242_i 682_1242 1242 93218.1
c_682_1242_i 682 682_1242 2.08965e-09
r_1242_1802_e 1242 1802 836.944
r_1242_1802_i 1242_1802 1802 4256.89
c_1242_1802_i 1242 1242_1802 4.67522e-10
r_1802_2362_e 1802 2362 836.944
r_1802_2362_i 1802_2362 2362 4256.89
c_1802_2362_i 1802 1802_2362 4.67522e-10
r_2362_2922_e 2362 2922 836.944
r_2362_2922_i 2362_2922 2922 4256.89
c_2362_2922_i 2362 2362_2922 4.67522e-10
r_2922_3482_e 2922 3482 13758.3
r_2922_3482_i 2922_3482 3482 95645.6
c_2922_3482_i 2922 2922_3482 9.36084e-12
r_123_683_e 123 683 13376.4
r_123_683_i 123_683 683 93218.1
c_123_683_i 123 123_683 2.08965e-09
r_683_1243_e 683 1243 13376.4
r_683_1243_i 683_1243 1243 93218.1
c_683_1243_i 683 683_1243 2.08965e-09
r_1243_1803_e 1243 1803 396.715
r_1243_1803_i 1243_1803 1803 1005.31
c_1243_1803_i 1243 1243_1803 1.65788e-10
r_1803_2363_e 1803 2363 836.944
r_1803_2363_i 1803_2363 2363 4256.89
c_1803_2363_i 1803 1803_2363 4.67522e-10
r_2363_2923_e 2363 2923 836.944
r_2363_2923_i 2363_2923 2923 4256.89
c_2363_2923_i 2363 2363_2923 4.67522e-10
r_2923_3483_e 2923 3483 13758.3
r_2923_3483_i 2923_3483 3483 95645.6
c_2923_3483_i 2923 2923_3483 9.36084e-12
r_124_684_e 124 684 13376.4
r_124_684_i 124_684 684 93218.1
c_124_684_i 124 124_684 2.08965e-09
r_684_1244_e 684 1244 13376.4
r_684_1244_i 684_1244 1244 93218.1
c_684_1244_i 684 684_1244 2.08965e-09
r_1244_1804_e 1244 1804 396.715
r_1244_1804_i 1244_1804 1804 1005.31
c_1244_1804_i 1244 1244_1804 1.65788e-10
r_1804_2364_e 1804 2364 836.944
r_1804_2364_i 1804_2364 2364 4256.89
c_1804_2364_i 1804 1804_2364 4.67522e-10
r_2364_2924_e 2364 2924 836.944
r_2364_2924_i 2364_2924 2924 4256.89
c_2364_2924_i 2364 2364_2924 4.67522e-10
r_2924_3484_e 2924 3484 13758.3
r_2924_3484_i 2924_3484 3484 95645.6
c_2924_3484_i 2924 2924_3484 9.36084e-12
r_125_685_e 125 685 13376.4
r_125_685_i 125_685 685 93218.1
c_125_685_i 125 125_685 2.08965e-09
r_685_1245_e 685 1245 13376.4
r_685_1245_i 685_1245 1245 93218.1
c_685_1245_i 685 685_1245 2.08965e-09
r_1245_1805_e 1245 1805 836.944
r_1245_1805_i 1245_1805 1805 4256.89
c_1245_1805_i 1245 1245_1805 4.67522e-10
r_1805_2365_e 1805 2365 836.944
r_1805_2365_i 1805_2365 2365 4256.89
c_1805_2365_i 1805 1805_2365 4.67522e-10
r_2365_2925_e 2365 2925 836.944
r_2365_2925_i 2365_2925 2925 4256.89
c_2365_2925_i 2365 2365_2925 4.67522e-10
r_2925_3485_e 2925 3485 13758.3
r_2925_3485_i 2925_3485 3485 95645.6
c_2925_3485_i 2925 2925_3485 9.36084e-12
r_126_686_e 126 686 13376.4
r_126_686_i 126_686 686 93218.1
c_126_686_i 126 126_686 2.08965e-09
r_686_1246_e 686 1246 13376.4
r_686_1246_i 686_1246 1246 93218.1
c_686_1246_i 686 686_1246 2.08965e-09
r_1246_1806_e 1246 1806 836.944
r_1246_1806_i 1246_1806 1806 4256.89
c_1246_1806_i 1246 1246_1806 4.67522e-10
r_1806_2366_e 1806 2366 836.944
r_1806_2366_i 1806_2366 2366 4256.89
c_1806_2366_i 1806 1806_2366 4.67522e-10
r_2366_2926_e 2366 2926 836.944
r_2366_2926_i 2366_2926 2926 4256.89
c_2366_2926_i 2366 2366_2926 4.67522e-10
r_2926_3486_e 2926 3486 13758.3
r_2926_3486_i 2926_3486 3486 95645.6
c_2926_3486_i 2926 2926_3486 9.36084e-12
r_127_687_e 127 687 13376.4
r_127_687_i 127_687 687 93218.1
c_127_687_i 127 127_687 2.08965e-09
r_687_1247_e 687 1247 13376.4
r_687_1247_i 687_1247 1247 93218.1
c_687_1247_i 687 687_1247 2.08965e-09
r_1247_1807_e 1247 1807 836.944
r_1247_1807_i 1247_1807 1807 4256.89
c_1247_1807_i 1247 1247_1807 4.67522e-10
r_1807_2367_e 1807 2367 836.944
r_1807_2367_i 1807_2367 2367 4256.89
c_1807_2367_i 1807 1807_2367 4.67522e-10
r_2367_2927_e 2367 2927 836.944
r_2367_2927_i 2367_2927 2927 4256.89
c_2367_2927_i 2367 2367_2927 4.67522e-10
r_2927_3487_e 2927 3487 13758.3
r_2927_3487_i 2927_3487 3487 95645.6
c_2927_3487_i 2927 2927_3487 9.36084e-12
r_128_688_e 128 688 13376.4
r_128_688_i 128_688 688 93218.1
c_128_688_i 128 128_688 2.08965e-09
r_688_1248_e 688 1248 13376.4
r_688_1248_i 688_1248 1248 93218.1
c_688_1248_i 688 688_1248 2.08965e-09
r_1248_1808_e 1248 1808 836.944
r_1248_1808_i 1248_1808 1808 4256.89
c_1248_1808_i 1248 1248_1808 4.67522e-10
r_1808_2368_e 1808 2368 836.944
r_1808_2368_i 1808_2368 2368 4256.89
c_1808_2368_i 1808 1808_2368 4.67522e-10
r_2368_2928_e 2368 2928 836.944
r_2368_2928_i 2368_2928 2928 4256.89
c_2368_2928_i 2368 2368_2928 4.67522e-10
r_2928_3488_e 2928 3488 13758.3
r_2928_3488_i 2928_3488 3488 95645.6
c_2928_3488_i 2928 2928_3488 9.36084e-12
r_129_689_e 129 689 13376.4
r_129_689_i 129_689 689 93218.1
c_129_689_i 129 129_689 2.08965e-09
r_689_1249_e 689 1249 13376.4
r_689_1249_i 689_1249 1249 93218.1
c_689_1249_i 689 689_1249 2.08965e-09
r_1249_1809_e 1249 1809 13376.4
r_1249_1809_i 1249_1809 1809 93218.1
c_1249_1809_i 1249 1249_1809 2.08965e-09
r_1809_2369_e 1809 2369 13376.4
r_1809_2369_i 1809_2369 2369 93218.1
c_1809_2369_i 1809 1809_2369 2.08965e-09
r_2369_2929_e 2369 2929 13376.4
r_2369_2929_i 2369_2929 2929 93218.1
c_2369_2929_i 2369 2369_2929 2.08965e-09
r_2929_3489_e 2929 3489 13376.4
r_2929_3489_i 2929_3489 3489 93218.1
c_2929_3489_i 2929 2929_3489 2.08965e-09
r_130_690_e 130 690 13376.4
r_130_690_i 130_690 690 93218.1
c_130_690_i 130 130_690 2.08965e-09
r_690_1250_e 690 1250 13376.4
r_690_1250_i 690_1250 1250 93218.1
c_690_1250_i 690 690_1250 2.08965e-09
r_1250_1810_e 1250 1810 13376.4
r_1250_1810_i 1250_1810 1810 93218.1
c_1250_1810_i 1250 1250_1810 2.08965e-09
r_1810_2370_e 1810 2370 13376.4
r_1810_2370_i 1810_2370 2370 93218.1
c_1810_2370_i 1810 1810_2370 2.08965e-09
r_2370_2930_e 2370 2930 13376.4
r_2370_2930_i 2370_2930 2930 93218.1
c_2370_2930_i 2370 2370_2930 2.08965e-09
r_2930_3490_e 2930 3490 13376.4
r_2930_3490_i 2930_3490 3490 93218.1
c_2930_3490_i 2930 2930_3490 2.08965e-09
r_131_691_e 131 691 13376.4
r_131_691_i 131_691 691 93218.1
c_131_691_i 131 131_691 2.08965e-09
r_691_1251_e 691 1251 13376.4
r_691_1251_i 691_1251 1251 93218.1
c_691_1251_i 691 691_1251 2.08965e-09
r_1251_1811_e 1251 1811 836.944
r_1251_1811_i 1251_1811 1811 4256.89
c_1251_1811_i 1251 1251_1811 4.67522e-10
r_1811_2371_e 1811 2371 836.944
r_1811_2371_i 1811_2371 2371 4256.89
c_1811_2371_i 1811 1811_2371 4.67522e-10
r_2371_2931_e 2371 2931 836.944
r_2371_2931_i 2371_2931 2931 4256.89
c_2371_2931_i 2371 2371_2931 4.67522e-10
r_2931_3491_e 2931 3491 836.944
r_2931_3491_i 2931_3491 3491 4256.89
c_2931_3491_i 2931 2931_3491 4.67522e-10
r_132_692_e 132 692 13376.4
r_132_692_i 132_692 692 93218.1
c_132_692_i 132 132_692 2.08965e-09
r_692_1252_e 692 1252 13376.4
r_692_1252_i 692_1252 1252 93218.1
c_692_1252_i 692 692_1252 2.08965e-09
r_1252_1812_e 1252 1812 836.944
r_1252_1812_i 1252_1812 1812 4256.89
c_1252_1812_i 1252 1252_1812 4.67522e-10
r_1812_2372_e 1812 2372 836.944
r_1812_2372_i 1812_2372 2372 4256.89
c_1812_2372_i 1812 1812_2372 4.67522e-10
r_2372_2932_e 2372 2932 836.944
r_2372_2932_i 2372_2932 2932 4256.89
c_2372_2932_i 2372 2372_2932 4.67522e-10
r_2932_3492_e 2932 3492 13758.3
r_2932_3492_i 2932_3492 3492 95645.6
c_2932_3492_i 2932 2932_3492 9.36084e-12
r_133_693_e 133 693 13376.4
r_133_693_i 133_693 693 93218.1
c_133_693_i 133 133_693 2.08965e-09
r_693_1253_e 693 1253 13376.4
r_693_1253_i 693_1253 1253 93218.1
c_693_1253_i 693 693_1253 2.08965e-09
r_1253_1813_e 1253 1813 836.944
r_1253_1813_i 1253_1813 1813 4256.89
c_1253_1813_i 1253 1253_1813 4.67522e-10
r_1813_2373_e 1813 2373 836.944
r_1813_2373_i 1813_2373 2373 4256.89
c_1813_2373_i 1813 1813_2373 4.67522e-10
r_2373_2933_e 2373 2933 836.944
r_2373_2933_i 2373_2933 2933 4256.89
c_2373_2933_i 2373 2373_2933 4.67522e-10
r_2933_3493_e 2933 3493 13758.3
r_2933_3493_i 2933_3493 3493 95645.6
c_2933_3493_i 2933 2933_3493 9.36084e-12
r_134_694_e 134 694 13376.4
r_134_694_i 134_694 694 93218.1
c_134_694_i 134 134_694 2.08965e-09
r_694_1254_e 694 1254 13376.4
r_694_1254_i 694_1254 1254 93218.1
c_694_1254_i 694 694_1254 2.08965e-09
r_1254_1814_e 1254 1814 836.944
r_1254_1814_i 1254_1814 1814 4256.89
c_1254_1814_i 1254 1254_1814 4.67522e-10
r_1814_2374_e 1814 2374 836.944
r_1814_2374_i 1814_2374 2374 4256.89
c_1814_2374_i 1814 1814_2374 4.67522e-10
r_2374_2934_e 2374 2934 836.944
r_2374_2934_i 2374_2934 2934 4256.89
c_2374_2934_i 2374 2374_2934 4.67522e-10
r_2934_3494_e 2934 3494 13758.3
r_2934_3494_i 2934_3494 3494 95645.6
c_2934_3494_i 2934 2934_3494 9.36084e-12
r_135_695_e 135 695 13376.4
r_135_695_i 135_695 695 93218.1
c_135_695_i 135 135_695 2.08965e-09
r_695_1255_e 695 1255 13376.4
r_695_1255_i 695_1255 1255 93218.1
c_695_1255_i 695 695_1255 2.08965e-09
r_1255_1815_e 1255 1815 836.944
r_1255_1815_i 1255_1815 1815 4256.89
c_1255_1815_i 1255 1255_1815 4.67522e-10
r_1815_2375_e 1815 2375 836.944
r_1815_2375_i 1815_2375 2375 4256.89
c_1815_2375_i 1815 1815_2375 4.67522e-10
r_2375_2935_e 2375 2935 836.944
r_2375_2935_i 2375_2935 2935 4256.89
c_2375_2935_i 2375 2375_2935 4.67522e-10
r_2935_3495_e 2935 3495 13758.3
r_2935_3495_i 2935_3495 3495 95645.6
c_2935_3495_i 2935 2935_3495 9.36084e-12
r_136_696_e 136 696 13376.4
r_136_696_i 136_696 696 93218.1
c_136_696_i 136 136_696 2.08965e-09
r_696_1256_e 696 1256 13376.4
r_696_1256_i 696_1256 1256 93218.1
c_696_1256_i 696 696_1256 2.08965e-09
r_1256_1816_e 1256 1816 836.944
r_1256_1816_i 1256_1816 1816 4256.89
c_1256_1816_i 1256 1256_1816 4.67522e-10
r_1816_2376_e 1816 2376 836.944
r_1816_2376_i 1816_2376 2376 4256.89
c_1816_2376_i 1816 1816_2376 4.67522e-10
r_2376_2936_e 2376 2936 836.944
r_2376_2936_i 2376_2936 2936 4256.89
c_2376_2936_i 2376 2376_2936 4.67522e-10
r_2936_3496_e 2936 3496 13758.3
r_2936_3496_i 2936_3496 3496 95645.6
c_2936_3496_i 2936 2936_3496 9.36084e-12
r_137_697_e 137 697 13376.4
r_137_697_i 137_697 697 93218.1
c_137_697_i 137 137_697 2.08965e-09
r_697_1257_e 697 1257 13376.4
r_697_1257_i 697_1257 1257 93218.1
c_697_1257_i 697 697_1257 2.08965e-09
r_1257_1817_e 1257 1817 836.944
r_1257_1817_i 1257_1817 1817 4256.89
c_1257_1817_i 1257 1257_1817 4.67522e-10
r_1817_2377_e 1817 2377 836.944
r_1817_2377_i 1817_2377 2377 4256.89
c_1817_2377_i 1817 1817_2377 4.67522e-10
r_2377_2937_e 2377 2937 836.944
r_2377_2937_i 2377_2937 2937 4256.89
c_2377_2937_i 2377 2377_2937 4.67522e-10
r_2937_3497_e 2937 3497 13758.3
r_2937_3497_i 2937_3497 3497 95645.6
c_2937_3497_i 2937 2937_3497 9.36084e-12
r_138_698_e 138 698 13376.4
r_138_698_i 138_698 698 93218.1
c_138_698_i 138 138_698 2.08965e-09
r_698_1258_e 698 1258 13376.4
r_698_1258_i 698_1258 1258 93218.1
c_698_1258_i 698 698_1258 2.08965e-09
r_1258_1818_e 1258 1818 836.944
r_1258_1818_i 1258_1818 1818 4256.89
c_1258_1818_i 1258 1258_1818 4.67522e-10
r_1818_2378_e 1818 2378 836.944
r_1818_2378_i 1818_2378 2378 4256.89
c_1818_2378_i 1818 1818_2378 4.67522e-10
r_2378_2938_e 2378 2938 836.944
r_2378_2938_i 2378_2938 2938 4256.89
c_2378_2938_i 2378 2378_2938 4.67522e-10
r_2938_3498_e 2938 3498 13758.3
r_2938_3498_i 2938_3498 3498 95645.6
c_2938_3498_i 2938 2938_3498 9.36084e-12
r_139_699_e 139 699 13376.4
r_139_699_i 139_699 699 93218.1
c_139_699_i 139 139_699 2.08965e-09
r_699_1259_e 699 1259 13376.4
r_699_1259_i 699_1259 1259 93218.1
c_699_1259_i 699 699_1259 2.08965e-09
r_1259_1819_e 1259 1819 396.706
r_1259_1819_i 1259_1819 1819 1005.29
c_1259_1819_i 1259 1259_1819 1.65792e-10
r_1819_2379_e 1819 2379 836.944
r_1819_2379_i 1819_2379 2379 4256.89
c_1819_2379_i 1819 1819_2379 4.67522e-10
r_2379_2939_e 2379 2939 836.944
r_2379_2939_i 2379_2939 2939 4256.89
c_2379_2939_i 2379 2379_2939 4.67522e-10
r_2939_3499_e 2939 3499 13758.3
r_2939_3499_i 2939_3499 3499 95645.6
c_2939_3499_i 2939 2939_3499 9.36084e-12
r_140_700_e 140 700 13376.4
r_140_700_i 140_700 700 93218.1
c_140_700_i 140 140_700 2.08965e-09
r_700_1260_e 700 1260 13376.4
r_700_1260_i 700_1260 1260 93218.1
c_700_1260_i 700 700_1260 2.08965e-09
r_1260_1820_e 1260 1820 396.706
r_1260_1820_i 1260_1820 1820 1005.29
c_1260_1820_i 1260 1260_1820 1.65792e-10
r_1820_2380_e 1820 2380 836.944
r_1820_2380_i 1820_2380 2380 4256.89
c_1820_2380_i 1820 1820_2380 4.67522e-10
r_2380_2940_e 2380 2940 836.944
r_2380_2940_i 2380_2940 2940 4256.89
c_2380_2940_i 2380 2380_2940 4.67522e-10
r_2940_3500_e 2940 3500 13758.3
r_2940_3500_i 2940_3500 3500 95645.6
c_2940_3500_i 2940 2940_3500 9.36084e-12
r_141_701_e 141 701 13376.4
r_141_701_i 141_701 701 93218.1
c_141_701_i 141 141_701 2.08965e-09
r_701_1261_e 701 1261 13376.4
r_701_1261_i 701_1261 1261 93218.1
c_701_1261_i 701 701_1261 2.08965e-09
r_1261_1821_e 1261 1821 836.944
r_1261_1821_i 1261_1821 1821 4256.89
c_1261_1821_i 1261 1261_1821 4.67522e-10
r_1821_2381_e 1821 2381 836.944
r_1821_2381_i 1821_2381 2381 4256.89
c_1821_2381_i 1821 1821_2381 4.67522e-10
r_2381_2941_e 2381 2941 836.944
r_2381_2941_i 2381_2941 2941 4256.89
c_2381_2941_i 2381 2381_2941 4.67522e-10
r_2941_3501_e 2941 3501 13758.3
r_2941_3501_i 2941_3501 3501 95645.6
c_2941_3501_i 2941 2941_3501 9.36084e-12
r_142_702_e 142 702 13376.4
r_142_702_i 142_702 702 93218.1
c_142_702_i 142 142_702 2.08965e-09
r_702_1262_e 702 1262 13376.4
r_702_1262_i 702_1262 1262 93218.1
c_702_1262_i 702 702_1262 2.08965e-09
r_1262_1822_e 1262 1822 836.944
r_1262_1822_i 1262_1822 1822 4256.89
c_1262_1822_i 1262 1262_1822 4.67522e-10
r_1822_2382_e 1822 2382 836.944
r_1822_2382_i 1822_2382 2382 4256.89
c_1822_2382_i 1822 1822_2382 4.67522e-10
r_2382_2942_e 2382 2942 836.944
r_2382_2942_i 2382_2942 2942 4256.89
c_2382_2942_i 2382 2382_2942 4.67522e-10
r_2942_3502_e 2942 3502 13758.3
r_2942_3502_i 2942_3502 3502 95645.6
c_2942_3502_i 2942 2942_3502 9.36084e-12
r_143_703_e 143 703 13376.4
r_143_703_i 143_703 703 93218.1
c_143_703_i 143 143_703 2.08965e-09
r_703_1263_e 703 1263 13376.4
r_703_1263_i 703_1263 1263 93218.1
c_703_1263_i 703 703_1263 2.08965e-09
r_1263_1823_e 1263 1823 836.944
r_1263_1823_i 1263_1823 1823 4256.89
c_1263_1823_i 1263 1263_1823 4.67522e-10
r_1823_2383_e 1823 2383 836.944
r_1823_2383_i 1823_2383 2383 4256.89
c_1823_2383_i 1823 1823_2383 4.67522e-10
r_2383_2943_e 2383 2943 836.944
r_2383_2943_i 2383_2943 2943 4256.89
c_2383_2943_i 2383 2383_2943 4.67522e-10
r_2943_3503_e 2943 3503 13758.3
r_2943_3503_i 2943_3503 3503 95645.6
c_2943_3503_i 2943 2943_3503 9.36084e-12
r_144_704_e 144 704 13376.4
r_144_704_i 144_704 704 93218.1
c_144_704_i 144 144_704 2.08965e-09
r_704_1264_e 704 1264 13376.4
r_704_1264_i 704_1264 1264 93218.1
c_704_1264_i 704 704_1264 2.08965e-09
r_1264_1824_e 1264 1824 836.944
r_1264_1824_i 1264_1824 1824 4256.89
c_1264_1824_i 1264 1264_1824 4.67522e-10
r_1824_2384_e 1824 2384 836.944
r_1824_2384_i 1824_2384 2384 4256.89
c_1824_2384_i 1824 1824_2384 4.67522e-10
r_2384_2944_e 2384 2944 836.944
r_2384_2944_i 2384_2944 2944 4256.89
c_2384_2944_i 2384 2384_2944 4.67522e-10
r_2944_3504_e 2944 3504 13758.3
r_2944_3504_i 2944_3504 3504 95645.6
c_2944_3504_i 2944 2944_3504 9.36084e-12
r_145_705_e 145 705 13376.4
r_145_705_i 145_705 705 93218.1
c_145_705_i 145 145_705 2.08965e-09
r_705_1265_e 705 1265 13376.4
r_705_1265_i 705_1265 1265 93218.1
c_705_1265_i 705 705_1265 2.08965e-09
r_1265_1825_e 1265 1825 13376.4
r_1265_1825_i 1265_1825 1825 93218.1
c_1265_1825_i 1265 1265_1825 2.08965e-09
r_1825_2385_e 1825 2385 13376.4
r_1825_2385_i 1825_2385 2385 93218.1
c_1825_2385_i 1825 1825_2385 2.08965e-09
r_2385_2945_e 2385 2945 13376.4
r_2385_2945_i 2385_2945 2945 93218.1
c_2385_2945_i 2385 2385_2945 2.08965e-09
r_2945_3505_e 2945 3505 13376.4
r_2945_3505_i 2945_3505 3505 93218.1
c_2945_3505_i 2945 2945_3505 2.08965e-09
r_146_706_e 146 706 13376.4
r_146_706_i 146_706 706 93218.1
c_146_706_i 146 146_706 2.08965e-09
r_706_1266_e 706 1266 13376.4
r_706_1266_i 706_1266 1266 93218.1
c_706_1266_i 706 706_1266 2.08965e-09
r_1266_1826_e 1266 1826 13376.4
r_1266_1826_i 1266_1826 1826 93218.1
c_1266_1826_i 1266 1266_1826 2.08965e-09
r_1826_2386_e 1826 2386 13376.4
r_1826_2386_i 1826_2386 2386 93218.1
c_1826_2386_i 1826 1826_2386 2.08965e-09
r_2386_2946_e 2386 2946 13376.4
r_2386_2946_i 2386_2946 2946 93218.1
c_2386_2946_i 2386 2386_2946 2.08965e-09
r_2946_3506_e 2946 3506 13376.4
r_2946_3506_i 2946_3506 3506 93218.1
c_2946_3506_i 2946 2946_3506 2.08965e-09
r_147_707_e 147 707 13376.4
r_147_707_i 147_707 707 93218.1
c_147_707_i 147 147_707 2.08965e-09
r_707_1267_e 707 1267 13376.4
r_707_1267_i 707_1267 1267 93218.1
c_707_1267_i 707 707_1267 2.08965e-09
r_1267_1827_e 1267 1827 836.944
r_1267_1827_i 1267_1827 1827 4256.89
c_1267_1827_i 1267 1267_1827 4.67522e-10
r_1827_2387_e 1827 2387 836.944
r_1827_2387_i 1827_2387 2387 4256.89
c_1827_2387_i 1827 1827_2387 4.67522e-10
r_2387_2947_e 2387 2947 836.944
r_2387_2947_i 2387_2947 2947 4256.89
c_2387_2947_i 2387 2387_2947 4.67522e-10
r_2947_3507_e 2947 3507 836.944
r_2947_3507_i 2947_3507 3507 4256.89
c_2947_3507_i 2947 2947_3507 4.67522e-10
r_148_708_e 148 708 13376.4
r_148_708_i 148_708 708 93218.1
c_148_708_i 148 148_708 2.08965e-09
r_708_1268_e 708 1268 13376.4
r_708_1268_i 708_1268 1268 93218.1
c_708_1268_i 708 708_1268 2.08965e-09
r_1268_1828_e 1268 1828 836.944
r_1268_1828_i 1268_1828 1828 4256.89
c_1268_1828_i 1268 1268_1828 4.67522e-10
r_1828_2388_e 1828 2388 836.944
r_1828_2388_i 1828_2388 2388 4256.89
c_1828_2388_i 1828 1828_2388 4.67522e-10
r_2388_2948_e 2388 2948 836.944
r_2388_2948_i 2388_2948 2948 4256.89
c_2388_2948_i 2388 2388_2948 4.67522e-10
r_2948_3508_e 2948 3508 13758.3
r_2948_3508_i 2948_3508 3508 95645.6
c_2948_3508_i 2948 2948_3508 9.36084e-12
r_149_709_e 149 709 13376.4
r_149_709_i 149_709 709 93218.1
c_149_709_i 149 149_709 2.08965e-09
r_709_1269_e 709 1269 13376.4
r_709_1269_i 709_1269 1269 93218.1
c_709_1269_i 709 709_1269 2.08965e-09
r_1269_1829_e 1269 1829 836.944
r_1269_1829_i 1269_1829 1829 4256.89
c_1269_1829_i 1269 1269_1829 4.67522e-10
r_1829_2389_e 1829 2389 836.944
r_1829_2389_i 1829_2389 2389 4256.89
c_1829_2389_i 1829 1829_2389 4.67522e-10
r_2389_2949_e 2389 2949 836.944
r_2389_2949_i 2389_2949 2949 4256.89
c_2389_2949_i 2389 2389_2949 4.67522e-10
r_2949_3509_e 2949 3509 13758.3
r_2949_3509_i 2949_3509 3509 95645.6
c_2949_3509_i 2949 2949_3509 9.36084e-12
r_150_710_e 150 710 13376.4
r_150_710_i 150_710 710 93218.1
c_150_710_i 150 150_710 2.08965e-09
r_710_1270_e 710 1270 13376.4
r_710_1270_i 710_1270 1270 93218.1
c_710_1270_i 710 710_1270 2.08965e-09
r_1270_1830_e 1270 1830 836.944
r_1270_1830_i 1270_1830 1830 4256.89
c_1270_1830_i 1270 1270_1830 4.67522e-10
r_1830_2390_e 1830 2390 836.944
r_1830_2390_i 1830_2390 2390 4256.89
c_1830_2390_i 1830 1830_2390 4.67522e-10
r_2390_2950_e 2390 2950 836.944
r_2390_2950_i 2390_2950 2950 4256.89
c_2390_2950_i 2390 2390_2950 4.67522e-10
r_2950_3510_e 2950 3510 13758.3
r_2950_3510_i 2950_3510 3510 95645.6
c_2950_3510_i 2950 2950_3510 9.36084e-12
r_151_711_e 151 711 13376.4
r_151_711_i 151_711 711 93218.1
c_151_711_i 151 151_711 2.08965e-09
r_711_1271_e 711 1271 13376.4
r_711_1271_i 711_1271 1271 93218.1
c_711_1271_i 711 711_1271 2.08965e-09
r_1271_1831_e 1271 1831 836.944
r_1271_1831_i 1271_1831 1831 4256.89
c_1271_1831_i 1271 1271_1831 4.67522e-10
r_1831_2391_e 1831 2391 836.944
r_1831_2391_i 1831_2391 2391 4256.89
c_1831_2391_i 1831 1831_2391 4.67522e-10
r_2391_2951_e 2391 2951 836.944
r_2391_2951_i 2391_2951 2951 4256.89
c_2391_2951_i 2391 2391_2951 4.67522e-10
r_2951_3511_e 2951 3511 13758.3
r_2951_3511_i 2951_3511 3511 95645.6
c_2951_3511_i 2951 2951_3511 9.36084e-12
r_152_712_e 152 712 13376.4
r_152_712_i 152_712 712 93218.1
c_152_712_i 152 152_712 2.08965e-09
r_712_1272_e 712 1272 13376.4
r_712_1272_i 712_1272 1272 93218.1
c_712_1272_i 712 712_1272 2.08965e-09
r_1272_1832_e 1272 1832 836.944
r_1272_1832_i 1272_1832 1832 4256.89
c_1272_1832_i 1272 1272_1832 4.67522e-10
r_1832_2392_e 1832 2392 836.944
r_1832_2392_i 1832_2392 2392 4256.89
c_1832_2392_i 1832 1832_2392 4.67522e-10
r_2392_2952_e 2392 2952 836.944
r_2392_2952_i 2392_2952 2952 4256.89
c_2392_2952_i 2392 2392_2952 4.67522e-10
r_2952_3512_e 2952 3512 13758.3
r_2952_3512_i 2952_3512 3512 95645.6
c_2952_3512_i 2952 2952_3512 9.36084e-12
r_153_713_e 153 713 13376.4
r_153_713_i 153_713 713 93218.1
c_153_713_i 153 153_713 2.08965e-09
r_713_1273_e 713 1273 13376.4
r_713_1273_i 713_1273 1273 93218.1
c_713_1273_i 713 713_1273 2.08965e-09
r_1273_1833_e 1273 1833 836.944
r_1273_1833_i 1273_1833 1833 4256.89
c_1273_1833_i 1273 1273_1833 4.67522e-10
r_1833_2393_e 1833 2393 836.944
r_1833_2393_i 1833_2393 2393 4256.89
c_1833_2393_i 1833 1833_2393 4.67522e-10
r_2393_2953_e 2393 2953 836.944
r_2393_2953_i 2393_2953 2953 4256.89
c_2393_2953_i 2393 2393_2953 4.67522e-10
r_2953_3513_e 2953 3513 13758.3
r_2953_3513_i 2953_3513 3513 95645.6
c_2953_3513_i 2953 2953_3513 9.36084e-12
r_154_714_e 154 714 13376.4
r_154_714_i 154_714 714 93218.1
c_154_714_i 154 154_714 2.08965e-09
r_714_1274_e 714 1274 13376.4
r_714_1274_i 714_1274 1274 93218.1
c_714_1274_i 714 714_1274 2.08965e-09
r_1274_1834_e 1274 1834 836.944
r_1274_1834_i 1274_1834 1834 4256.89
c_1274_1834_i 1274 1274_1834 4.67522e-10
r_1834_2394_e 1834 2394 836.944
r_1834_2394_i 1834_2394 2394 4256.89
c_1834_2394_i 1834 1834_2394 4.67522e-10
r_2394_2954_e 2394 2954 836.944
r_2394_2954_i 2394_2954 2954 4256.89
c_2394_2954_i 2394 2394_2954 4.67522e-10
r_2954_3514_e 2954 3514 13758.3
r_2954_3514_i 2954_3514 3514 95645.6
c_2954_3514_i 2954 2954_3514 9.36084e-12
r_155_715_e 155 715 13376.4
r_155_715_i 155_715 715 93218.1
c_155_715_i 155 155_715 2.08965e-09
r_715_1275_e 715 1275 13376.4
r_715_1275_i 715_1275 1275 93218.1
c_715_1275_i 715 715_1275 2.08965e-09
r_1275_1835_e 1275 1835 396.697
r_1275_1835_i 1275_1835 1835 1005.27
c_1275_1835_i 1275 1275_1835 1.65796e-10
r_1835_2395_e 1835 2395 836.944
r_1835_2395_i 1835_2395 2395 4256.89
c_1835_2395_i 1835 1835_2395 4.67522e-10
r_2395_2955_e 2395 2955 836.944
r_2395_2955_i 2395_2955 2955 4256.89
c_2395_2955_i 2395 2395_2955 4.67522e-10
r_2955_3515_e 2955 3515 13758.3
r_2955_3515_i 2955_3515 3515 95645.6
c_2955_3515_i 2955 2955_3515 9.36084e-12
r_156_716_e 156 716 13376.4
r_156_716_i 156_716 716 93218.1
c_156_716_i 156 156_716 2.08965e-09
r_716_1276_e 716 1276 13376.4
r_716_1276_i 716_1276 1276 93218.1
c_716_1276_i 716 716_1276 2.08965e-09
r_1276_1836_e 1276 1836 396.697
r_1276_1836_i 1276_1836 1836 1005.27
c_1276_1836_i 1276 1276_1836 1.65796e-10
r_1836_2396_e 1836 2396 836.944
r_1836_2396_i 1836_2396 2396 4256.89
c_1836_2396_i 1836 1836_2396 4.67522e-10
r_2396_2956_e 2396 2956 836.944
r_2396_2956_i 2396_2956 2956 4256.89
c_2396_2956_i 2396 2396_2956 4.67522e-10
r_2956_3516_e 2956 3516 13758.3
r_2956_3516_i 2956_3516 3516 95645.6
c_2956_3516_i 2956 2956_3516 9.36084e-12
r_157_717_e 157 717 13376.4
r_157_717_i 157_717 717 93218.1
c_157_717_i 157 157_717 2.08965e-09
r_717_1277_e 717 1277 13376.4
r_717_1277_i 717_1277 1277 93218.1
c_717_1277_i 717 717_1277 2.08965e-09
r_1277_1837_e 1277 1837 836.944
r_1277_1837_i 1277_1837 1837 4256.89
c_1277_1837_i 1277 1277_1837 4.67522e-10
r_1837_2397_e 1837 2397 836.944
r_1837_2397_i 1837_2397 2397 4256.89
c_1837_2397_i 1837 1837_2397 4.67522e-10
r_2397_2957_e 2397 2957 836.944
r_2397_2957_i 2397_2957 2957 4256.89
c_2397_2957_i 2397 2397_2957 4.67522e-10
r_2957_3517_e 2957 3517 13758.3
r_2957_3517_i 2957_3517 3517 95645.6
c_2957_3517_i 2957 2957_3517 9.36084e-12
r_158_718_e 158 718 13376.4
r_158_718_i 158_718 718 93218.1
c_158_718_i 158 158_718 2.08965e-09
r_718_1278_e 718 1278 13376.4
r_718_1278_i 718_1278 1278 93218.1
c_718_1278_i 718 718_1278 2.08965e-09
r_1278_1838_e 1278 1838 836.944
r_1278_1838_i 1278_1838 1838 4256.89
c_1278_1838_i 1278 1278_1838 4.67522e-10
r_1838_2398_e 1838 2398 836.944
r_1838_2398_i 1838_2398 2398 4256.89
c_1838_2398_i 1838 1838_2398 4.67522e-10
r_2398_2958_e 2398 2958 836.944
r_2398_2958_i 2398_2958 2958 4256.89
c_2398_2958_i 2398 2398_2958 4.67522e-10
r_2958_3518_e 2958 3518 13758.3
r_2958_3518_i 2958_3518 3518 95645.6
c_2958_3518_i 2958 2958_3518 9.36084e-12
r_159_719_e 159 719 13376.4
r_159_719_i 159_719 719 93218.1
c_159_719_i 159 159_719 2.08965e-09
r_719_1279_e 719 1279 13376.4
r_719_1279_i 719_1279 1279 93218.1
c_719_1279_i 719 719_1279 2.08965e-09
r_1279_1839_e 1279 1839 836.944
r_1279_1839_i 1279_1839 1839 4256.89
c_1279_1839_i 1279 1279_1839 4.67522e-10
r_1839_2399_e 1839 2399 836.944
r_1839_2399_i 1839_2399 2399 4256.89
c_1839_2399_i 1839 1839_2399 4.67522e-10
r_2399_2959_e 2399 2959 836.944
r_2399_2959_i 2399_2959 2959 4256.89
c_2399_2959_i 2399 2399_2959 4.67522e-10
r_2959_3519_e 2959 3519 13758.3
r_2959_3519_i 2959_3519 3519 95645.6
c_2959_3519_i 2959 2959_3519 9.36084e-12
r_160_720_e 160 720 13376.4
r_160_720_i 160_720 720 93218.1
c_160_720_i 160 160_720 2.08965e-09
r_720_1280_e 720 1280 13376.4
r_720_1280_i 720_1280 1280 93218.1
c_720_1280_i 720 720_1280 2.08965e-09
r_1280_1840_e 1280 1840 836.944
r_1280_1840_i 1280_1840 1840 4256.89
c_1280_1840_i 1280 1280_1840 4.67522e-10
r_1840_2400_e 1840 2400 836.944
r_1840_2400_i 1840_2400 2400 4256.89
c_1840_2400_i 1840 1840_2400 4.67522e-10
r_2400_2960_e 2400 2960 836.944
r_2400_2960_i 2400_2960 2960 4256.89
c_2400_2960_i 2400 2400_2960 4.67522e-10
r_2960_3520_e 2960 3520 13758.3
r_2960_3520_i 2960_3520 3520 95645.6
c_2960_3520_i 2960 2960_3520 9.36084e-12
r_161_721_e 161 721 13376.4
r_161_721_i 161_721 721 93218.1
c_161_721_i 161 161_721 2.08965e-09
r_721_1281_e 721 1281 13376.4
r_721_1281_i 721_1281 1281 93218.1
c_721_1281_i 721 721_1281 2.08965e-09
r_1281_1841_e 1281 1841 13376.4
r_1281_1841_i 1281_1841 1841 93218.1
c_1281_1841_i 1281 1281_1841 2.08965e-09
r_1841_2401_e 1841 2401 13376.4
r_1841_2401_i 1841_2401 2401 93218.1
c_1841_2401_i 1841 1841_2401 2.08965e-09
r_2401_2961_e 2401 2961 13376.4
r_2401_2961_i 2401_2961 2961 93218.1
c_2401_2961_i 2401 2401_2961 2.08965e-09
r_2961_3521_e 2961 3521 13376.4
r_2961_3521_i 2961_3521 3521 93218.1
c_2961_3521_i 2961 2961_3521 2.08965e-09
r_162_722_e 162 722 13376.4
r_162_722_i 162_722 722 93218.1
c_162_722_i 162 162_722 2.08965e-09
r_722_1282_e 722 1282 13376.4
r_722_1282_i 722_1282 1282 93218.1
c_722_1282_i 722 722_1282 2.08965e-09
r_1282_1842_e 1282 1842 13376.4
r_1282_1842_i 1282_1842 1842 93218.1
c_1282_1842_i 1282 1282_1842 2.08965e-09
r_1842_2402_e 1842 2402 13376.4
r_1842_2402_i 1842_2402 2402 93218.1
c_1842_2402_i 1842 1842_2402 2.08965e-09
r_2402_2962_e 2402 2962 13376.4
r_2402_2962_i 2402_2962 2962 93218.1
c_2402_2962_i 2402 2402_2962 2.08965e-09
r_2962_3522_e 2962 3522 13376.4
r_2962_3522_i 2962_3522 3522 93218.1
c_2962_3522_i 2962 2962_3522 2.08965e-09
r_163_723_e 163 723 13376.4
r_163_723_i 163_723 723 93218.1
c_163_723_i 163 163_723 2.08965e-09
r_723_1283_e 723 1283 13376.4
r_723_1283_i 723_1283 1283 93218.1
c_723_1283_i 723 723_1283 2.08965e-09
r_1283_1843_e 1283 1843 836.944
r_1283_1843_i 1283_1843 1843 4256.89
c_1283_1843_i 1283 1283_1843 4.67522e-10
r_1843_2403_e 1843 2403 836.944
r_1843_2403_i 1843_2403 2403 4256.89
c_1843_2403_i 1843 1843_2403 4.67522e-10
r_2403_2963_e 2403 2963 836.944
r_2403_2963_i 2403_2963 2963 4256.89
c_2403_2963_i 2403 2403_2963 4.67522e-10
r_2963_3523_e 2963 3523 836.944
r_2963_3523_i 2963_3523 3523 4256.89
c_2963_3523_i 2963 2963_3523 4.67522e-10
r_164_724_e 164 724 13376.4
r_164_724_i 164_724 724 93218.1
c_164_724_i 164 164_724 2.08965e-09
r_724_1284_e 724 1284 13376.4
r_724_1284_i 724_1284 1284 93218.1
c_724_1284_i 724 724_1284 2.08965e-09
r_1284_1844_e 1284 1844 836.944
r_1284_1844_i 1284_1844 1844 4256.89
c_1284_1844_i 1284 1284_1844 4.67522e-10
r_1844_2404_e 1844 2404 836.944
r_1844_2404_i 1844_2404 2404 4256.89
c_1844_2404_i 1844 1844_2404 4.67522e-10
r_2404_2964_e 2404 2964 836.944
r_2404_2964_i 2404_2964 2964 4256.89
c_2404_2964_i 2404 2404_2964 4.67522e-10
r_2964_3524_e 2964 3524 13758.3
r_2964_3524_i 2964_3524 3524 95645.6
c_2964_3524_i 2964 2964_3524 9.36084e-12
r_165_725_e 165 725 13376.4
r_165_725_i 165_725 725 93218.1
c_165_725_i 165 165_725 2.08965e-09
r_725_1285_e 725 1285 13376.4
r_725_1285_i 725_1285 1285 93218.1
c_725_1285_i 725 725_1285 2.08965e-09
r_1285_1845_e 1285 1845 836.944
r_1285_1845_i 1285_1845 1845 4256.89
c_1285_1845_i 1285 1285_1845 4.67522e-10
r_1845_2405_e 1845 2405 836.944
r_1845_2405_i 1845_2405 2405 4256.89
c_1845_2405_i 1845 1845_2405 4.67522e-10
r_2405_2965_e 2405 2965 836.944
r_2405_2965_i 2405_2965 2965 4256.89
c_2405_2965_i 2405 2405_2965 4.67522e-10
r_2965_3525_e 2965 3525 13758.3
r_2965_3525_i 2965_3525 3525 95645.6
c_2965_3525_i 2965 2965_3525 9.36084e-12
r_166_726_e 166 726 13376.4
r_166_726_i 166_726 726 93218.1
c_166_726_i 166 166_726 2.08965e-09
r_726_1286_e 726 1286 13376.4
r_726_1286_i 726_1286 1286 93218.1
c_726_1286_i 726 726_1286 2.08965e-09
r_1286_1846_e 1286 1846 836.944
r_1286_1846_i 1286_1846 1846 4256.89
c_1286_1846_i 1286 1286_1846 4.67522e-10
r_1846_2406_e 1846 2406 836.944
r_1846_2406_i 1846_2406 2406 4256.89
c_1846_2406_i 1846 1846_2406 4.67522e-10
r_2406_2966_e 2406 2966 836.944
r_2406_2966_i 2406_2966 2966 4256.89
c_2406_2966_i 2406 2406_2966 4.67522e-10
r_2966_3526_e 2966 3526 13758.3
r_2966_3526_i 2966_3526 3526 95645.6
c_2966_3526_i 2966 2966_3526 9.36084e-12
r_167_727_e 167 727 13376.4
r_167_727_i 167_727 727 93218.1
c_167_727_i 167 167_727 2.08965e-09
r_727_1287_e 727 1287 13376.4
r_727_1287_i 727_1287 1287 93218.1
c_727_1287_i 727 727_1287 2.08965e-09
r_1287_1847_e 1287 1847 836.944
r_1287_1847_i 1287_1847 1847 4256.89
c_1287_1847_i 1287 1287_1847 4.67522e-10
r_1847_2407_e 1847 2407 836.944
r_1847_2407_i 1847_2407 2407 4256.89
c_1847_2407_i 1847 1847_2407 4.67522e-10
r_2407_2967_e 2407 2967 836.944
r_2407_2967_i 2407_2967 2967 4256.89
c_2407_2967_i 2407 2407_2967 4.67522e-10
r_2967_3527_e 2967 3527 13758.3
r_2967_3527_i 2967_3527 3527 95645.6
c_2967_3527_i 2967 2967_3527 9.36084e-12
r_168_728_e 168 728 13376.4
r_168_728_i 168_728 728 93218.1
c_168_728_i 168 168_728 2.08965e-09
r_728_1288_e 728 1288 13376.4
r_728_1288_i 728_1288 1288 93218.1
c_728_1288_i 728 728_1288 2.08965e-09
r_1288_1848_e 1288 1848 836.944
r_1288_1848_i 1288_1848 1848 4256.89
c_1288_1848_i 1288 1288_1848 4.67522e-10
r_1848_2408_e 1848 2408 836.944
r_1848_2408_i 1848_2408 2408 4256.89
c_1848_2408_i 1848 1848_2408 4.67522e-10
r_2408_2968_e 2408 2968 836.944
r_2408_2968_i 2408_2968 2968 4256.89
c_2408_2968_i 2408 2408_2968 4.67522e-10
r_2968_3528_e 2968 3528 13758.3
r_2968_3528_i 2968_3528 3528 95645.6
c_2968_3528_i 2968 2968_3528 9.36084e-12
r_169_729_e 169 729 13376.4
r_169_729_i 169_729 729 93218.1
c_169_729_i 169 169_729 2.08965e-09
r_729_1289_e 729 1289 13376.4
r_729_1289_i 729_1289 1289 93218.1
c_729_1289_i 729 729_1289 2.08965e-09
r_1289_1849_e 1289 1849 836.944
r_1289_1849_i 1289_1849 1849 4256.89
c_1289_1849_i 1289 1289_1849 4.67522e-10
r_1849_2409_e 1849 2409 836.944
r_1849_2409_i 1849_2409 2409 4256.89
c_1849_2409_i 1849 1849_2409 4.67522e-10
r_2409_2969_e 2409 2969 836.944
r_2409_2969_i 2409_2969 2969 4256.89
c_2409_2969_i 2409 2409_2969 4.67522e-10
r_2969_3529_e 2969 3529 13758.3
r_2969_3529_i 2969_3529 3529 95645.6
c_2969_3529_i 2969 2969_3529 9.36084e-12
r_170_730_e 170 730 13376.4
r_170_730_i 170_730 730 93218.1
c_170_730_i 170 170_730 2.08965e-09
r_730_1290_e 730 1290 13376.4
r_730_1290_i 730_1290 1290 93218.1
c_730_1290_i 730 730_1290 2.08965e-09
r_1290_1850_e 1290 1850 836.944
r_1290_1850_i 1290_1850 1850 4256.89
c_1290_1850_i 1290 1290_1850 4.67522e-10
r_1850_2410_e 1850 2410 836.944
r_1850_2410_i 1850_2410 2410 4256.89
c_1850_2410_i 1850 1850_2410 4.67522e-10
r_2410_2970_e 2410 2970 836.944
r_2410_2970_i 2410_2970 2970 4256.89
c_2410_2970_i 2410 2410_2970 4.67522e-10
r_2970_3530_e 2970 3530 13758.3
r_2970_3530_i 2970_3530 3530 95645.6
c_2970_3530_i 2970 2970_3530 9.36084e-12
r_171_731_e 171 731 13376.4
r_171_731_i 171_731 731 93218.1
c_171_731_i 171 171_731 2.08965e-09
r_731_1291_e 731 1291 13376.4
r_731_1291_i 731_1291 1291 93218.1
c_731_1291_i 731 731_1291 2.08965e-09
r_1291_1851_e 1291 1851 396.689
r_1291_1851_i 1291_1851 1851 1005.25
c_1291_1851_i 1291 1291_1851 1.65799e-10
r_1851_2411_e 1851 2411 836.944
r_1851_2411_i 1851_2411 2411 4256.89
c_1851_2411_i 1851 1851_2411 4.67522e-10
r_2411_2971_e 2411 2971 836.944
r_2411_2971_i 2411_2971 2971 4256.89
c_2411_2971_i 2411 2411_2971 4.67522e-10
r_2971_3531_e 2971 3531 13758.3
r_2971_3531_i 2971_3531 3531 95645.6
c_2971_3531_i 2971 2971_3531 9.36084e-12
r_172_732_e 172 732 13376.4
r_172_732_i 172_732 732 93218.1
c_172_732_i 172 172_732 2.08965e-09
r_732_1292_e 732 1292 13376.4
r_732_1292_i 732_1292 1292 93218.1
c_732_1292_i 732 732_1292 2.08965e-09
r_1292_1852_e 1292 1852 396.689
r_1292_1852_i 1292_1852 1852 1005.25
c_1292_1852_i 1292 1292_1852 1.65799e-10
r_1852_2412_e 1852 2412 836.944
r_1852_2412_i 1852_2412 2412 4256.89
c_1852_2412_i 1852 1852_2412 4.67522e-10
r_2412_2972_e 2412 2972 836.944
r_2412_2972_i 2412_2972 2972 4256.89
c_2412_2972_i 2412 2412_2972 4.67522e-10
r_2972_3532_e 2972 3532 13758.3
r_2972_3532_i 2972_3532 3532 95645.6
c_2972_3532_i 2972 2972_3532 9.36084e-12
r_173_733_e 173 733 13376.4
r_173_733_i 173_733 733 93218.1
c_173_733_i 173 173_733 2.08965e-09
r_733_1293_e 733 1293 13376.4
r_733_1293_i 733_1293 1293 93218.1
c_733_1293_i 733 733_1293 2.08965e-09
r_1293_1853_e 1293 1853 836.944
r_1293_1853_i 1293_1853 1853 4256.89
c_1293_1853_i 1293 1293_1853 4.67522e-10
r_1853_2413_e 1853 2413 836.944
r_1853_2413_i 1853_2413 2413 4256.89
c_1853_2413_i 1853 1853_2413 4.67522e-10
r_2413_2973_e 2413 2973 836.944
r_2413_2973_i 2413_2973 2973 4256.89
c_2413_2973_i 2413 2413_2973 4.67522e-10
r_2973_3533_e 2973 3533 13758.3
r_2973_3533_i 2973_3533 3533 95645.6
c_2973_3533_i 2973 2973_3533 9.36084e-12
r_174_734_e 174 734 13376.4
r_174_734_i 174_734 734 93218.1
c_174_734_i 174 174_734 2.08965e-09
r_734_1294_e 734 1294 13376.4
r_734_1294_i 734_1294 1294 93218.1
c_734_1294_i 734 734_1294 2.08965e-09
r_1294_1854_e 1294 1854 836.944
r_1294_1854_i 1294_1854 1854 4256.89
c_1294_1854_i 1294 1294_1854 4.67522e-10
r_1854_2414_e 1854 2414 836.944
r_1854_2414_i 1854_2414 2414 4256.89
c_1854_2414_i 1854 1854_2414 4.67522e-10
r_2414_2974_e 2414 2974 836.944
r_2414_2974_i 2414_2974 2974 4256.89
c_2414_2974_i 2414 2414_2974 4.67522e-10
r_2974_3534_e 2974 3534 13758.3
r_2974_3534_i 2974_3534 3534 95645.6
c_2974_3534_i 2974 2974_3534 9.36084e-12
r_175_735_e 175 735 13376.4
r_175_735_i 175_735 735 93218.1
c_175_735_i 175 175_735 2.08965e-09
r_735_1295_e 735 1295 13376.4
r_735_1295_i 735_1295 1295 93218.1
c_735_1295_i 735 735_1295 2.08965e-09
r_1295_1855_e 1295 1855 836.944
r_1295_1855_i 1295_1855 1855 4256.89
c_1295_1855_i 1295 1295_1855 4.67522e-10
r_1855_2415_e 1855 2415 836.944
r_1855_2415_i 1855_2415 2415 4256.89
c_1855_2415_i 1855 1855_2415 4.67522e-10
r_2415_2975_e 2415 2975 836.944
r_2415_2975_i 2415_2975 2975 4256.89
c_2415_2975_i 2415 2415_2975 4.67522e-10
r_2975_3535_e 2975 3535 13758.3
r_2975_3535_i 2975_3535 3535 95645.6
c_2975_3535_i 2975 2975_3535 9.36084e-12
r_176_736_e 176 736 13376.4
r_176_736_i 176_736 736 93218.1
c_176_736_i 176 176_736 2.08965e-09
r_736_1296_e 736 1296 13376.4
r_736_1296_i 736_1296 1296 93218.1
c_736_1296_i 736 736_1296 2.08965e-09
r_1296_1856_e 1296 1856 836.944
r_1296_1856_i 1296_1856 1856 4256.89
c_1296_1856_i 1296 1296_1856 4.67522e-10
r_1856_2416_e 1856 2416 836.944
r_1856_2416_i 1856_2416 2416 4256.89
c_1856_2416_i 1856 1856_2416 4.67522e-10
r_2416_2976_e 2416 2976 836.944
r_2416_2976_i 2416_2976 2976 4256.89
c_2416_2976_i 2416 2416_2976 4.67522e-10
r_2976_3536_e 2976 3536 13758.3
r_2976_3536_i 2976_3536 3536 95645.6
c_2976_3536_i 2976 2976_3536 9.36084e-12
r_177_737_e 177 737 13376.4
r_177_737_i 177_737 737 93218.1
c_177_737_i 177 177_737 2.08965e-09
r_737_1297_e 737 1297 13376.4
r_737_1297_i 737_1297 1297 93218.1
c_737_1297_i 737 737_1297 2.08965e-09
r_1297_1857_e 1297 1857 13376.4
r_1297_1857_i 1297_1857 1857 93218.1
c_1297_1857_i 1297 1297_1857 2.08965e-09
r_1857_2417_e 1857 2417 13376.4
r_1857_2417_i 1857_2417 2417 93218.1
c_1857_2417_i 1857 1857_2417 2.08965e-09
r_2417_2977_e 2417 2977 13376.4
r_2417_2977_i 2417_2977 2977 93218.1
c_2417_2977_i 2417 2417_2977 2.08965e-09
r_2977_3537_e 2977 3537 13376.4
r_2977_3537_i 2977_3537 3537 93218.1
c_2977_3537_i 2977 2977_3537 2.08965e-09
r_178_738_e 178 738 13376.4
r_178_738_i 178_738 738 93218.1
c_178_738_i 178 178_738 2.08965e-09
r_738_1298_e 738 1298 13376.4
r_738_1298_i 738_1298 1298 93218.1
c_738_1298_i 738 738_1298 2.08965e-09
r_1298_1858_e 1298 1858 13376.4
r_1298_1858_i 1298_1858 1858 93218.1
c_1298_1858_i 1298 1298_1858 2.08965e-09
r_1858_2418_e 1858 2418 13376.4
r_1858_2418_i 1858_2418 2418 93218.1
c_1858_2418_i 1858 1858_2418 2.08965e-09
r_2418_2978_e 2418 2978 13376.4
r_2418_2978_i 2418_2978 2978 93218.1
c_2418_2978_i 2418 2418_2978 2.08965e-09
r_2978_3538_e 2978 3538 13376.4
r_2978_3538_i 2978_3538 3538 93218.1
c_2978_3538_i 2978 2978_3538 2.08965e-09
r_179_739_e 179 739 13376.4
r_179_739_i 179_739 739 93218.1
c_179_739_i 179 179_739 2.08965e-09
r_739_1299_e 739 1299 13376.4
r_739_1299_i 739_1299 1299 93218.1
c_739_1299_i 739 739_1299 2.08965e-09
r_1299_1859_e 1299 1859 836.944
r_1299_1859_i 1299_1859 1859 4256.89
c_1299_1859_i 1299 1299_1859 4.67522e-10
r_1859_2419_e 1859 2419 836.944
r_1859_2419_i 1859_2419 2419 4256.89
c_1859_2419_i 1859 1859_2419 4.67522e-10
r_2419_2979_e 2419 2979 836.944
r_2419_2979_i 2419_2979 2979 4256.89
c_2419_2979_i 2419 2419_2979 4.67522e-10
r_2979_3539_e 2979 3539 836.944
r_2979_3539_i 2979_3539 3539 4256.89
c_2979_3539_i 2979 2979_3539 4.67522e-10
r_180_740_e 180 740 13376.4
r_180_740_i 180_740 740 93218.1
c_180_740_i 180 180_740 2.08965e-09
r_740_1300_e 740 1300 13376.4
r_740_1300_i 740_1300 1300 93218.1
c_740_1300_i 740 740_1300 2.08965e-09
r_1300_1860_e 1300 1860 836.944
r_1300_1860_i 1300_1860 1860 4256.89
c_1300_1860_i 1300 1300_1860 4.67522e-10
r_1860_2420_e 1860 2420 836.944
r_1860_2420_i 1860_2420 2420 4256.89
c_1860_2420_i 1860 1860_2420 4.67522e-10
r_2420_2980_e 2420 2980 836.944
r_2420_2980_i 2420_2980 2980 4256.89
c_2420_2980_i 2420 2420_2980 4.67522e-10
r_2980_3540_e 2980 3540 13758.3
r_2980_3540_i 2980_3540 3540 95645.6
c_2980_3540_i 2980 2980_3540 9.36084e-12
r_181_741_e 181 741 13376.4
r_181_741_i 181_741 741 93218.1
c_181_741_i 181 181_741 2.08965e-09
r_741_1301_e 741 1301 13376.4
r_741_1301_i 741_1301 1301 93218.1
c_741_1301_i 741 741_1301 2.08965e-09
r_1301_1861_e 1301 1861 836.944
r_1301_1861_i 1301_1861 1861 4256.89
c_1301_1861_i 1301 1301_1861 4.67522e-10
r_1861_2421_e 1861 2421 836.944
r_1861_2421_i 1861_2421 2421 4256.89
c_1861_2421_i 1861 1861_2421 4.67522e-10
r_2421_2981_e 2421 2981 836.944
r_2421_2981_i 2421_2981 2981 4256.89
c_2421_2981_i 2421 2421_2981 4.67522e-10
r_2981_3541_e 2981 3541 13758.3
r_2981_3541_i 2981_3541 3541 95645.6
c_2981_3541_i 2981 2981_3541 9.36084e-12
r_182_742_e 182 742 13376.4
r_182_742_i 182_742 742 93218.1
c_182_742_i 182 182_742 2.08965e-09
r_742_1302_e 742 1302 13376.4
r_742_1302_i 742_1302 1302 93218.1
c_742_1302_i 742 742_1302 2.08965e-09
r_1302_1862_e 1302 1862 836.944
r_1302_1862_i 1302_1862 1862 4256.89
c_1302_1862_i 1302 1302_1862 4.67522e-10
r_1862_2422_e 1862 2422 836.944
r_1862_2422_i 1862_2422 2422 4256.89
c_1862_2422_i 1862 1862_2422 4.67522e-10
r_2422_2982_e 2422 2982 836.944
r_2422_2982_i 2422_2982 2982 4256.89
c_2422_2982_i 2422 2422_2982 4.67522e-10
r_2982_3542_e 2982 3542 13758.3
r_2982_3542_i 2982_3542 3542 95645.6
c_2982_3542_i 2982 2982_3542 9.36084e-12
r_183_743_e 183 743 13376.4
r_183_743_i 183_743 743 93218.1
c_183_743_i 183 183_743 2.08965e-09
r_743_1303_e 743 1303 13376.4
r_743_1303_i 743_1303 1303 93218.1
c_743_1303_i 743 743_1303 2.08965e-09
r_1303_1863_e 1303 1863 836.944
r_1303_1863_i 1303_1863 1863 4256.89
c_1303_1863_i 1303 1303_1863 4.67522e-10
r_1863_2423_e 1863 2423 836.944
r_1863_2423_i 1863_2423 2423 4256.89
c_1863_2423_i 1863 1863_2423 4.67522e-10
r_2423_2983_e 2423 2983 836.944
r_2423_2983_i 2423_2983 2983 4256.89
c_2423_2983_i 2423 2423_2983 4.67522e-10
r_2983_3543_e 2983 3543 13758.3
r_2983_3543_i 2983_3543 3543 95645.6
c_2983_3543_i 2983 2983_3543 9.36084e-12
r_184_744_e 184 744 13376.4
r_184_744_i 184_744 744 93218.1
c_184_744_i 184 184_744 2.08965e-09
r_744_1304_e 744 1304 13376.4
r_744_1304_i 744_1304 1304 93218.1
c_744_1304_i 744 744_1304 2.08965e-09
r_1304_1864_e 1304 1864 836.944
r_1304_1864_i 1304_1864 1864 4256.89
c_1304_1864_i 1304 1304_1864 4.67522e-10
r_1864_2424_e 1864 2424 836.944
r_1864_2424_i 1864_2424 2424 4256.89
c_1864_2424_i 1864 1864_2424 4.67522e-10
r_2424_2984_e 2424 2984 836.944
r_2424_2984_i 2424_2984 2984 4256.89
c_2424_2984_i 2424 2424_2984 4.67522e-10
r_2984_3544_e 2984 3544 13758.3
r_2984_3544_i 2984_3544 3544 95645.6
c_2984_3544_i 2984 2984_3544 9.36084e-12
r_185_745_e 185 745 13376.4
r_185_745_i 185_745 745 93218.1
c_185_745_i 185 185_745 2.08965e-09
r_745_1305_e 745 1305 13376.4
r_745_1305_i 745_1305 1305 93218.1
c_745_1305_i 745 745_1305 2.08965e-09
r_1305_1865_e 1305 1865 836.944
r_1305_1865_i 1305_1865 1865 4256.89
c_1305_1865_i 1305 1305_1865 4.67522e-10
r_1865_2425_e 1865 2425 836.944
r_1865_2425_i 1865_2425 2425 4256.89
c_1865_2425_i 1865 1865_2425 4.67522e-10
r_2425_2985_e 2425 2985 836.944
r_2425_2985_i 2425_2985 2985 4256.89
c_2425_2985_i 2425 2425_2985 4.67522e-10
r_2985_3545_e 2985 3545 13758.3
r_2985_3545_i 2985_3545 3545 95645.6
c_2985_3545_i 2985 2985_3545 9.36084e-12
r_186_746_e 186 746 13376.4
r_186_746_i 186_746 746 93218.1
c_186_746_i 186 186_746 2.08965e-09
r_746_1306_e 746 1306 13376.4
r_746_1306_i 746_1306 1306 93218.1
c_746_1306_i 746 746_1306 2.08965e-09
r_1306_1866_e 1306 1866 836.944
r_1306_1866_i 1306_1866 1866 4256.89
c_1306_1866_i 1306 1306_1866 4.67522e-10
r_1866_2426_e 1866 2426 836.944
r_1866_2426_i 1866_2426 2426 4256.89
c_1866_2426_i 1866 1866_2426 4.67522e-10
r_2426_2986_e 2426 2986 836.944
r_2426_2986_i 2426_2986 2986 4256.89
c_2426_2986_i 2426 2426_2986 4.67522e-10
r_2986_3546_e 2986 3546 13758.3
r_2986_3546_i 2986_3546 3546 95645.6
c_2986_3546_i 2986 2986_3546 9.36084e-12
r_187_747_e 187 747 13376.4
r_187_747_i 187_747 747 93218.1
c_187_747_i 187 187_747 2.08965e-09
r_747_1307_e 747 1307 13376.4
r_747_1307_i 747_1307 1307 93218.1
c_747_1307_i 747 747_1307 2.08965e-09
r_1307_1867_e 1307 1867 396.68
r_1307_1867_i 1307_1867 1867 1005.22
c_1307_1867_i 1307 1307_1867 1.65803e-10
r_1867_2427_e 1867 2427 836.944
r_1867_2427_i 1867_2427 2427 4256.89
c_1867_2427_i 1867 1867_2427 4.67522e-10
r_2427_2987_e 2427 2987 836.944
r_2427_2987_i 2427_2987 2987 4256.89
c_2427_2987_i 2427 2427_2987 4.67522e-10
r_2987_3547_e 2987 3547 13758.3
r_2987_3547_i 2987_3547 3547 95645.6
c_2987_3547_i 2987 2987_3547 9.36084e-12
r_188_748_e 188 748 13376.4
r_188_748_i 188_748 748 93218.1
c_188_748_i 188 188_748 2.08965e-09
r_748_1308_e 748 1308 13376.4
r_748_1308_i 748_1308 1308 93218.1
c_748_1308_i 748 748_1308 2.08965e-09
r_1308_1868_e 1308 1868 396.68
r_1308_1868_i 1308_1868 1868 1005.22
c_1308_1868_i 1308 1308_1868 1.65803e-10
r_1868_2428_e 1868 2428 836.944
r_1868_2428_i 1868_2428 2428 4256.89
c_1868_2428_i 1868 1868_2428 4.67522e-10
r_2428_2988_e 2428 2988 836.944
r_2428_2988_i 2428_2988 2988 4256.89
c_2428_2988_i 2428 2428_2988 4.67522e-10
r_2988_3548_e 2988 3548 13758.3
r_2988_3548_i 2988_3548 3548 95645.6
c_2988_3548_i 2988 2988_3548 9.36084e-12
r_189_749_e 189 749 13376.4
r_189_749_i 189_749 749 93218.1
c_189_749_i 189 189_749 2.08965e-09
r_749_1309_e 749 1309 13376.4
r_749_1309_i 749_1309 1309 93218.1
c_749_1309_i 749 749_1309 2.08965e-09
r_1309_1869_e 1309 1869 836.944
r_1309_1869_i 1309_1869 1869 4256.89
c_1309_1869_i 1309 1309_1869 4.67522e-10
r_1869_2429_e 1869 2429 836.944
r_1869_2429_i 1869_2429 2429 4256.89
c_1869_2429_i 1869 1869_2429 4.67522e-10
r_2429_2989_e 2429 2989 836.944
r_2429_2989_i 2429_2989 2989 4256.89
c_2429_2989_i 2429 2429_2989 4.67522e-10
r_2989_3549_e 2989 3549 13758.3
r_2989_3549_i 2989_3549 3549 95645.6
c_2989_3549_i 2989 2989_3549 9.36084e-12
r_190_750_e 190 750 13376.4
r_190_750_i 190_750 750 93218.1
c_190_750_i 190 190_750 2.08965e-09
r_750_1310_e 750 1310 13376.4
r_750_1310_i 750_1310 1310 93218.1
c_750_1310_i 750 750_1310 2.08965e-09
r_1310_1870_e 1310 1870 836.944
r_1310_1870_i 1310_1870 1870 4256.89
c_1310_1870_i 1310 1310_1870 4.67522e-10
r_1870_2430_e 1870 2430 836.944
r_1870_2430_i 1870_2430 2430 4256.89
c_1870_2430_i 1870 1870_2430 4.67522e-10
r_2430_2990_e 2430 2990 836.944
r_2430_2990_i 2430_2990 2990 4256.89
c_2430_2990_i 2430 2430_2990 4.67522e-10
r_2990_3550_e 2990 3550 13758.3
r_2990_3550_i 2990_3550 3550 95645.6
c_2990_3550_i 2990 2990_3550 9.36084e-12
r_191_751_e 191 751 13376.4
r_191_751_i 191_751 751 93218.1
c_191_751_i 191 191_751 2.08965e-09
r_751_1311_e 751 1311 13376.4
r_751_1311_i 751_1311 1311 93218.1
c_751_1311_i 751 751_1311 2.08965e-09
r_1311_1871_e 1311 1871 836.944
r_1311_1871_i 1311_1871 1871 4256.89
c_1311_1871_i 1311 1311_1871 4.67522e-10
r_1871_2431_e 1871 2431 836.944
r_1871_2431_i 1871_2431 2431 4256.89
c_1871_2431_i 1871 1871_2431 4.67522e-10
r_2431_2991_e 2431 2991 836.944
r_2431_2991_i 2431_2991 2991 4256.89
c_2431_2991_i 2431 2431_2991 4.67522e-10
r_2991_3551_e 2991 3551 13758.3
r_2991_3551_i 2991_3551 3551 95645.6
c_2991_3551_i 2991 2991_3551 9.36084e-12
r_192_752_e 192 752 13376.4
r_192_752_i 192_752 752 93218.1
c_192_752_i 192 192_752 2.08965e-09
r_752_1312_e 752 1312 13376.4
r_752_1312_i 752_1312 1312 93218.1
c_752_1312_i 752 752_1312 2.08965e-09
r_1312_1872_e 1312 1872 836.944
r_1312_1872_i 1312_1872 1872 4256.89
c_1312_1872_i 1312 1312_1872 4.67522e-10
r_1872_2432_e 1872 2432 836.944
r_1872_2432_i 1872_2432 2432 4256.89
c_1872_2432_i 1872 1872_2432 4.67522e-10
r_2432_2992_e 2432 2992 836.944
r_2432_2992_i 2432_2992 2992 4256.89
c_2432_2992_i 2432 2432_2992 4.67522e-10
r_2992_3552_e 2992 3552 13758.3
r_2992_3552_i 2992_3552 3552 95645.6
c_2992_3552_i 2992 2992_3552 9.36084e-12
r_193_753_e 193 753 13376.4
r_193_753_i 193_753 753 93218.1
c_193_753_i 193 193_753 2.08965e-09
r_753_1313_e 753 1313 13376.4
r_753_1313_i 753_1313 1313 93218.1
c_753_1313_i 753 753_1313 2.08965e-09
r_1313_1873_e 1313 1873 13376.4
r_1313_1873_i 1313_1873 1873 93218.1
c_1313_1873_i 1313 1313_1873 2.08965e-09
r_1873_2433_e 1873 2433 13376.4
r_1873_2433_i 1873_2433 2433 93218.1
c_1873_2433_i 1873 1873_2433 2.08965e-09
r_2433_2993_e 2433 2993 13376.4
r_2433_2993_i 2433_2993 2993 93218.1
c_2433_2993_i 2433 2433_2993 2.08965e-09
r_2993_3553_e 2993 3553 13376.4
r_2993_3553_i 2993_3553 3553 93218.1
c_2993_3553_i 2993 2993_3553 2.08965e-09
r_194_754_e 194 754 13376.4
r_194_754_i 194_754 754 93218.1
c_194_754_i 194 194_754 2.08965e-09
r_754_1314_e 754 1314 13376.4
r_754_1314_i 754_1314 1314 93218.1
c_754_1314_i 754 754_1314 2.08965e-09
r_1314_1874_e 1314 1874 13376.4
r_1314_1874_i 1314_1874 1874 93218.1
c_1314_1874_i 1314 1314_1874 2.08965e-09
r_1874_2434_e 1874 2434 13376.4
r_1874_2434_i 1874_2434 2434 93218.1
c_1874_2434_i 1874 1874_2434 2.08965e-09
r_2434_2994_e 2434 2994 13376.4
r_2434_2994_i 2434_2994 2994 93218.1
c_2434_2994_i 2434 2434_2994 2.08965e-09
r_2994_3554_e 2994 3554 13376.4
r_2994_3554_i 2994_3554 3554 93218.1
c_2994_3554_i 2994 2994_3554 2.08965e-09
r_195_755_e 195 755 13376.4
r_195_755_i 195_755 755 93218.1
c_195_755_i 195 195_755 2.08965e-09
r_755_1315_e 755 1315 13376.4
r_755_1315_i 755_1315 1315 93218.1
c_755_1315_i 755 755_1315 2.08965e-09
r_1315_1875_e 1315 1875 836.944
r_1315_1875_i 1315_1875 1875 4256.89
c_1315_1875_i 1315 1315_1875 4.67522e-10
r_1875_2435_e 1875 2435 836.944
r_1875_2435_i 1875_2435 2435 4256.89
c_1875_2435_i 1875 1875_2435 4.67522e-10
r_2435_2995_e 2435 2995 836.944
r_2435_2995_i 2435_2995 2995 4256.89
c_2435_2995_i 2435 2435_2995 4.67522e-10
r_2995_3555_e 2995 3555 836.944
r_2995_3555_i 2995_3555 3555 4256.89
c_2995_3555_i 2995 2995_3555 4.67522e-10
r_196_756_e 196 756 13376.4
r_196_756_i 196_756 756 93218.1
c_196_756_i 196 196_756 2.08965e-09
r_756_1316_e 756 1316 13376.4
r_756_1316_i 756_1316 1316 93218.1
c_756_1316_i 756 756_1316 2.08965e-09
r_1316_1876_e 1316 1876 836.944
r_1316_1876_i 1316_1876 1876 4256.89
c_1316_1876_i 1316 1316_1876 4.67522e-10
r_1876_2436_e 1876 2436 836.944
r_1876_2436_i 1876_2436 2436 4256.89
c_1876_2436_i 1876 1876_2436 4.67522e-10
r_2436_2996_e 2436 2996 836.944
r_2436_2996_i 2436_2996 2996 4256.89
c_2436_2996_i 2436 2436_2996 4.67522e-10
r_2996_3556_e 2996 3556 13758.3
r_2996_3556_i 2996_3556 3556 95645.6
c_2996_3556_i 2996 2996_3556 9.36084e-12
r_197_757_e 197 757 13376.4
r_197_757_i 197_757 757 93218.1
c_197_757_i 197 197_757 2.08965e-09
r_757_1317_e 757 1317 13376.4
r_757_1317_i 757_1317 1317 93218.1
c_757_1317_i 757 757_1317 2.08965e-09
r_1317_1877_e 1317 1877 836.944
r_1317_1877_i 1317_1877 1877 4256.89
c_1317_1877_i 1317 1317_1877 4.67522e-10
r_1877_2437_e 1877 2437 836.944
r_1877_2437_i 1877_2437 2437 4256.89
c_1877_2437_i 1877 1877_2437 4.67522e-10
r_2437_2997_e 2437 2997 836.944
r_2437_2997_i 2437_2997 2997 4256.89
c_2437_2997_i 2437 2437_2997 4.67522e-10
r_2997_3557_e 2997 3557 13758.3
r_2997_3557_i 2997_3557 3557 95645.6
c_2997_3557_i 2997 2997_3557 9.36084e-12
r_198_758_e 198 758 13376.4
r_198_758_i 198_758 758 93218.1
c_198_758_i 198 198_758 2.08965e-09
r_758_1318_e 758 1318 13376.4
r_758_1318_i 758_1318 1318 93218.1
c_758_1318_i 758 758_1318 2.08965e-09
r_1318_1878_e 1318 1878 836.944
r_1318_1878_i 1318_1878 1878 4256.89
c_1318_1878_i 1318 1318_1878 4.67522e-10
r_1878_2438_e 1878 2438 836.944
r_1878_2438_i 1878_2438 2438 4256.89
c_1878_2438_i 1878 1878_2438 4.67522e-10
r_2438_2998_e 2438 2998 836.944
r_2438_2998_i 2438_2998 2998 4256.89
c_2438_2998_i 2438 2438_2998 4.67522e-10
r_2998_3558_e 2998 3558 13758.3
r_2998_3558_i 2998_3558 3558 95645.6
c_2998_3558_i 2998 2998_3558 9.36084e-12
r_199_759_e 199 759 13376.4
r_199_759_i 199_759 759 93218.1
c_199_759_i 199 199_759 2.08965e-09
r_759_1319_e 759 1319 13376.4
r_759_1319_i 759_1319 1319 93218.1
c_759_1319_i 759 759_1319 2.08965e-09
r_1319_1879_e 1319 1879 836.944
r_1319_1879_i 1319_1879 1879 4256.89
c_1319_1879_i 1319 1319_1879 4.67522e-10
r_1879_2439_e 1879 2439 836.944
r_1879_2439_i 1879_2439 2439 4256.89
c_1879_2439_i 1879 1879_2439 4.67522e-10
r_2439_2999_e 2439 2999 836.944
r_2439_2999_i 2439_2999 2999 4256.89
c_2439_2999_i 2439 2439_2999 4.67522e-10
r_2999_3559_e 2999 3559 13758.3
r_2999_3559_i 2999_3559 3559 95645.6
c_2999_3559_i 2999 2999_3559 9.36084e-12
r_200_760_e 200 760 13376.4
r_200_760_i 200_760 760 93218.1
c_200_760_i 200 200_760 2.08965e-09
r_760_1320_e 760 1320 13376.4
r_760_1320_i 760_1320 1320 93218.1
c_760_1320_i 760 760_1320 2.08965e-09
r_1320_1880_e 1320 1880 836.944
r_1320_1880_i 1320_1880 1880 4256.89
c_1320_1880_i 1320 1320_1880 4.67522e-10
r_1880_2440_e 1880 2440 836.944
r_1880_2440_i 1880_2440 2440 4256.89
c_1880_2440_i 1880 1880_2440 4.67522e-10
r_2440_3000_e 2440 3000 836.944
r_2440_3000_i 2440_3000 3000 4256.89
c_2440_3000_i 2440 2440_3000 4.67522e-10
r_3000_3560_e 3000 3560 13758.3
r_3000_3560_i 3000_3560 3560 95645.6
c_3000_3560_i 3000 3000_3560 9.36084e-12
r_201_761_e 201 761 13376.4
r_201_761_i 201_761 761 93218.1
c_201_761_i 201 201_761 2.08965e-09
r_761_1321_e 761 1321 13376.4
r_761_1321_i 761_1321 1321 93218.1
c_761_1321_i 761 761_1321 2.08965e-09
r_1321_1881_e 1321 1881 836.944
r_1321_1881_i 1321_1881 1881 4256.89
c_1321_1881_i 1321 1321_1881 4.67522e-10
r_1881_2441_e 1881 2441 836.944
r_1881_2441_i 1881_2441 2441 4256.89
c_1881_2441_i 1881 1881_2441 4.67522e-10
r_2441_3001_e 2441 3001 836.944
r_2441_3001_i 2441_3001 3001 4256.89
c_2441_3001_i 2441 2441_3001 4.67522e-10
r_3001_3561_e 3001 3561 13758.3
r_3001_3561_i 3001_3561 3561 95645.6
c_3001_3561_i 3001 3001_3561 9.36084e-12
r_202_762_e 202 762 13376.4
r_202_762_i 202_762 762 93218.1
c_202_762_i 202 202_762 2.08965e-09
r_762_1322_e 762 1322 13376.4
r_762_1322_i 762_1322 1322 93218.1
c_762_1322_i 762 762_1322 2.08965e-09
r_1322_1882_e 1322 1882 836.944
r_1322_1882_i 1322_1882 1882 4256.89
c_1322_1882_i 1322 1322_1882 4.67522e-10
r_1882_2442_e 1882 2442 836.944
r_1882_2442_i 1882_2442 2442 4256.89
c_1882_2442_i 1882 1882_2442 4.67522e-10
r_2442_3002_e 2442 3002 836.944
r_2442_3002_i 2442_3002 3002 4256.89
c_2442_3002_i 2442 2442_3002 4.67522e-10
r_3002_3562_e 3002 3562 13758.3
r_3002_3562_i 3002_3562 3562 95645.6
c_3002_3562_i 3002 3002_3562 9.36084e-12
r_203_763_e 203 763 13376.4
r_203_763_i 203_763 763 93218.1
c_203_763_i 203 203_763 2.08965e-09
r_763_1323_e 763 1323 13376.4
r_763_1323_i 763_1323 1323 93218.1
c_763_1323_i 763 763_1323 2.08965e-09
r_1323_1883_e 1323 1883 396.671
r_1323_1883_i 1323_1883 1883 1005.2
c_1323_1883_i 1323 1323_1883 1.65806e-10
r_1883_2443_e 1883 2443 836.944
r_1883_2443_i 1883_2443 2443 4256.89
c_1883_2443_i 1883 1883_2443 4.67522e-10
r_2443_3003_e 2443 3003 836.944
r_2443_3003_i 2443_3003 3003 4256.89
c_2443_3003_i 2443 2443_3003 4.67522e-10
r_3003_3563_e 3003 3563 13758.3
r_3003_3563_i 3003_3563 3563 95645.6
c_3003_3563_i 3003 3003_3563 9.36084e-12
r_204_764_e 204 764 13376.4
r_204_764_i 204_764 764 93218.1
c_204_764_i 204 204_764 2.08965e-09
r_764_1324_e 764 1324 13376.4
r_764_1324_i 764_1324 1324 93218.1
c_764_1324_i 764 764_1324 2.08965e-09
r_1324_1884_e 1324 1884 396.671
r_1324_1884_i 1324_1884 1884 1005.2
c_1324_1884_i 1324 1324_1884 1.65806e-10
r_1884_2444_e 1884 2444 836.944
r_1884_2444_i 1884_2444 2444 4256.89
c_1884_2444_i 1884 1884_2444 4.67522e-10
r_2444_3004_e 2444 3004 836.944
r_2444_3004_i 2444_3004 3004 4256.89
c_2444_3004_i 2444 2444_3004 4.67522e-10
r_3004_3564_e 3004 3564 13758.3
r_3004_3564_i 3004_3564 3564 95645.6
c_3004_3564_i 3004 3004_3564 9.36084e-12
r_205_765_e 205 765 13376.4
r_205_765_i 205_765 765 93218.1
c_205_765_i 205 205_765 2.08965e-09
r_765_1325_e 765 1325 13376.4
r_765_1325_i 765_1325 1325 93218.1
c_765_1325_i 765 765_1325 2.08965e-09
r_1325_1885_e 1325 1885 836.944
r_1325_1885_i 1325_1885 1885 4256.89
c_1325_1885_i 1325 1325_1885 4.67522e-10
r_1885_2445_e 1885 2445 836.944
r_1885_2445_i 1885_2445 2445 4256.89
c_1885_2445_i 1885 1885_2445 4.67522e-10
r_2445_3005_e 2445 3005 836.944
r_2445_3005_i 2445_3005 3005 4256.89
c_2445_3005_i 2445 2445_3005 4.67522e-10
r_3005_3565_e 3005 3565 13758.3
r_3005_3565_i 3005_3565 3565 95645.6
c_3005_3565_i 3005 3005_3565 9.36084e-12
r_206_766_e 206 766 13376.4
r_206_766_i 206_766 766 93218.1
c_206_766_i 206 206_766 2.08965e-09
r_766_1326_e 766 1326 13376.4
r_766_1326_i 766_1326 1326 93218.1
c_766_1326_i 766 766_1326 2.08965e-09
r_1326_1886_e 1326 1886 836.944
r_1326_1886_i 1326_1886 1886 4256.89
c_1326_1886_i 1326 1326_1886 4.67522e-10
r_1886_2446_e 1886 2446 836.944
r_1886_2446_i 1886_2446 2446 4256.89
c_1886_2446_i 1886 1886_2446 4.67522e-10
r_2446_3006_e 2446 3006 836.944
r_2446_3006_i 2446_3006 3006 4256.89
c_2446_3006_i 2446 2446_3006 4.67522e-10
r_3006_3566_e 3006 3566 13758.3
r_3006_3566_i 3006_3566 3566 95645.6
c_3006_3566_i 3006 3006_3566 9.36084e-12
r_207_767_e 207 767 13376.4
r_207_767_i 207_767 767 93218.1
c_207_767_i 207 207_767 2.08965e-09
r_767_1327_e 767 1327 13376.4
r_767_1327_i 767_1327 1327 93218.1
c_767_1327_i 767 767_1327 2.08965e-09
r_1327_1887_e 1327 1887 836.944
r_1327_1887_i 1327_1887 1887 4256.89
c_1327_1887_i 1327 1327_1887 4.67522e-10
r_1887_2447_e 1887 2447 836.944
r_1887_2447_i 1887_2447 2447 4256.89
c_1887_2447_i 1887 1887_2447 4.67522e-10
r_2447_3007_e 2447 3007 836.944
r_2447_3007_i 2447_3007 3007 4256.89
c_2447_3007_i 2447 2447_3007 4.67522e-10
r_3007_3567_e 3007 3567 13758.3
r_3007_3567_i 3007_3567 3567 95645.6
c_3007_3567_i 3007 3007_3567 9.36084e-12
r_208_768_e 208 768 13376.4
r_208_768_i 208_768 768 93218.1
c_208_768_i 208 208_768 2.08965e-09
r_768_1328_e 768 1328 13376.4
r_768_1328_i 768_1328 1328 93218.1
c_768_1328_i 768 768_1328 2.08965e-09
r_1328_1888_e 1328 1888 836.944
r_1328_1888_i 1328_1888 1888 4256.89
c_1328_1888_i 1328 1328_1888 4.67522e-10
r_1888_2448_e 1888 2448 836.944
r_1888_2448_i 1888_2448 2448 4256.89
c_1888_2448_i 1888 1888_2448 4.67522e-10
r_2448_3008_e 2448 3008 836.944
r_2448_3008_i 2448_3008 3008 4256.89
c_2448_3008_i 2448 2448_3008 4.67522e-10
r_3008_3568_e 3008 3568 13758.3
r_3008_3568_i 3008_3568 3568 95645.6
c_3008_3568_i 3008 3008_3568 9.36084e-12
r_209_769_e 209 769 13376.4
r_209_769_i 209_769 769 93218.1
c_209_769_i 209 209_769 2.08965e-09
r_769_1329_e 769 1329 13376.4
r_769_1329_i 769_1329 1329 93218.1
c_769_1329_i 769 769_1329 2.08965e-09
r_1329_1889_e 1329 1889 13376.4
r_1329_1889_i 1329_1889 1889 93218.1
c_1329_1889_i 1329 1329_1889 2.08965e-09
r_1889_2449_e 1889 2449 13376.4
r_1889_2449_i 1889_2449 2449 93218.1
c_1889_2449_i 1889 1889_2449 2.08965e-09
r_2449_3009_e 2449 3009 13376.4
r_2449_3009_i 2449_3009 3009 93218.1
c_2449_3009_i 2449 2449_3009 2.08965e-09
r_3009_3569_e 3009 3569 13376.4
r_3009_3569_i 3009_3569 3569 93218.1
c_3009_3569_i 3009 3009_3569 2.08965e-09
r_210_770_e 210 770 13376.4
r_210_770_i 210_770 770 93218.1
c_210_770_i 210 210_770 2.08965e-09
r_770_1330_e 770 1330 13376.4
r_770_1330_i 770_1330 1330 93218.1
c_770_1330_i 770 770_1330 2.08965e-09
r_1330_1890_e 1330 1890 13376.4
r_1330_1890_i 1330_1890 1890 93218.1
c_1330_1890_i 1330 1330_1890 2.08965e-09
r_1890_2450_e 1890 2450 13376.4
r_1890_2450_i 1890_2450 2450 93218.1
c_1890_2450_i 1890 1890_2450 2.08965e-09
r_2450_3010_e 2450 3010 13376.4
r_2450_3010_i 2450_3010 3010 93218.1
c_2450_3010_i 2450 2450_3010 2.08965e-09
r_3010_3570_e 3010 3570 13376.4
r_3010_3570_i 3010_3570 3570 93218.1
c_3010_3570_i 3010 3010_3570 2.08965e-09
r_211_771_e 211 771 13376.4
r_211_771_i 211_771 771 93218.1
c_211_771_i 211 211_771 2.08965e-09
r_771_1331_e 771 1331 13376.4
r_771_1331_i 771_1331 1331 93218.1
c_771_1331_i 771 771_1331 2.08965e-09
r_1331_1891_e 1331 1891 836.944
r_1331_1891_i 1331_1891 1891 4256.89
c_1331_1891_i 1331 1331_1891 4.67522e-10
r_1891_2451_e 1891 2451 836.944
r_1891_2451_i 1891_2451 2451 4256.89
c_1891_2451_i 1891 1891_2451 4.67522e-10
r_2451_3011_e 2451 3011 836.944
r_2451_3011_i 2451_3011 3011 4256.89
c_2451_3011_i 2451 2451_3011 4.67522e-10
r_3011_3571_e 3011 3571 836.944
r_3011_3571_i 3011_3571 3571 4256.89
c_3011_3571_i 3011 3011_3571 4.67522e-10
r_212_772_e 212 772 13376.4
r_212_772_i 212_772 772 93218.1
c_212_772_i 212 212_772 2.08965e-09
r_772_1332_e 772 1332 13376.4
r_772_1332_i 772_1332 1332 93218.1
c_772_1332_i 772 772_1332 2.08965e-09
r_1332_1892_e 1332 1892 836.944
r_1332_1892_i 1332_1892 1892 4256.89
c_1332_1892_i 1332 1332_1892 4.67522e-10
r_1892_2452_e 1892 2452 836.944
r_1892_2452_i 1892_2452 2452 4256.89
c_1892_2452_i 1892 1892_2452 4.67522e-10
r_2452_3012_e 2452 3012 836.944
r_2452_3012_i 2452_3012 3012 4256.89
c_2452_3012_i 2452 2452_3012 4.67522e-10
r_3012_3572_e 3012 3572 13758.3
r_3012_3572_i 3012_3572 3572 95645.6
c_3012_3572_i 3012 3012_3572 9.36084e-12
r_213_773_e 213 773 13376.4
r_213_773_i 213_773 773 93218.1
c_213_773_i 213 213_773 2.08965e-09
r_773_1333_e 773 1333 13376.4
r_773_1333_i 773_1333 1333 93218.1
c_773_1333_i 773 773_1333 2.08965e-09
r_1333_1893_e 1333 1893 836.944
r_1333_1893_i 1333_1893 1893 4256.89
c_1333_1893_i 1333 1333_1893 4.67522e-10
r_1893_2453_e 1893 2453 836.944
r_1893_2453_i 1893_2453 2453 4256.89
c_1893_2453_i 1893 1893_2453 4.67522e-10
r_2453_3013_e 2453 3013 836.944
r_2453_3013_i 2453_3013 3013 4256.89
c_2453_3013_i 2453 2453_3013 4.67522e-10
r_3013_3573_e 3013 3573 13758.3
r_3013_3573_i 3013_3573 3573 95645.6
c_3013_3573_i 3013 3013_3573 9.36084e-12
r_214_774_e 214 774 13376.4
r_214_774_i 214_774 774 93218.1
c_214_774_i 214 214_774 2.08965e-09
r_774_1334_e 774 1334 13376.4
r_774_1334_i 774_1334 1334 93218.1
c_774_1334_i 774 774_1334 2.08965e-09
r_1334_1894_e 1334 1894 836.944
r_1334_1894_i 1334_1894 1894 4256.89
c_1334_1894_i 1334 1334_1894 4.67522e-10
r_1894_2454_e 1894 2454 836.944
r_1894_2454_i 1894_2454 2454 4256.89
c_1894_2454_i 1894 1894_2454 4.67522e-10
r_2454_3014_e 2454 3014 836.944
r_2454_3014_i 2454_3014 3014 4256.89
c_2454_3014_i 2454 2454_3014 4.67522e-10
r_3014_3574_e 3014 3574 13758.3
r_3014_3574_i 3014_3574 3574 95645.6
c_3014_3574_i 3014 3014_3574 9.36084e-12
r_215_775_e 215 775 13376.4
r_215_775_i 215_775 775 93218.1
c_215_775_i 215 215_775 2.08965e-09
r_775_1335_e 775 1335 13376.4
r_775_1335_i 775_1335 1335 93218.1
c_775_1335_i 775 775_1335 2.08965e-09
r_1335_1895_e 1335 1895 836.944
r_1335_1895_i 1335_1895 1895 4256.89
c_1335_1895_i 1335 1335_1895 4.67522e-10
r_1895_2455_e 1895 2455 836.944
r_1895_2455_i 1895_2455 2455 4256.89
c_1895_2455_i 1895 1895_2455 4.67522e-10
r_2455_3015_e 2455 3015 836.944
r_2455_3015_i 2455_3015 3015 4256.89
c_2455_3015_i 2455 2455_3015 4.67522e-10
r_3015_3575_e 3015 3575 13758.3
r_3015_3575_i 3015_3575 3575 95645.6
c_3015_3575_i 3015 3015_3575 9.36084e-12
r_216_776_e 216 776 13376.4
r_216_776_i 216_776 776 93218.1
c_216_776_i 216 216_776 2.08965e-09
r_776_1336_e 776 1336 13376.4
r_776_1336_i 776_1336 1336 93218.1
c_776_1336_i 776 776_1336 2.08965e-09
r_1336_1896_e 1336 1896 836.944
r_1336_1896_i 1336_1896 1896 4256.89
c_1336_1896_i 1336 1336_1896 4.67522e-10
r_1896_2456_e 1896 2456 836.944
r_1896_2456_i 1896_2456 2456 4256.89
c_1896_2456_i 1896 1896_2456 4.67522e-10
r_2456_3016_e 2456 3016 836.944
r_2456_3016_i 2456_3016 3016 4256.89
c_2456_3016_i 2456 2456_3016 4.67522e-10
r_3016_3576_e 3016 3576 13758.3
r_3016_3576_i 3016_3576 3576 95645.6
c_3016_3576_i 3016 3016_3576 9.36084e-12
r_217_777_e 217 777 13376.4
r_217_777_i 217_777 777 93218.1
c_217_777_i 217 217_777 2.08965e-09
r_777_1337_e 777 1337 13376.4
r_777_1337_i 777_1337 1337 93218.1
c_777_1337_i 777 777_1337 2.08965e-09
r_1337_1897_e 1337 1897 836.944
r_1337_1897_i 1337_1897 1897 4256.89
c_1337_1897_i 1337 1337_1897 4.67522e-10
r_1897_2457_e 1897 2457 836.944
r_1897_2457_i 1897_2457 2457 4256.89
c_1897_2457_i 1897 1897_2457 4.67522e-10
r_2457_3017_e 2457 3017 836.944
r_2457_3017_i 2457_3017 3017 4256.89
c_2457_3017_i 2457 2457_3017 4.67522e-10
r_3017_3577_e 3017 3577 13758.3
r_3017_3577_i 3017_3577 3577 95645.6
c_3017_3577_i 3017 3017_3577 9.36084e-12
r_218_778_e 218 778 13376.4
r_218_778_i 218_778 778 93218.1
c_218_778_i 218 218_778 2.08965e-09
r_778_1338_e 778 1338 13376.4
r_778_1338_i 778_1338 1338 93218.1
c_778_1338_i 778 778_1338 2.08965e-09
r_1338_1898_e 1338 1898 836.944
r_1338_1898_i 1338_1898 1898 4256.89
c_1338_1898_i 1338 1338_1898 4.67522e-10
r_1898_2458_e 1898 2458 836.944
r_1898_2458_i 1898_2458 2458 4256.89
c_1898_2458_i 1898 1898_2458 4.67522e-10
r_2458_3018_e 2458 3018 836.944
r_2458_3018_i 2458_3018 3018 4256.89
c_2458_3018_i 2458 2458_3018 4.67522e-10
r_3018_3578_e 3018 3578 13758.3
r_3018_3578_i 3018_3578 3578 95645.6
c_3018_3578_i 3018 3018_3578 9.36084e-12
r_219_779_e 219 779 13376.4
r_219_779_i 219_779 779 93218.1
c_219_779_i 219 219_779 2.08965e-09
r_779_1339_e 779 1339 13376.4
r_779_1339_i 779_1339 1339 93218.1
c_779_1339_i 779 779_1339 2.08965e-09
r_1339_1899_e 1339 1899 396.662
r_1339_1899_i 1339_1899 1899 1005.18
c_1339_1899_i 1339 1339_1899 1.6581e-10
r_1899_2459_e 1899 2459 836.944
r_1899_2459_i 1899_2459 2459 4256.89
c_1899_2459_i 1899 1899_2459 4.67522e-10
r_2459_3019_e 2459 3019 836.944
r_2459_3019_i 2459_3019 3019 4256.89
c_2459_3019_i 2459 2459_3019 4.67522e-10
r_3019_3579_e 3019 3579 13758.3
r_3019_3579_i 3019_3579 3579 95645.6
c_3019_3579_i 3019 3019_3579 9.36084e-12
r_220_780_e 220 780 13376.4
r_220_780_i 220_780 780 93218.1
c_220_780_i 220 220_780 2.08965e-09
r_780_1340_e 780 1340 13376.4
r_780_1340_i 780_1340 1340 93218.1
c_780_1340_i 780 780_1340 2.08965e-09
r_1340_1900_e 1340 1900 396.662
r_1340_1900_i 1340_1900 1900 1005.18
c_1340_1900_i 1340 1340_1900 1.6581e-10
r_1900_2460_e 1900 2460 836.944
r_1900_2460_i 1900_2460 2460 4256.89
c_1900_2460_i 1900 1900_2460 4.67522e-10
r_2460_3020_e 2460 3020 836.944
r_2460_3020_i 2460_3020 3020 4256.89
c_2460_3020_i 2460 2460_3020 4.67522e-10
r_3020_3580_e 3020 3580 13758.3
r_3020_3580_i 3020_3580 3580 95645.6
c_3020_3580_i 3020 3020_3580 9.36084e-12
r_221_781_e 221 781 13376.4
r_221_781_i 221_781 781 93218.1
c_221_781_i 221 221_781 2.08965e-09
r_781_1341_e 781 1341 13376.4
r_781_1341_i 781_1341 1341 93218.1
c_781_1341_i 781 781_1341 2.08965e-09
r_1341_1901_e 1341 1901 836.944
r_1341_1901_i 1341_1901 1901 4256.89
c_1341_1901_i 1341 1341_1901 4.67522e-10
r_1901_2461_e 1901 2461 836.944
r_1901_2461_i 1901_2461 2461 4256.89
c_1901_2461_i 1901 1901_2461 4.67522e-10
r_2461_3021_e 2461 3021 836.944
r_2461_3021_i 2461_3021 3021 4256.89
c_2461_3021_i 2461 2461_3021 4.67522e-10
r_3021_3581_e 3021 3581 13758.3
r_3021_3581_i 3021_3581 3581 95645.6
c_3021_3581_i 3021 3021_3581 9.36084e-12
r_222_782_e 222 782 13376.4
r_222_782_i 222_782 782 93218.1
c_222_782_i 222 222_782 2.08965e-09
r_782_1342_e 782 1342 13376.4
r_782_1342_i 782_1342 1342 93218.1
c_782_1342_i 782 782_1342 2.08965e-09
r_1342_1902_e 1342 1902 836.944
r_1342_1902_i 1342_1902 1902 4256.89
c_1342_1902_i 1342 1342_1902 4.67522e-10
r_1902_2462_e 1902 2462 836.944
r_1902_2462_i 1902_2462 2462 4256.89
c_1902_2462_i 1902 1902_2462 4.67522e-10
r_2462_3022_e 2462 3022 836.944
r_2462_3022_i 2462_3022 3022 4256.89
c_2462_3022_i 2462 2462_3022 4.67522e-10
r_3022_3582_e 3022 3582 13758.3
r_3022_3582_i 3022_3582 3582 95645.6
c_3022_3582_i 3022 3022_3582 9.36084e-12
r_223_783_e 223 783 13376.4
r_223_783_i 223_783 783 93218.1
c_223_783_i 223 223_783 2.08965e-09
r_783_1343_e 783 1343 13376.4
r_783_1343_i 783_1343 1343 93218.1
c_783_1343_i 783 783_1343 2.08965e-09
r_1343_1903_e 1343 1903 836.944
r_1343_1903_i 1343_1903 1903 4256.89
c_1343_1903_i 1343 1343_1903 4.67522e-10
r_1903_2463_e 1903 2463 836.944
r_1903_2463_i 1903_2463 2463 4256.89
c_1903_2463_i 1903 1903_2463 4.67522e-10
r_2463_3023_e 2463 3023 836.944
r_2463_3023_i 2463_3023 3023 4256.89
c_2463_3023_i 2463 2463_3023 4.67522e-10
r_3023_3583_e 3023 3583 13758.3
r_3023_3583_i 3023_3583 3583 95645.6
c_3023_3583_i 3023 3023_3583 9.36084e-12
r_224_784_e 224 784 13376.4
r_224_784_i 224_784 784 93218.1
c_224_784_i 224 224_784 2.08965e-09
r_784_1344_e 784 1344 13376.4
r_784_1344_i 784_1344 1344 93218.1
c_784_1344_i 784 784_1344 2.08965e-09
r_1344_1904_e 1344 1904 836.944
r_1344_1904_i 1344_1904 1904 4256.89
c_1344_1904_i 1344 1344_1904 4.67522e-10
r_1904_2464_e 1904 2464 836.944
r_1904_2464_i 1904_2464 2464 4256.89
c_1904_2464_i 1904 1904_2464 4.67522e-10
r_2464_3024_e 2464 3024 836.944
r_2464_3024_i 2464_3024 3024 4256.89
c_2464_3024_i 2464 2464_3024 4.67522e-10
r_3024_3584_e 3024 3584 13758.3
r_3024_3584_i 3024_3584 3584 95645.6
c_3024_3584_i 3024 3024_3584 9.36084e-12
r_225_785_e 225 785 13376.4
r_225_785_i 225_785 785 93218.1
c_225_785_i 225 225_785 2.08965e-09
r_785_1345_e 785 1345 13376.4
r_785_1345_i 785_1345 1345 93218.1
c_785_1345_i 785 785_1345 2.08965e-09
r_1345_1905_e 1345 1905 13376.4
r_1345_1905_i 1345_1905 1905 93218.1
c_1345_1905_i 1345 1345_1905 2.08965e-09
r_1905_2465_e 1905 2465 13376.4
r_1905_2465_i 1905_2465 2465 93218.1
c_1905_2465_i 1905 1905_2465 2.08965e-09
r_2465_3025_e 2465 3025 13376.4
r_2465_3025_i 2465_3025 3025 93218.1
c_2465_3025_i 2465 2465_3025 2.08965e-09
r_3025_3585_e 3025 3585 13376.4
r_3025_3585_i 3025_3585 3585 93218.1
c_3025_3585_i 3025 3025_3585 2.08965e-09
r_226_786_e 226 786 13376.4
r_226_786_i 226_786 786 93218.1
c_226_786_i 226 226_786 2.08965e-09
r_786_1346_e 786 1346 13376.4
r_786_1346_i 786_1346 1346 93218.1
c_786_1346_i 786 786_1346 2.08965e-09
r_1346_1906_e 1346 1906 13376.4
r_1346_1906_i 1346_1906 1906 93218.1
c_1346_1906_i 1346 1346_1906 2.08965e-09
r_1906_2466_e 1906 2466 13376.4
r_1906_2466_i 1906_2466 2466 93218.1
c_1906_2466_i 1906 1906_2466 2.08965e-09
r_2466_3026_e 2466 3026 13376.4
r_2466_3026_i 2466_3026 3026 93218.1
c_2466_3026_i 2466 2466_3026 2.08965e-09
r_3026_3586_e 3026 3586 13376.4
r_3026_3586_i 3026_3586 3586 93218.1
c_3026_3586_i 3026 3026_3586 2.08965e-09
r_227_787_e 227 787 13376.4
r_227_787_i 227_787 787 93218.1
c_227_787_i 227 227_787 2.08965e-09
r_787_1347_e 787 1347 13376.4
r_787_1347_i 787_1347 1347 93218.1
c_787_1347_i 787 787_1347 2.08965e-09
r_1347_1907_e 1347 1907 836.944
r_1347_1907_i 1347_1907 1907 4256.89
c_1347_1907_i 1347 1347_1907 4.67522e-10
r_1907_2467_e 1907 2467 836.944
r_1907_2467_i 1907_2467 2467 4256.89
c_1907_2467_i 1907 1907_2467 4.67522e-10
r_2467_3027_e 2467 3027 836.944
r_2467_3027_i 2467_3027 3027 4256.89
c_2467_3027_i 2467 2467_3027 4.67522e-10
r_3027_3587_e 3027 3587 836.944
r_3027_3587_i 3027_3587 3587 4256.89
c_3027_3587_i 3027 3027_3587 4.67522e-10
r_228_788_e 228 788 13376.4
r_228_788_i 228_788 788 93218.1
c_228_788_i 228 228_788 2.08965e-09
r_788_1348_e 788 1348 13376.4
r_788_1348_i 788_1348 1348 93218.1
c_788_1348_i 788 788_1348 2.08965e-09
r_1348_1908_e 1348 1908 836.944
r_1348_1908_i 1348_1908 1908 4256.89
c_1348_1908_i 1348 1348_1908 4.67522e-10
r_1908_2468_e 1908 2468 836.944
r_1908_2468_i 1908_2468 2468 4256.89
c_1908_2468_i 1908 1908_2468 4.67522e-10
r_2468_3028_e 2468 3028 836.944
r_2468_3028_i 2468_3028 3028 4256.89
c_2468_3028_i 2468 2468_3028 4.67522e-10
r_3028_3588_e 3028 3588 13758.3
r_3028_3588_i 3028_3588 3588 95645.6
c_3028_3588_i 3028 3028_3588 9.36084e-12
r_229_789_e 229 789 13376.4
r_229_789_i 229_789 789 93218.1
c_229_789_i 229 229_789 2.08965e-09
r_789_1349_e 789 1349 13376.4
r_789_1349_i 789_1349 1349 93218.1
c_789_1349_i 789 789_1349 2.08965e-09
r_1349_1909_e 1349 1909 836.944
r_1349_1909_i 1349_1909 1909 4256.89
c_1349_1909_i 1349 1349_1909 4.67522e-10
r_1909_2469_e 1909 2469 836.944
r_1909_2469_i 1909_2469 2469 4256.89
c_1909_2469_i 1909 1909_2469 4.67522e-10
r_2469_3029_e 2469 3029 836.944
r_2469_3029_i 2469_3029 3029 4256.89
c_2469_3029_i 2469 2469_3029 4.67522e-10
r_3029_3589_e 3029 3589 13758.3
r_3029_3589_i 3029_3589 3589 95645.6
c_3029_3589_i 3029 3029_3589 9.36084e-12
r_230_790_e 230 790 13376.4
r_230_790_i 230_790 790 93218.1
c_230_790_i 230 230_790 2.08965e-09
r_790_1350_e 790 1350 13376.4
r_790_1350_i 790_1350 1350 93218.1
c_790_1350_i 790 790_1350 2.08965e-09
r_1350_1910_e 1350 1910 836.944
r_1350_1910_i 1350_1910 1910 4256.89
c_1350_1910_i 1350 1350_1910 4.67522e-10
r_1910_2470_e 1910 2470 836.944
r_1910_2470_i 1910_2470 2470 4256.89
c_1910_2470_i 1910 1910_2470 4.67522e-10
r_2470_3030_e 2470 3030 836.944
r_2470_3030_i 2470_3030 3030 4256.89
c_2470_3030_i 2470 2470_3030 4.67522e-10
r_3030_3590_e 3030 3590 13758.3
r_3030_3590_i 3030_3590 3590 95645.6
c_3030_3590_i 3030 3030_3590 9.36084e-12
r_231_791_e 231 791 13376.4
r_231_791_i 231_791 791 93218.1
c_231_791_i 231 231_791 2.08965e-09
r_791_1351_e 791 1351 13376.4
r_791_1351_i 791_1351 1351 93218.1
c_791_1351_i 791 791_1351 2.08965e-09
r_1351_1911_e 1351 1911 836.944
r_1351_1911_i 1351_1911 1911 4256.89
c_1351_1911_i 1351 1351_1911 4.67522e-10
r_1911_2471_e 1911 2471 836.944
r_1911_2471_i 1911_2471 2471 4256.89
c_1911_2471_i 1911 1911_2471 4.67522e-10
r_2471_3031_e 2471 3031 836.944
r_2471_3031_i 2471_3031 3031 4256.89
c_2471_3031_i 2471 2471_3031 4.67522e-10
r_3031_3591_e 3031 3591 13758.3
r_3031_3591_i 3031_3591 3591 95645.6
c_3031_3591_i 3031 3031_3591 9.36084e-12
r_232_792_e 232 792 13376.4
r_232_792_i 232_792 792 93218.1
c_232_792_i 232 232_792 2.08965e-09
r_792_1352_e 792 1352 13376.4
r_792_1352_i 792_1352 1352 93218.1
c_792_1352_i 792 792_1352 2.08965e-09
r_1352_1912_e 1352 1912 836.944
r_1352_1912_i 1352_1912 1912 4256.89
c_1352_1912_i 1352 1352_1912 4.67522e-10
r_1912_2472_e 1912 2472 836.944
r_1912_2472_i 1912_2472 2472 4256.89
c_1912_2472_i 1912 1912_2472 4.67522e-10
r_2472_3032_e 2472 3032 836.944
r_2472_3032_i 2472_3032 3032 4256.89
c_2472_3032_i 2472 2472_3032 4.67522e-10
r_3032_3592_e 3032 3592 13758.3
r_3032_3592_i 3032_3592 3592 95645.6
c_3032_3592_i 3032 3032_3592 9.36084e-12
r_233_793_e 233 793 13376.4
r_233_793_i 233_793 793 93218.1
c_233_793_i 233 233_793 2.08965e-09
r_793_1353_e 793 1353 13376.4
r_793_1353_i 793_1353 1353 93218.1
c_793_1353_i 793 793_1353 2.08965e-09
r_1353_1913_e 1353 1913 836.944
r_1353_1913_i 1353_1913 1913 4256.89
c_1353_1913_i 1353 1353_1913 4.67522e-10
r_1913_2473_e 1913 2473 836.944
r_1913_2473_i 1913_2473 2473 4256.89
c_1913_2473_i 1913 1913_2473 4.67522e-10
r_2473_3033_e 2473 3033 836.944
r_2473_3033_i 2473_3033 3033 4256.89
c_2473_3033_i 2473 2473_3033 4.67522e-10
r_3033_3593_e 3033 3593 13758.3
r_3033_3593_i 3033_3593 3593 95645.6
c_3033_3593_i 3033 3033_3593 9.36084e-12
r_234_794_e 234 794 13376.4
r_234_794_i 234_794 794 93218.1
c_234_794_i 234 234_794 2.08965e-09
r_794_1354_e 794 1354 13376.4
r_794_1354_i 794_1354 1354 93218.1
c_794_1354_i 794 794_1354 2.08965e-09
r_1354_1914_e 1354 1914 836.944
r_1354_1914_i 1354_1914 1914 4256.89
c_1354_1914_i 1354 1354_1914 4.67522e-10
r_1914_2474_e 1914 2474 836.944
r_1914_2474_i 1914_2474 2474 4256.89
c_1914_2474_i 1914 1914_2474 4.67522e-10
r_2474_3034_e 2474 3034 836.944
r_2474_3034_i 2474_3034 3034 4256.89
c_2474_3034_i 2474 2474_3034 4.67522e-10
r_3034_3594_e 3034 3594 13758.3
r_3034_3594_i 3034_3594 3594 95645.6
c_3034_3594_i 3034 3034_3594 9.36084e-12
r_235_795_e 235 795 13376.4
r_235_795_i 235_795 795 93218.1
c_235_795_i 235 235_795 2.08965e-09
r_795_1355_e 795 1355 13376.4
r_795_1355_i 795_1355 1355 93218.1
c_795_1355_i 795 795_1355 2.08965e-09
r_1355_1915_e 1355 1915 396.654
r_1355_1915_i 1355_1915 1915 1005.16
c_1355_1915_i 1355 1355_1915 1.65814e-10
r_1915_2475_e 1915 2475 836.944
r_1915_2475_i 1915_2475 2475 4256.89
c_1915_2475_i 1915 1915_2475 4.67522e-10
r_2475_3035_e 2475 3035 836.944
r_2475_3035_i 2475_3035 3035 4256.89
c_2475_3035_i 2475 2475_3035 4.67522e-10
r_3035_3595_e 3035 3595 13758.3
r_3035_3595_i 3035_3595 3595 95645.6
c_3035_3595_i 3035 3035_3595 9.36084e-12
r_236_796_e 236 796 13376.4
r_236_796_i 236_796 796 93218.1
c_236_796_i 236 236_796 2.08965e-09
r_796_1356_e 796 1356 13376.4
r_796_1356_i 796_1356 1356 93218.1
c_796_1356_i 796 796_1356 2.08965e-09
r_1356_1916_e 1356 1916 396.654
r_1356_1916_i 1356_1916 1916 1005.16
c_1356_1916_i 1356 1356_1916 1.65814e-10
r_1916_2476_e 1916 2476 836.944
r_1916_2476_i 1916_2476 2476 4256.89
c_1916_2476_i 1916 1916_2476 4.67522e-10
r_2476_3036_e 2476 3036 836.944
r_2476_3036_i 2476_3036 3036 4256.89
c_2476_3036_i 2476 2476_3036 4.67522e-10
r_3036_3596_e 3036 3596 13758.3
r_3036_3596_i 3036_3596 3596 95645.6
c_3036_3596_i 3036 3036_3596 9.36084e-12
r_237_797_e 237 797 13376.4
r_237_797_i 237_797 797 93218.1
c_237_797_i 237 237_797 2.08965e-09
r_797_1357_e 797 1357 13376.4
r_797_1357_i 797_1357 1357 93218.1
c_797_1357_i 797 797_1357 2.08965e-09
r_1357_1917_e 1357 1917 836.944
r_1357_1917_i 1357_1917 1917 4256.89
c_1357_1917_i 1357 1357_1917 4.67522e-10
r_1917_2477_e 1917 2477 836.944
r_1917_2477_i 1917_2477 2477 4256.89
c_1917_2477_i 1917 1917_2477 4.67522e-10
r_2477_3037_e 2477 3037 836.944
r_2477_3037_i 2477_3037 3037 4256.89
c_2477_3037_i 2477 2477_3037 4.67522e-10
r_3037_3597_e 3037 3597 13758.3
r_3037_3597_i 3037_3597 3597 95645.6
c_3037_3597_i 3037 3037_3597 9.36084e-12
r_238_798_e 238 798 13376.4
r_238_798_i 238_798 798 93218.1
c_238_798_i 238 238_798 2.08965e-09
r_798_1358_e 798 1358 13376.4
r_798_1358_i 798_1358 1358 93218.1
c_798_1358_i 798 798_1358 2.08965e-09
r_1358_1918_e 1358 1918 836.944
r_1358_1918_i 1358_1918 1918 4256.89
c_1358_1918_i 1358 1358_1918 4.67522e-10
r_1918_2478_e 1918 2478 836.944
r_1918_2478_i 1918_2478 2478 4256.89
c_1918_2478_i 1918 1918_2478 4.67522e-10
r_2478_3038_e 2478 3038 836.944
r_2478_3038_i 2478_3038 3038 4256.89
c_2478_3038_i 2478 2478_3038 4.67522e-10
r_3038_3598_e 3038 3598 13758.3
r_3038_3598_i 3038_3598 3598 95645.6
c_3038_3598_i 3038 3038_3598 9.36084e-12
r_239_799_e 239 799 13376.4
r_239_799_i 239_799 799 93218.1
c_239_799_i 239 239_799 2.08965e-09
r_799_1359_e 799 1359 13376.4
r_799_1359_i 799_1359 1359 93218.1
c_799_1359_i 799 799_1359 2.08965e-09
r_1359_1919_e 1359 1919 836.944
r_1359_1919_i 1359_1919 1919 4256.89
c_1359_1919_i 1359 1359_1919 4.67522e-10
r_1919_2479_e 1919 2479 836.944
r_1919_2479_i 1919_2479 2479 4256.89
c_1919_2479_i 1919 1919_2479 4.67522e-10
r_2479_3039_e 2479 3039 836.944
r_2479_3039_i 2479_3039 3039 4256.89
c_2479_3039_i 2479 2479_3039 4.67522e-10
r_3039_3599_e 3039 3599 13758.3
r_3039_3599_i 3039_3599 3599 95645.6
c_3039_3599_i 3039 3039_3599 9.36084e-12
r_240_800_e 240 800 13376.4
r_240_800_i 240_800 800 93218.1
c_240_800_i 240 240_800 2.08965e-09
r_800_1360_e 800 1360 13376.4
r_800_1360_i 800_1360 1360 93218.1
c_800_1360_i 800 800_1360 2.08965e-09
r_1360_1920_e 1360 1920 836.944
r_1360_1920_i 1360_1920 1920 4256.89
c_1360_1920_i 1360 1360_1920 4.67522e-10
r_1920_2480_e 1920 2480 836.944
r_1920_2480_i 1920_2480 2480 4256.89
c_1920_2480_i 1920 1920_2480 4.67522e-10
r_2480_3040_e 2480 3040 836.944
r_2480_3040_i 2480_3040 3040 4256.89
c_2480_3040_i 2480 2480_3040 4.67522e-10
r_3040_3600_e 3040 3600 13758.3
r_3040_3600_i 3040_3600 3600 95645.6
c_3040_3600_i 3040 3040_3600 9.36084e-12
r_241_801_e 241 801 13376.4
r_241_801_i 241_801 801 93218.1
c_241_801_i 241 241_801 2.08965e-09
r_801_1361_e 801 1361 13376.4
r_801_1361_i 801_1361 1361 93218.1
c_801_1361_i 801 801_1361 2.08965e-09
r_1361_1921_e 1361 1921 13376.4
r_1361_1921_i 1361_1921 1921 93218.1
c_1361_1921_i 1361 1361_1921 2.08965e-09
r_1921_2481_e 1921 2481 13376.4
r_1921_2481_i 1921_2481 2481 93218.1
c_1921_2481_i 1921 1921_2481 2.08965e-09
r_2481_3041_e 2481 3041 13376.4
r_2481_3041_i 2481_3041 3041 93218.1
c_2481_3041_i 2481 2481_3041 2.08965e-09
r_3041_3601_e 3041 3601 13376.4
r_3041_3601_i 3041_3601 3601 93218.1
c_3041_3601_i 3041 3041_3601 2.08965e-09
r_242_802_e 242 802 13376.4
r_242_802_i 242_802 802 93218.1
c_242_802_i 242 242_802 2.08965e-09
r_802_1362_e 802 1362 13376.4
r_802_1362_i 802_1362 1362 93218.1
c_802_1362_i 802 802_1362 2.08965e-09
r_1362_1922_e 1362 1922 13376.4
r_1362_1922_i 1362_1922 1922 93218.1
c_1362_1922_i 1362 1362_1922 2.08965e-09
r_1922_2482_e 1922 2482 13376.4
r_1922_2482_i 1922_2482 2482 93218.1
c_1922_2482_i 1922 1922_2482 2.08965e-09
r_2482_3042_e 2482 3042 13376.4
r_2482_3042_i 2482_3042 3042 93218.1
c_2482_3042_i 2482 2482_3042 2.08965e-09
r_3042_3602_e 3042 3602 13376.4
r_3042_3602_i 3042_3602 3602 93218.1
c_3042_3602_i 3042 3042_3602 2.08965e-09
r_243_803_e 243 803 13376.4
r_243_803_i 243_803 803 93218.1
c_243_803_i 243 243_803 2.08965e-09
r_803_1363_e 803 1363 13376.4
r_803_1363_i 803_1363 1363 93218.1
c_803_1363_i 803 803_1363 2.08965e-09
r_1363_1923_e 1363 1923 836.944
r_1363_1923_i 1363_1923 1923 4256.89
c_1363_1923_i 1363 1363_1923 4.67522e-10
r_1923_2483_e 1923 2483 836.944
r_1923_2483_i 1923_2483 2483 4256.89
c_1923_2483_i 1923 1923_2483 4.67522e-10
r_2483_3043_e 2483 3043 836.944
r_2483_3043_i 2483_3043 3043 4256.89
c_2483_3043_i 2483 2483_3043 4.67522e-10
r_3043_3603_e 3043 3603 836.944
r_3043_3603_i 3043_3603 3603 4256.89
c_3043_3603_i 3043 3043_3603 4.67522e-10
r_244_804_e 244 804 13376.4
r_244_804_i 244_804 804 93218.1
c_244_804_i 244 244_804 2.08965e-09
r_804_1364_e 804 1364 13376.4
r_804_1364_i 804_1364 1364 93218.1
c_804_1364_i 804 804_1364 2.08965e-09
r_1364_1924_e 1364 1924 836.944
r_1364_1924_i 1364_1924 1924 4256.89
c_1364_1924_i 1364 1364_1924 4.67522e-10
r_1924_2484_e 1924 2484 836.944
r_1924_2484_i 1924_2484 2484 4256.89
c_1924_2484_i 1924 1924_2484 4.67522e-10
r_2484_3044_e 2484 3044 836.944
r_2484_3044_i 2484_3044 3044 4256.89
c_2484_3044_i 2484 2484_3044 4.67522e-10
r_3044_3604_e 3044 3604 13758.3
r_3044_3604_i 3044_3604 3604 95645.6
c_3044_3604_i 3044 3044_3604 9.36084e-12
r_245_805_e 245 805 13376.4
r_245_805_i 245_805 805 93218.1
c_245_805_i 245 245_805 2.08965e-09
r_805_1365_e 805 1365 13376.4
r_805_1365_i 805_1365 1365 93218.1
c_805_1365_i 805 805_1365 2.08965e-09
r_1365_1925_e 1365 1925 836.944
r_1365_1925_i 1365_1925 1925 4256.89
c_1365_1925_i 1365 1365_1925 4.67522e-10
r_1925_2485_e 1925 2485 836.944
r_1925_2485_i 1925_2485 2485 4256.89
c_1925_2485_i 1925 1925_2485 4.67522e-10
r_2485_3045_e 2485 3045 836.944
r_2485_3045_i 2485_3045 3045 4256.89
c_2485_3045_i 2485 2485_3045 4.67522e-10
r_3045_3605_e 3045 3605 13758.3
r_3045_3605_i 3045_3605 3605 95645.6
c_3045_3605_i 3045 3045_3605 9.36084e-12
r_246_806_e 246 806 13376.4
r_246_806_i 246_806 806 93218.1
c_246_806_i 246 246_806 2.08965e-09
r_806_1366_e 806 1366 13376.4
r_806_1366_i 806_1366 1366 93218.1
c_806_1366_i 806 806_1366 2.08965e-09
r_1366_1926_e 1366 1926 836.944
r_1366_1926_i 1366_1926 1926 4256.89
c_1366_1926_i 1366 1366_1926 4.67522e-10
r_1926_2486_e 1926 2486 836.944
r_1926_2486_i 1926_2486 2486 4256.89
c_1926_2486_i 1926 1926_2486 4.67522e-10
r_2486_3046_e 2486 3046 836.944
r_2486_3046_i 2486_3046 3046 4256.89
c_2486_3046_i 2486 2486_3046 4.67522e-10
r_3046_3606_e 3046 3606 13758.3
r_3046_3606_i 3046_3606 3606 95645.6
c_3046_3606_i 3046 3046_3606 9.36084e-12
r_247_807_e 247 807 13376.4
r_247_807_i 247_807 807 93218.1
c_247_807_i 247 247_807 2.08965e-09
r_807_1367_e 807 1367 13376.4
r_807_1367_i 807_1367 1367 93218.1
c_807_1367_i 807 807_1367 2.08965e-09
r_1367_1927_e 1367 1927 836.944
r_1367_1927_i 1367_1927 1927 4256.89
c_1367_1927_i 1367 1367_1927 4.67522e-10
r_1927_2487_e 1927 2487 836.944
r_1927_2487_i 1927_2487 2487 4256.89
c_1927_2487_i 1927 1927_2487 4.67522e-10
r_2487_3047_e 2487 3047 836.944
r_2487_3047_i 2487_3047 3047 4256.89
c_2487_3047_i 2487 2487_3047 4.67522e-10
r_3047_3607_e 3047 3607 13758.3
r_3047_3607_i 3047_3607 3607 95645.6
c_3047_3607_i 3047 3047_3607 9.36084e-12
r_248_808_e 248 808 13376.4
r_248_808_i 248_808 808 93218.1
c_248_808_i 248 248_808 2.08965e-09
r_808_1368_e 808 1368 13376.4
r_808_1368_i 808_1368 1368 93218.1
c_808_1368_i 808 808_1368 2.08965e-09
r_1368_1928_e 1368 1928 836.944
r_1368_1928_i 1368_1928 1928 4256.89
c_1368_1928_i 1368 1368_1928 4.67522e-10
r_1928_2488_e 1928 2488 836.944
r_1928_2488_i 1928_2488 2488 4256.89
c_1928_2488_i 1928 1928_2488 4.67522e-10
r_2488_3048_e 2488 3048 836.944
r_2488_3048_i 2488_3048 3048 4256.89
c_2488_3048_i 2488 2488_3048 4.67522e-10
r_3048_3608_e 3048 3608 13758.3
r_3048_3608_i 3048_3608 3608 95645.6
c_3048_3608_i 3048 3048_3608 9.36084e-12
r_249_809_e 249 809 13376.4
r_249_809_i 249_809 809 93218.1
c_249_809_i 249 249_809 2.08965e-09
r_809_1369_e 809 1369 13376.4
r_809_1369_i 809_1369 1369 93218.1
c_809_1369_i 809 809_1369 2.08965e-09
r_1369_1929_e 1369 1929 836.944
r_1369_1929_i 1369_1929 1929 4256.89
c_1369_1929_i 1369 1369_1929 4.67522e-10
r_1929_2489_e 1929 2489 836.944
r_1929_2489_i 1929_2489 2489 4256.89
c_1929_2489_i 1929 1929_2489 4.67522e-10
r_2489_3049_e 2489 3049 836.944
r_2489_3049_i 2489_3049 3049 4256.89
c_2489_3049_i 2489 2489_3049 4.67522e-10
r_3049_3609_e 3049 3609 13758.3
r_3049_3609_i 3049_3609 3609 95645.6
c_3049_3609_i 3049 3049_3609 9.36084e-12
r_250_810_e 250 810 13376.4
r_250_810_i 250_810 810 93218.1
c_250_810_i 250 250_810 2.08965e-09
r_810_1370_e 810 1370 13376.4
r_810_1370_i 810_1370 1370 93218.1
c_810_1370_i 810 810_1370 2.08965e-09
r_1370_1930_e 1370 1930 836.944
r_1370_1930_i 1370_1930 1930 4256.89
c_1370_1930_i 1370 1370_1930 4.67522e-10
r_1930_2490_e 1930 2490 836.944
r_1930_2490_i 1930_2490 2490 4256.89
c_1930_2490_i 1930 1930_2490 4.67522e-10
r_2490_3050_e 2490 3050 836.944
r_2490_3050_i 2490_3050 3050 4256.89
c_2490_3050_i 2490 2490_3050 4.67522e-10
r_3050_3610_e 3050 3610 13758.3
r_3050_3610_i 3050_3610 3610 95645.6
c_3050_3610_i 3050 3050_3610 9.36084e-12
r_251_811_e 251 811 13376.4
r_251_811_i 251_811 811 93218.1
c_251_811_i 251 251_811 2.08965e-09
r_811_1371_e 811 1371 13376.4
r_811_1371_i 811_1371 1371 93218.1
c_811_1371_i 811 811_1371 2.08965e-09
r_1371_1931_e 1371 1931 396.645
r_1371_1931_i 1371_1931 1931 1005.14
c_1371_1931_i 1371 1371_1931 1.65817e-10
r_1931_2491_e 1931 2491 836.944
r_1931_2491_i 1931_2491 2491 4256.89
c_1931_2491_i 1931 1931_2491 4.67522e-10
r_2491_3051_e 2491 3051 836.944
r_2491_3051_i 2491_3051 3051 4256.89
c_2491_3051_i 2491 2491_3051 4.67522e-10
r_3051_3611_e 3051 3611 13758.3
r_3051_3611_i 3051_3611 3611 95645.6
c_3051_3611_i 3051 3051_3611 9.36084e-12
r_252_812_e 252 812 13376.4
r_252_812_i 252_812 812 93218.1
c_252_812_i 252 252_812 2.08965e-09
r_812_1372_e 812 1372 13376.4
r_812_1372_i 812_1372 1372 93218.1
c_812_1372_i 812 812_1372 2.08965e-09
r_1372_1932_e 1372 1932 396.645
r_1372_1932_i 1372_1932 1932 1005.14
c_1372_1932_i 1372 1372_1932 1.65817e-10
r_1932_2492_e 1932 2492 836.944
r_1932_2492_i 1932_2492 2492 4256.89
c_1932_2492_i 1932 1932_2492 4.67522e-10
r_2492_3052_e 2492 3052 836.944
r_2492_3052_i 2492_3052 3052 4256.89
c_2492_3052_i 2492 2492_3052 4.67522e-10
r_3052_3612_e 3052 3612 13758.3
r_3052_3612_i 3052_3612 3612 95645.6
c_3052_3612_i 3052 3052_3612 9.36084e-12
r_253_813_e 253 813 13376.4
r_253_813_i 253_813 813 93218.1
c_253_813_i 253 253_813 2.08965e-09
r_813_1373_e 813 1373 13376.4
r_813_1373_i 813_1373 1373 93218.1
c_813_1373_i 813 813_1373 2.08965e-09
r_1373_1933_e 1373 1933 836.944
r_1373_1933_i 1373_1933 1933 4256.89
c_1373_1933_i 1373 1373_1933 4.67522e-10
r_1933_2493_e 1933 2493 836.944
r_1933_2493_i 1933_2493 2493 4256.89
c_1933_2493_i 1933 1933_2493 4.67522e-10
r_2493_3053_e 2493 3053 836.944
r_2493_3053_i 2493_3053 3053 4256.89
c_2493_3053_i 2493 2493_3053 4.67522e-10
r_3053_3613_e 3053 3613 13758.3
r_3053_3613_i 3053_3613 3613 95645.6
c_3053_3613_i 3053 3053_3613 9.36084e-12
r_254_814_e 254 814 13376.4
r_254_814_i 254_814 814 93218.1
c_254_814_i 254 254_814 2.08965e-09
r_814_1374_e 814 1374 13376.4
r_814_1374_i 814_1374 1374 93218.1
c_814_1374_i 814 814_1374 2.08965e-09
r_1374_1934_e 1374 1934 836.944
r_1374_1934_i 1374_1934 1934 4256.89
c_1374_1934_i 1374 1374_1934 4.67522e-10
r_1934_2494_e 1934 2494 836.944
r_1934_2494_i 1934_2494 2494 4256.89
c_1934_2494_i 1934 1934_2494 4.67522e-10
r_2494_3054_e 2494 3054 836.944
r_2494_3054_i 2494_3054 3054 4256.89
c_2494_3054_i 2494 2494_3054 4.67522e-10
r_3054_3614_e 3054 3614 13758.3
r_3054_3614_i 3054_3614 3614 95645.6
c_3054_3614_i 3054 3054_3614 9.36084e-12
r_255_815_e 255 815 13376.4
r_255_815_i 255_815 815 93218.1
c_255_815_i 255 255_815 2.08965e-09
r_815_1375_e 815 1375 13376.4
r_815_1375_i 815_1375 1375 93218.1
c_815_1375_i 815 815_1375 2.08965e-09
r_1375_1935_e 1375 1935 836.944
r_1375_1935_i 1375_1935 1935 4256.89
c_1375_1935_i 1375 1375_1935 4.67522e-10
r_1935_2495_e 1935 2495 836.944
r_1935_2495_i 1935_2495 2495 4256.89
c_1935_2495_i 1935 1935_2495 4.67522e-10
r_2495_3055_e 2495 3055 836.944
r_2495_3055_i 2495_3055 3055 4256.89
c_2495_3055_i 2495 2495_3055 4.67522e-10
r_3055_3615_e 3055 3615 13758.3
r_3055_3615_i 3055_3615 3615 95645.6
c_3055_3615_i 3055 3055_3615 9.36084e-12
r_256_816_e 256 816 13376.4
r_256_816_i 256_816 816 93218.1
c_256_816_i 256 256_816 2.08965e-09
r_816_1376_e 816 1376 13376.4
r_816_1376_i 816_1376 1376 93218.1
c_816_1376_i 816 816_1376 2.08965e-09
r_1376_1936_e 1376 1936 836.944
r_1376_1936_i 1376_1936 1936 4256.89
c_1376_1936_i 1376 1376_1936 4.67522e-10
r_1936_2496_e 1936 2496 836.944
r_1936_2496_i 1936_2496 2496 4256.89
c_1936_2496_i 1936 1936_2496 4.67522e-10
r_2496_3056_e 2496 3056 836.944
r_2496_3056_i 2496_3056 3056 4256.89
c_2496_3056_i 2496 2496_3056 4.67522e-10
r_3056_3616_e 3056 3616 13758.3
r_3056_3616_i 3056_3616 3616 95645.6
c_3056_3616_i 3056 3056_3616 9.36084e-12
r_257_817_e 257 817 13376.4
r_257_817_i 257_817 817 93218.1
c_257_817_i 257 257_817 2.08965e-09
r_817_1377_e 817 1377 13376.4
r_817_1377_i 817_1377 1377 93218.1
c_817_1377_i 817 817_1377 2.08965e-09
r_1377_1937_e 1377 1937 13376.4
r_1377_1937_i 1377_1937 1937 93218.1
c_1377_1937_i 1377 1377_1937 2.08965e-09
r_1937_2497_e 1937 2497 13376.4
r_1937_2497_i 1937_2497 2497 93218.1
c_1937_2497_i 1937 1937_2497 2.08965e-09
r_2497_3057_e 2497 3057 13376.4
r_2497_3057_i 2497_3057 3057 93218.1
c_2497_3057_i 2497 2497_3057 2.08965e-09
r_3057_3617_e 3057 3617 13376.4
r_3057_3617_i 3057_3617 3617 93218.1
c_3057_3617_i 3057 3057_3617 2.08965e-09
r_258_818_e 258 818 13376.4
r_258_818_i 258_818 818 93218.1
c_258_818_i 258 258_818 2.08965e-09
r_818_1378_e 818 1378 13376.4
r_818_1378_i 818_1378 1378 93218.1
c_818_1378_i 818 818_1378 2.08965e-09
r_1378_1938_e 1378 1938 13376.4
r_1378_1938_i 1378_1938 1938 93218.1
c_1378_1938_i 1378 1378_1938 2.08965e-09
r_1938_2498_e 1938 2498 13376.4
r_1938_2498_i 1938_2498 2498 93218.1
c_1938_2498_i 1938 1938_2498 2.08965e-09
r_2498_3058_e 2498 3058 13376.4
r_2498_3058_i 2498_3058 3058 93218.1
c_2498_3058_i 2498 2498_3058 2.08965e-09
r_3058_3618_e 3058 3618 13376.4
r_3058_3618_i 3058_3618 3618 93218.1
c_3058_3618_i 3058 3058_3618 2.08965e-09
r_259_819_e 259 819 13376.4
r_259_819_i 259_819 819 93218.1
c_259_819_i 259 259_819 2.08965e-09
r_819_1379_e 819 1379 13376.4
r_819_1379_i 819_1379 1379 93218.1
c_819_1379_i 819 819_1379 2.08965e-09
r_1379_1939_e 1379 1939 836.944
r_1379_1939_i 1379_1939 1939 4256.89
c_1379_1939_i 1379 1379_1939 4.67522e-10
r_1939_2499_e 1939 2499 836.944
r_1939_2499_i 1939_2499 2499 4256.89
c_1939_2499_i 1939 1939_2499 4.67522e-10
r_2499_3059_e 2499 3059 836.944
r_2499_3059_i 2499_3059 3059 4256.89
c_2499_3059_i 2499 2499_3059 4.67522e-10
r_3059_3619_e 3059 3619 836.944
r_3059_3619_i 3059_3619 3619 4256.89
c_3059_3619_i 3059 3059_3619 4.67522e-10
r_260_820_e 260 820 13376.4
r_260_820_i 260_820 820 93218.1
c_260_820_i 260 260_820 2.08965e-09
r_820_1380_e 820 1380 13376.4
r_820_1380_i 820_1380 1380 93218.1
c_820_1380_i 820 820_1380 2.08965e-09
r_1380_1940_e 1380 1940 836.944
r_1380_1940_i 1380_1940 1940 4256.89
c_1380_1940_i 1380 1380_1940 4.67522e-10
r_1940_2500_e 1940 2500 836.944
r_1940_2500_i 1940_2500 2500 4256.89
c_1940_2500_i 1940 1940_2500 4.67522e-10
r_2500_3060_e 2500 3060 836.944
r_2500_3060_i 2500_3060 3060 4256.89
c_2500_3060_i 2500 2500_3060 4.67522e-10
r_3060_3620_e 3060 3620 13758.3
r_3060_3620_i 3060_3620 3620 95645.6
c_3060_3620_i 3060 3060_3620 9.36084e-12
r_261_821_e 261 821 13376.4
r_261_821_i 261_821 821 93218.1
c_261_821_i 261 261_821 2.08965e-09
r_821_1381_e 821 1381 13376.4
r_821_1381_i 821_1381 1381 93218.1
c_821_1381_i 821 821_1381 2.08965e-09
r_1381_1941_e 1381 1941 836.944
r_1381_1941_i 1381_1941 1941 4256.89
c_1381_1941_i 1381 1381_1941 4.67522e-10
r_1941_2501_e 1941 2501 836.944
r_1941_2501_i 1941_2501 2501 4256.89
c_1941_2501_i 1941 1941_2501 4.67522e-10
r_2501_3061_e 2501 3061 836.944
r_2501_3061_i 2501_3061 3061 4256.89
c_2501_3061_i 2501 2501_3061 4.67522e-10
r_3061_3621_e 3061 3621 13758.3
r_3061_3621_i 3061_3621 3621 95645.6
c_3061_3621_i 3061 3061_3621 9.36084e-12
r_262_822_e 262 822 13376.4
r_262_822_i 262_822 822 93218.1
c_262_822_i 262 262_822 2.08965e-09
r_822_1382_e 822 1382 13376.4
r_822_1382_i 822_1382 1382 93218.1
c_822_1382_i 822 822_1382 2.08965e-09
r_1382_1942_e 1382 1942 836.944
r_1382_1942_i 1382_1942 1942 4256.89
c_1382_1942_i 1382 1382_1942 4.67522e-10
r_1942_2502_e 1942 2502 836.944
r_1942_2502_i 1942_2502 2502 4256.89
c_1942_2502_i 1942 1942_2502 4.67522e-10
r_2502_3062_e 2502 3062 836.944
r_2502_3062_i 2502_3062 3062 4256.89
c_2502_3062_i 2502 2502_3062 4.67522e-10
r_3062_3622_e 3062 3622 13758.3
r_3062_3622_i 3062_3622 3622 95645.6
c_3062_3622_i 3062 3062_3622 9.36084e-12
r_263_823_e 263 823 13376.4
r_263_823_i 263_823 823 93218.1
c_263_823_i 263 263_823 2.08965e-09
r_823_1383_e 823 1383 13376.4
r_823_1383_i 823_1383 1383 93218.1
c_823_1383_i 823 823_1383 2.08965e-09
r_1383_1943_e 1383 1943 836.944
r_1383_1943_i 1383_1943 1943 4256.89
c_1383_1943_i 1383 1383_1943 4.67522e-10
r_1943_2503_e 1943 2503 836.944
r_1943_2503_i 1943_2503 2503 4256.89
c_1943_2503_i 1943 1943_2503 4.67522e-10
r_2503_3063_e 2503 3063 836.944
r_2503_3063_i 2503_3063 3063 4256.89
c_2503_3063_i 2503 2503_3063 4.67522e-10
r_3063_3623_e 3063 3623 13758.3
r_3063_3623_i 3063_3623 3623 95645.6
c_3063_3623_i 3063 3063_3623 9.36084e-12
r_264_824_e 264 824 13376.4
r_264_824_i 264_824 824 93218.1
c_264_824_i 264 264_824 2.08965e-09
r_824_1384_e 824 1384 13376.4
r_824_1384_i 824_1384 1384 93218.1
c_824_1384_i 824 824_1384 2.08965e-09
r_1384_1944_e 1384 1944 836.944
r_1384_1944_i 1384_1944 1944 4256.89
c_1384_1944_i 1384 1384_1944 4.67522e-10
r_1944_2504_e 1944 2504 836.944
r_1944_2504_i 1944_2504 2504 4256.89
c_1944_2504_i 1944 1944_2504 4.67522e-10
r_2504_3064_e 2504 3064 836.944
r_2504_3064_i 2504_3064 3064 4256.89
c_2504_3064_i 2504 2504_3064 4.67522e-10
r_3064_3624_e 3064 3624 13758.3
r_3064_3624_i 3064_3624 3624 95645.6
c_3064_3624_i 3064 3064_3624 9.36084e-12
r_265_825_e 265 825 13376.4
r_265_825_i 265_825 825 93218.1
c_265_825_i 265 265_825 2.08965e-09
r_825_1385_e 825 1385 13376.4
r_825_1385_i 825_1385 1385 93218.1
c_825_1385_i 825 825_1385 2.08965e-09
r_1385_1945_e 1385 1945 836.944
r_1385_1945_i 1385_1945 1945 4256.89
c_1385_1945_i 1385 1385_1945 4.67522e-10
r_1945_2505_e 1945 2505 836.944
r_1945_2505_i 1945_2505 2505 4256.89
c_1945_2505_i 1945 1945_2505 4.67522e-10
r_2505_3065_e 2505 3065 836.944
r_2505_3065_i 2505_3065 3065 4256.89
c_2505_3065_i 2505 2505_3065 4.67522e-10
r_3065_3625_e 3065 3625 13758.3
r_3065_3625_i 3065_3625 3625 95645.6
c_3065_3625_i 3065 3065_3625 9.36084e-12
r_266_826_e 266 826 13376.4
r_266_826_i 266_826 826 93218.1
c_266_826_i 266 266_826 2.08965e-09
r_826_1386_e 826 1386 13376.4
r_826_1386_i 826_1386 1386 93218.1
c_826_1386_i 826 826_1386 2.08965e-09
r_1386_1946_e 1386 1946 836.944
r_1386_1946_i 1386_1946 1946 4256.89
c_1386_1946_i 1386 1386_1946 4.67522e-10
r_1946_2506_e 1946 2506 836.944
r_1946_2506_i 1946_2506 2506 4256.89
c_1946_2506_i 1946 1946_2506 4.67522e-10
r_2506_3066_e 2506 3066 836.944
r_2506_3066_i 2506_3066 3066 4256.89
c_2506_3066_i 2506 2506_3066 4.67522e-10
r_3066_3626_e 3066 3626 13758.3
r_3066_3626_i 3066_3626 3626 95645.6
c_3066_3626_i 3066 3066_3626 9.36084e-12
r_267_827_e 267 827 13376.4
r_267_827_i 267_827 827 93218.1
c_267_827_i 267 267_827 2.08965e-09
r_827_1387_e 827 1387 13376.4
r_827_1387_i 827_1387 1387 93218.1
c_827_1387_i 827 827_1387 2.08965e-09
r_1387_1947_e 1387 1947 396.636
r_1387_1947_i 1387_1947 1947 1005.11
c_1387_1947_i 1387 1387_1947 1.65821e-10
r_1947_2507_e 1947 2507 836.944
r_1947_2507_i 1947_2507 2507 4256.89
c_1947_2507_i 1947 1947_2507 4.67522e-10
r_2507_3067_e 2507 3067 836.944
r_2507_3067_i 2507_3067 3067 4256.89
c_2507_3067_i 2507 2507_3067 4.67522e-10
r_3067_3627_e 3067 3627 13758.3
r_3067_3627_i 3067_3627 3627 95645.6
c_3067_3627_i 3067 3067_3627 9.36084e-12
r_268_828_e 268 828 13376.4
r_268_828_i 268_828 828 93218.1
c_268_828_i 268 268_828 2.08965e-09
r_828_1388_e 828 1388 13376.4
r_828_1388_i 828_1388 1388 93218.1
c_828_1388_i 828 828_1388 2.08965e-09
r_1388_1948_e 1388 1948 396.636
r_1388_1948_i 1388_1948 1948 1005.11
c_1388_1948_i 1388 1388_1948 1.65821e-10
r_1948_2508_e 1948 2508 836.944
r_1948_2508_i 1948_2508 2508 4256.89
c_1948_2508_i 1948 1948_2508 4.67522e-10
r_2508_3068_e 2508 3068 836.944
r_2508_3068_i 2508_3068 3068 4256.89
c_2508_3068_i 2508 2508_3068 4.67522e-10
r_3068_3628_e 3068 3628 13758.3
r_3068_3628_i 3068_3628 3628 95645.6
c_3068_3628_i 3068 3068_3628 9.36084e-12
r_269_829_e 269 829 13376.4
r_269_829_i 269_829 829 93218.1
c_269_829_i 269 269_829 2.08965e-09
r_829_1389_e 829 1389 13376.4
r_829_1389_i 829_1389 1389 93218.1
c_829_1389_i 829 829_1389 2.08965e-09
r_1389_1949_e 1389 1949 836.944
r_1389_1949_i 1389_1949 1949 4256.89
c_1389_1949_i 1389 1389_1949 4.67522e-10
r_1949_2509_e 1949 2509 836.944
r_1949_2509_i 1949_2509 2509 4256.89
c_1949_2509_i 1949 1949_2509 4.67522e-10
r_2509_3069_e 2509 3069 836.944
r_2509_3069_i 2509_3069 3069 4256.89
c_2509_3069_i 2509 2509_3069 4.67522e-10
r_3069_3629_e 3069 3629 13758.3
r_3069_3629_i 3069_3629 3629 95645.6
c_3069_3629_i 3069 3069_3629 9.36084e-12
r_270_830_e 270 830 13376.4
r_270_830_i 270_830 830 93218.1
c_270_830_i 270 270_830 2.08965e-09
r_830_1390_e 830 1390 13376.4
r_830_1390_i 830_1390 1390 93218.1
c_830_1390_i 830 830_1390 2.08965e-09
r_1390_1950_e 1390 1950 836.944
r_1390_1950_i 1390_1950 1950 4256.89
c_1390_1950_i 1390 1390_1950 4.67522e-10
r_1950_2510_e 1950 2510 836.944
r_1950_2510_i 1950_2510 2510 4256.89
c_1950_2510_i 1950 1950_2510 4.67522e-10
r_2510_3070_e 2510 3070 836.944
r_2510_3070_i 2510_3070 3070 4256.89
c_2510_3070_i 2510 2510_3070 4.67522e-10
r_3070_3630_e 3070 3630 13758.3
r_3070_3630_i 3070_3630 3630 95645.6
c_3070_3630_i 3070 3070_3630 9.36084e-12
r_271_831_e 271 831 13376.4
r_271_831_i 271_831 831 93218.1
c_271_831_i 271 271_831 2.08965e-09
r_831_1391_e 831 1391 13376.4
r_831_1391_i 831_1391 1391 93218.1
c_831_1391_i 831 831_1391 2.08965e-09
r_1391_1951_e 1391 1951 836.944
r_1391_1951_i 1391_1951 1951 4256.89
c_1391_1951_i 1391 1391_1951 4.67522e-10
r_1951_2511_e 1951 2511 836.944
r_1951_2511_i 1951_2511 2511 4256.89
c_1951_2511_i 1951 1951_2511 4.67522e-10
r_2511_3071_e 2511 3071 836.944
r_2511_3071_i 2511_3071 3071 4256.89
c_2511_3071_i 2511 2511_3071 4.67522e-10
r_3071_3631_e 3071 3631 13758.3
r_3071_3631_i 3071_3631 3631 95645.6
c_3071_3631_i 3071 3071_3631 9.36084e-12
r_272_832_e 272 832 13376.4
r_272_832_i 272_832 832 93218.1
c_272_832_i 272 272_832 2.08965e-09
r_832_1392_e 832 1392 13376.4
r_832_1392_i 832_1392 1392 93218.1
c_832_1392_i 832 832_1392 2.08965e-09
r_1392_1952_e 1392 1952 836.944
r_1392_1952_i 1392_1952 1952 4256.89
c_1392_1952_i 1392 1392_1952 4.67522e-10
r_1952_2512_e 1952 2512 836.944
r_1952_2512_i 1952_2512 2512 4256.89
c_1952_2512_i 1952 1952_2512 4.67522e-10
r_2512_3072_e 2512 3072 836.944
r_2512_3072_i 2512_3072 3072 4256.89
c_2512_3072_i 2512 2512_3072 4.67522e-10
r_3072_3632_e 3072 3632 13758.3
r_3072_3632_i 3072_3632 3632 95645.6
c_3072_3632_i 3072 3072_3632 9.36084e-12
r_273_833_e 273 833 13376.4
r_273_833_i 273_833 833 93218.1
c_273_833_i 273 273_833 2.08965e-09
r_833_1393_e 833 1393 13376.4
r_833_1393_i 833_1393 1393 93218.1
c_833_1393_i 833 833_1393 2.08965e-09
r_1393_1953_e 1393 1953 13376.4
r_1393_1953_i 1393_1953 1953 93218.1
c_1393_1953_i 1393 1393_1953 2.08965e-09
r_1953_2513_e 1953 2513 13376.4
r_1953_2513_i 1953_2513 2513 93218.1
c_1953_2513_i 1953 1953_2513 2.08965e-09
r_2513_3073_e 2513 3073 13376.4
r_2513_3073_i 2513_3073 3073 93218.1
c_2513_3073_i 2513 2513_3073 2.08965e-09
r_3073_3633_e 3073 3633 13376.4
r_3073_3633_i 3073_3633 3633 93218.1
c_3073_3633_i 3073 3073_3633 2.08965e-09
r_274_834_e 274 834 13376.4
r_274_834_i 274_834 834 93218.1
c_274_834_i 274 274_834 2.08965e-09
r_834_1394_e 834 1394 13376.4
r_834_1394_i 834_1394 1394 93218.1
c_834_1394_i 834 834_1394 2.08965e-09
r_1394_1954_e 1394 1954 13376.4
r_1394_1954_i 1394_1954 1954 93218.1
c_1394_1954_i 1394 1394_1954 2.08965e-09
r_1954_2514_e 1954 2514 13376.4
r_1954_2514_i 1954_2514 2514 93218.1
c_1954_2514_i 1954 1954_2514 2.08965e-09
r_2514_3074_e 2514 3074 13376.4
r_2514_3074_i 2514_3074 3074 93218.1
c_2514_3074_i 2514 2514_3074 2.08965e-09
r_3074_3634_e 3074 3634 13376.4
r_3074_3634_i 3074_3634 3634 93218.1
c_3074_3634_i 3074 3074_3634 2.08965e-09
r_275_835_e 275 835 13376.4
r_275_835_i 275_835 835 93218.1
c_275_835_i 275 275_835 2.08965e-09
r_835_1395_e 835 1395 13376.4
r_835_1395_i 835_1395 1395 93218.1
c_835_1395_i 835 835_1395 2.08965e-09
r_1395_1955_e 1395 1955 836.944
r_1395_1955_i 1395_1955 1955 4256.89
c_1395_1955_i 1395 1395_1955 4.67522e-10
r_1955_2515_e 1955 2515 836.944
r_1955_2515_i 1955_2515 2515 4256.89
c_1955_2515_i 1955 1955_2515 4.67522e-10
r_2515_3075_e 2515 3075 836.944
r_2515_3075_i 2515_3075 3075 4256.89
c_2515_3075_i 2515 2515_3075 4.67522e-10
r_3075_3635_e 3075 3635 836.944
r_3075_3635_i 3075_3635 3635 4256.89
c_3075_3635_i 3075 3075_3635 4.67522e-10
r_276_836_e 276 836 13376.4
r_276_836_i 276_836 836 93218.1
c_276_836_i 276 276_836 2.08965e-09
r_836_1396_e 836 1396 13376.4
r_836_1396_i 836_1396 1396 93218.1
c_836_1396_i 836 836_1396 2.08965e-09
r_1396_1956_e 1396 1956 836.944
r_1396_1956_i 1396_1956 1956 4256.89
c_1396_1956_i 1396 1396_1956 4.67522e-10
r_1956_2516_e 1956 2516 836.944
r_1956_2516_i 1956_2516 2516 4256.89
c_1956_2516_i 1956 1956_2516 4.67522e-10
r_2516_3076_e 2516 3076 836.944
r_2516_3076_i 2516_3076 3076 4256.89
c_2516_3076_i 2516 2516_3076 4.67522e-10
r_3076_3636_e 3076 3636 13758.3
r_3076_3636_i 3076_3636 3636 95645.6
c_3076_3636_i 3076 3076_3636 9.36084e-12
r_277_837_e 277 837 13376.4
r_277_837_i 277_837 837 93218.1
c_277_837_i 277 277_837 2.08965e-09
r_837_1397_e 837 1397 13376.4
r_837_1397_i 837_1397 1397 93218.1
c_837_1397_i 837 837_1397 2.08965e-09
r_1397_1957_e 1397 1957 836.944
r_1397_1957_i 1397_1957 1957 4256.89
c_1397_1957_i 1397 1397_1957 4.67522e-10
r_1957_2517_e 1957 2517 836.944
r_1957_2517_i 1957_2517 2517 4256.89
c_1957_2517_i 1957 1957_2517 4.67522e-10
r_2517_3077_e 2517 3077 836.944
r_2517_3077_i 2517_3077 3077 4256.89
c_2517_3077_i 2517 2517_3077 4.67522e-10
r_3077_3637_e 3077 3637 13758.3
r_3077_3637_i 3077_3637 3637 95645.6
c_3077_3637_i 3077 3077_3637 9.36084e-12
r_278_838_e 278 838 13376.4
r_278_838_i 278_838 838 93218.1
c_278_838_i 278 278_838 2.08965e-09
r_838_1398_e 838 1398 13376.4
r_838_1398_i 838_1398 1398 93218.1
c_838_1398_i 838 838_1398 2.08965e-09
r_1398_1958_e 1398 1958 836.944
r_1398_1958_i 1398_1958 1958 4256.89
c_1398_1958_i 1398 1398_1958 4.67522e-10
r_1958_2518_e 1958 2518 836.944
r_1958_2518_i 1958_2518 2518 4256.89
c_1958_2518_i 1958 1958_2518 4.67522e-10
r_2518_3078_e 2518 3078 836.944
r_2518_3078_i 2518_3078 3078 4256.89
c_2518_3078_i 2518 2518_3078 4.67522e-10
r_3078_3638_e 3078 3638 13758.3
r_3078_3638_i 3078_3638 3638 95645.6
c_3078_3638_i 3078 3078_3638 9.36084e-12
r_279_839_e 279 839 13376.4
r_279_839_i 279_839 839 93218.1
c_279_839_i 279 279_839 2.08965e-09
r_839_1399_e 839 1399 13376.4
r_839_1399_i 839_1399 1399 93218.1
c_839_1399_i 839 839_1399 2.08965e-09
r_1399_1959_e 1399 1959 836.944
r_1399_1959_i 1399_1959 1959 4256.89
c_1399_1959_i 1399 1399_1959 4.67522e-10
r_1959_2519_e 1959 2519 836.944
r_1959_2519_i 1959_2519 2519 4256.89
c_1959_2519_i 1959 1959_2519 4.67522e-10
r_2519_3079_e 2519 3079 836.944
r_2519_3079_i 2519_3079 3079 4256.89
c_2519_3079_i 2519 2519_3079 4.67522e-10
r_3079_3639_e 3079 3639 13758.3
r_3079_3639_i 3079_3639 3639 95645.6
c_3079_3639_i 3079 3079_3639 9.36084e-12
r_280_840_e 280 840 13376.4
r_280_840_i 280_840 840 93218.1
c_280_840_i 280 280_840 2.08965e-09
r_840_1400_e 840 1400 13376.4
r_840_1400_i 840_1400 1400 93218.1
c_840_1400_i 840 840_1400 2.08965e-09
r_1400_1960_e 1400 1960 836.944
r_1400_1960_i 1400_1960 1960 4256.89
c_1400_1960_i 1400 1400_1960 4.67522e-10
r_1960_2520_e 1960 2520 836.944
r_1960_2520_i 1960_2520 2520 4256.89
c_1960_2520_i 1960 1960_2520 4.67522e-10
r_2520_3080_e 2520 3080 836.944
r_2520_3080_i 2520_3080 3080 4256.89
c_2520_3080_i 2520 2520_3080 4.67522e-10
r_3080_3640_e 3080 3640 13758.3
r_3080_3640_i 3080_3640 3640 95645.6
c_3080_3640_i 3080 3080_3640 9.36084e-12
r_281_841_e 281 841 13376.4
r_281_841_i 281_841 841 93218.1
c_281_841_i 281 281_841 2.08965e-09
r_841_1401_e 841 1401 13376.4
r_841_1401_i 841_1401 1401 93218.1
c_841_1401_i 841 841_1401 2.08965e-09
r_1401_1961_e 1401 1961 836.944
r_1401_1961_i 1401_1961 1961 4256.89
c_1401_1961_i 1401 1401_1961 4.67522e-10
r_1961_2521_e 1961 2521 836.944
r_1961_2521_i 1961_2521 2521 4256.89
c_1961_2521_i 1961 1961_2521 4.67522e-10
r_2521_3081_e 2521 3081 836.944
r_2521_3081_i 2521_3081 3081 4256.89
c_2521_3081_i 2521 2521_3081 4.67522e-10
r_3081_3641_e 3081 3641 13758.3
r_3081_3641_i 3081_3641 3641 95645.6
c_3081_3641_i 3081 3081_3641 9.36084e-12
r_282_842_e 282 842 13376.4
r_282_842_i 282_842 842 93218.1
c_282_842_i 282 282_842 2.08965e-09
r_842_1402_e 842 1402 13376.4
r_842_1402_i 842_1402 1402 93218.1
c_842_1402_i 842 842_1402 2.08965e-09
r_1402_1962_e 1402 1962 836.944
r_1402_1962_i 1402_1962 1962 4256.89
c_1402_1962_i 1402 1402_1962 4.67522e-10
r_1962_2522_e 1962 2522 836.944
r_1962_2522_i 1962_2522 2522 4256.89
c_1962_2522_i 1962 1962_2522 4.67522e-10
r_2522_3082_e 2522 3082 836.944
r_2522_3082_i 2522_3082 3082 4256.89
c_2522_3082_i 2522 2522_3082 4.67522e-10
r_3082_3642_e 3082 3642 13758.3
r_3082_3642_i 3082_3642 3642 95645.6
c_3082_3642_i 3082 3082_3642 9.36084e-12
r_283_843_e 283 843 13376.4
r_283_843_i 283_843 843 93218.1
c_283_843_i 283 283_843 2.08965e-09
r_843_1403_e 843 1403 13376.4
r_843_1403_i 843_1403 1403 93218.1
c_843_1403_i 843 843_1403 2.08965e-09
r_1403_1963_e 1403 1963 396.628
r_1403_1963_i 1403_1963 1963 1005.09
c_1403_1963_i 1403 1403_1963 1.65824e-10
r_1963_2523_e 1963 2523 836.944
r_1963_2523_i 1963_2523 2523 4256.89
c_1963_2523_i 1963 1963_2523 4.67522e-10
r_2523_3083_e 2523 3083 836.944
r_2523_3083_i 2523_3083 3083 4256.89
c_2523_3083_i 2523 2523_3083 4.67522e-10
r_3083_3643_e 3083 3643 13758.3
r_3083_3643_i 3083_3643 3643 95645.6
c_3083_3643_i 3083 3083_3643 9.36084e-12
r_284_844_e 284 844 13376.4
r_284_844_i 284_844 844 93218.1
c_284_844_i 284 284_844 2.08965e-09
r_844_1404_e 844 1404 13376.4
r_844_1404_i 844_1404 1404 93218.1
c_844_1404_i 844 844_1404 2.08965e-09
r_1404_1964_e 1404 1964 396.628
r_1404_1964_i 1404_1964 1964 1005.09
c_1404_1964_i 1404 1404_1964 1.65824e-10
r_1964_2524_e 1964 2524 836.944
r_1964_2524_i 1964_2524 2524 4256.89
c_1964_2524_i 1964 1964_2524 4.67522e-10
r_2524_3084_e 2524 3084 836.944
r_2524_3084_i 2524_3084 3084 4256.89
c_2524_3084_i 2524 2524_3084 4.67522e-10
r_3084_3644_e 3084 3644 13758.3
r_3084_3644_i 3084_3644 3644 95645.6
c_3084_3644_i 3084 3084_3644 9.36084e-12
r_285_845_e 285 845 13376.4
r_285_845_i 285_845 845 93218.1
c_285_845_i 285 285_845 2.08965e-09
r_845_1405_e 845 1405 13376.4
r_845_1405_i 845_1405 1405 93218.1
c_845_1405_i 845 845_1405 2.08965e-09
r_1405_1965_e 1405 1965 836.944
r_1405_1965_i 1405_1965 1965 4256.89
c_1405_1965_i 1405 1405_1965 4.67522e-10
r_1965_2525_e 1965 2525 836.944
r_1965_2525_i 1965_2525 2525 4256.89
c_1965_2525_i 1965 1965_2525 4.67522e-10
r_2525_3085_e 2525 3085 836.944
r_2525_3085_i 2525_3085 3085 4256.89
c_2525_3085_i 2525 2525_3085 4.67522e-10
r_3085_3645_e 3085 3645 13758.3
r_3085_3645_i 3085_3645 3645 95645.6
c_3085_3645_i 3085 3085_3645 9.36084e-12
r_286_846_e 286 846 13376.4
r_286_846_i 286_846 846 93218.1
c_286_846_i 286 286_846 2.08965e-09
r_846_1406_e 846 1406 13376.4
r_846_1406_i 846_1406 1406 93218.1
c_846_1406_i 846 846_1406 2.08965e-09
r_1406_1966_e 1406 1966 836.944
r_1406_1966_i 1406_1966 1966 4256.89
c_1406_1966_i 1406 1406_1966 4.67522e-10
r_1966_2526_e 1966 2526 836.944
r_1966_2526_i 1966_2526 2526 4256.89
c_1966_2526_i 1966 1966_2526 4.67522e-10
r_2526_3086_e 2526 3086 836.944
r_2526_3086_i 2526_3086 3086 4256.89
c_2526_3086_i 2526 2526_3086 4.67522e-10
r_3086_3646_e 3086 3646 13758.3
r_3086_3646_i 3086_3646 3646 95645.6
c_3086_3646_i 3086 3086_3646 9.36084e-12
r_287_847_e 287 847 13376.4
r_287_847_i 287_847 847 93218.1
c_287_847_i 287 287_847 2.08965e-09
r_847_1407_e 847 1407 13376.4
r_847_1407_i 847_1407 1407 93218.1
c_847_1407_i 847 847_1407 2.08965e-09
r_1407_1967_e 1407 1967 836.944
r_1407_1967_i 1407_1967 1967 4256.89
c_1407_1967_i 1407 1407_1967 4.67522e-10
r_1967_2527_e 1967 2527 836.944
r_1967_2527_i 1967_2527 2527 4256.89
c_1967_2527_i 1967 1967_2527 4.67522e-10
r_2527_3087_e 2527 3087 836.944
r_2527_3087_i 2527_3087 3087 4256.89
c_2527_3087_i 2527 2527_3087 4.67522e-10
r_3087_3647_e 3087 3647 13758.3
r_3087_3647_i 3087_3647 3647 95645.6
c_3087_3647_i 3087 3087_3647 9.36084e-12
r_288_848_e 288 848 13376.4
r_288_848_i 288_848 848 93218.1
c_288_848_i 288 288_848 2.08965e-09
r_848_1408_e 848 1408 13376.4
r_848_1408_i 848_1408 1408 93218.1
c_848_1408_i 848 848_1408 2.08965e-09
r_1408_1968_e 1408 1968 836.944
r_1408_1968_i 1408_1968 1968 4256.89
c_1408_1968_i 1408 1408_1968 4.67522e-10
r_1968_2528_e 1968 2528 836.944
r_1968_2528_i 1968_2528 2528 4256.89
c_1968_2528_i 1968 1968_2528 4.67522e-10
r_2528_3088_e 2528 3088 836.944
r_2528_3088_i 2528_3088 3088 4256.89
c_2528_3088_i 2528 2528_3088 4.67522e-10
r_3088_3648_e 3088 3648 13758.3
r_3088_3648_i 3088_3648 3648 95645.6
c_3088_3648_i 3088 3088_3648 9.36084e-12
r_289_849_e 289 849 13376.4
r_289_849_i 289_849 849 93218.1
c_289_849_i 289 289_849 2.08965e-09
r_849_1409_e 849 1409 13376.4
r_849_1409_i 849_1409 1409 93218.1
c_849_1409_i 849 849_1409 2.08965e-09
r_1409_1969_e 1409 1969 13376.4
r_1409_1969_i 1409_1969 1969 93218.1
c_1409_1969_i 1409 1409_1969 2.08965e-09
r_1969_2529_e 1969 2529 13376.4
r_1969_2529_i 1969_2529 2529 93218.1
c_1969_2529_i 1969 1969_2529 2.08965e-09
r_2529_3089_e 2529 3089 13376.4
r_2529_3089_i 2529_3089 3089 93218.1
c_2529_3089_i 2529 2529_3089 2.08965e-09
r_3089_3649_e 3089 3649 13376.4
r_3089_3649_i 3089_3649 3649 93218.1
c_3089_3649_i 3089 3089_3649 2.08965e-09
r_290_850_e 290 850 13376.4
r_290_850_i 290_850 850 93218.1
c_290_850_i 290 290_850 2.08965e-09
r_850_1410_e 850 1410 13376.4
r_850_1410_i 850_1410 1410 93218.1
c_850_1410_i 850 850_1410 2.08965e-09
r_1410_1970_e 1410 1970 13376.4
r_1410_1970_i 1410_1970 1970 93218.1
c_1410_1970_i 1410 1410_1970 2.08965e-09
r_1970_2530_e 1970 2530 13376.4
r_1970_2530_i 1970_2530 2530 93218.1
c_1970_2530_i 1970 1970_2530 2.08965e-09
r_2530_3090_e 2530 3090 13376.4
r_2530_3090_i 2530_3090 3090 93218.1
c_2530_3090_i 2530 2530_3090 2.08965e-09
r_3090_3650_e 3090 3650 13376.4
r_3090_3650_i 3090_3650 3650 93218.1
c_3090_3650_i 3090 3090_3650 2.08965e-09
r_291_851_e 291 851 13376.4
r_291_851_i 291_851 851 93218.1
c_291_851_i 291 291_851 2.08965e-09
r_851_1411_e 851 1411 13376.4
r_851_1411_i 851_1411 1411 93218.1
c_851_1411_i 851 851_1411 2.08965e-09
r_1411_1971_e 1411 1971 836.944
r_1411_1971_i 1411_1971 1971 4256.89
c_1411_1971_i 1411 1411_1971 4.67522e-10
r_1971_2531_e 1971 2531 836.944
r_1971_2531_i 1971_2531 2531 4256.89
c_1971_2531_i 1971 1971_2531 4.67522e-10
r_2531_3091_e 2531 3091 836.944
r_2531_3091_i 2531_3091 3091 4256.89
c_2531_3091_i 2531 2531_3091 4.67522e-10
r_3091_3651_e 3091 3651 836.944
r_3091_3651_i 3091_3651 3651 4256.89
c_3091_3651_i 3091 3091_3651 4.67522e-10
r_292_852_e 292 852 13376.4
r_292_852_i 292_852 852 93218.1
c_292_852_i 292 292_852 2.08965e-09
r_852_1412_e 852 1412 13376.4
r_852_1412_i 852_1412 1412 93218.1
c_852_1412_i 852 852_1412 2.08965e-09
r_1412_1972_e 1412 1972 836.944
r_1412_1972_i 1412_1972 1972 4256.89
c_1412_1972_i 1412 1412_1972 4.67522e-10
r_1972_2532_e 1972 2532 836.944
r_1972_2532_i 1972_2532 2532 4256.89
c_1972_2532_i 1972 1972_2532 4.67522e-10
r_2532_3092_e 2532 3092 836.944
r_2532_3092_i 2532_3092 3092 4256.89
c_2532_3092_i 2532 2532_3092 4.67522e-10
r_3092_3652_e 3092 3652 13758.3
r_3092_3652_i 3092_3652 3652 95645.6
c_3092_3652_i 3092 3092_3652 9.36084e-12
r_293_853_e 293 853 13376.4
r_293_853_i 293_853 853 93218.1
c_293_853_i 293 293_853 2.08965e-09
r_853_1413_e 853 1413 13376.4
r_853_1413_i 853_1413 1413 93218.1
c_853_1413_i 853 853_1413 2.08965e-09
r_1413_1973_e 1413 1973 836.944
r_1413_1973_i 1413_1973 1973 4256.89
c_1413_1973_i 1413 1413_1973 4.67522e-10
r_1973_2533_e 1973 2533 836.944
r_1973_2533_i 1973_2533 2533 4256.89
c_1973_2533_i 1973 1973_2533 4.67522e-10
r_2533_3093_e 2533 3093 836.944
r_2533_3093_i 2533_3093 3093 4256.89
c_2533_3093_i 2533 2533_3093 4.67522e-10
r_3093_3653_e 3093 3653 13758.3
r_3093_3653_i 3093_3653 3653 95645.6
c_3093_3653_i 3093 3093_3653 9.36084e-12
r_294_854_e 294 854 13376.4
r_294_854_i 294_854 854 93218.1
c_294_854_i 294 294_854 2.08965e-09
r_854_1414_e 854 1414 13376.4
r_854_1414_i 854_1414 1414 93218.1
c_854_1414_i 854 854_1414 2.08965e-09
r_1414_1974_e 1414 1974 836.944
r_1414_1974_i 1414_1974 1974 4256.89
c_1414_1974_i 1414 1414_1974 4.67522e-10
r_1974_2534_e 1974 2534 836.944
r_1974_2534_i 1974_2534 2534 4256.89
c_1974_2534_i 1974 1974_2534 4.67522e-10
r_2534_3094_e 2534 3094 836.944
r_2534_3094_i 2534_3094 3094 4256.89
c_2534_3094_i 2534 2534_3094 4.67522e-10
r_3094_3654_e 3094 3654 13758.3
r_3094_3654_i 3094_3654 3654 95645.6
c_3094_3654_i 3094 3094_3654 9.36084e-12
r_295_855_e 295 855 13376.4
r_295_855_i 295_855 855 93218.1
c_295_855_i 295 295_855 2.08965e-09
r_855_1415_e 855 1415 13376.4
r_855_1415_i 855_1415 1415 93218.1
c_855_1415_i 855 855_1415 2.08965e-09
r_1415_1975_e 1415 1975 836.944
r_1415_1975_i 1415_1975 1975 4256.89
c_1415_1975_i 1415 1415_1975 4.67522e-10
r_1975_2535_e 1975 2535 836.944
r_1975_2535_i 1975_2535 2535 4256.89
c_1975_2535_i 1975 1975_2535 4.67522e-10
r_2535_3095_e 2535 3095 836.944
r_2535_3095_i 2535_3095 3095 4256.89
c_2535_3095_i 2535 2535_3095 4.67522e-10
r_3095_3655_e 3095 3655 13758.3
r_3095_3655_i 3095_3655 3655 95645.6
c_3095_3655_i 3095 3095_3655 9.36084e-12
r_296_856_e 296 856 13376.4
r_296_856_i 296_856 856 93218.1
c_296_856_i 296 296_856 2.08965e-09
r_856_1416_e 856 1416 13376.4
r_856_1416_i 856_1416 1416 93218.1
c_856_1416_i 856 856_1416 2.08965e-09
r_1416_1976_e 1416 1976 836.944
r_1416_1976_i 1416_1976 1976 4256.89
c_1416_1976_i 1416 1416_1976 4.67522e-10
r_1976_2536_e 1976 2536 836.944
r_1976_2536_i 1976_2536 2536 4256.89
c_1976_2536_i 1976 1976_2536 4.67522e-10
r_2536_3096_e 2536 3096 836.944
r_2536_3096_i 2536_3096 3096 4256.89
c_2536_3096_i 2536 2536_3096 4.67522e-10
r_3096_3656_e 3096 3656 13758.3
r_3096_3656_i 3096_3656 3656 95645.6
c_3096_3656_i 3096 3096_3656 9.36084e-12
r_297_857_e 297 857 13376.4
r_297_857_i 297_857 857 93218.1
c_297_857_i 297 297_857 2.08965e-09
r_857_1417_e 857 1417 13376.4
r_857_1417_i 857_1417 1417 93218.1
c_857_1417_i 857 857_1417 2.08965e-09
r_1417_1977_e 1417 1977 836.944
r_1417_1977_i 1417_1977 1977 4256.89
c_1417_1977_i 1417 1417_1977 4.67522e-10
r_1977_2537_e 1977 2537 836.944
r_1977_2537_i 1977_2537 2537 4256.89
c_1977_2537_i 1977 1977_2537 4.67522e-10
r_2537_3097_e 2537 3097 836.944
r_2537_3097_i 2537_3097 3097 4256.89
c_2537_3097_i 2537 2537_3097 4.67522e-10
r_3097_3657_e 3097 3657 13758.3
r_3097_3657_i 3097_3657 3657 95645.6
c_3097_3657_i 3097 3097_3657 9.36084e-12
r_298_858_e 298 858 13376.4
r_298_858_i 298_858 858 93218.1
c_298_858_i 298 298_858 2.08965e-09
r_858_1418_e 858 1418 13376.4
r_858_1418_i 858_1418 1418 93218.1
c_858_1418_i 858 858_1418 2.08965e-09
r_1418_1978_e 1418 1978 836.944
r_1418_1978_i 1418_1978 1978 4256.89
c_1418_1978_i 1418 1418_1978 4.67522e-10
r_1978_2538_e 1978 2538 836.944
r_1978_2538_i 1978_2538 2538 4256.89
c_1978_2538_i 1978 1978_2538 4.67522e-10
r_2538_3098_e 2538 3098 836.944
r_2538_3098_i 2538_3098 3098 4256.89
c_2538_3098_i 2538 2538_3098 4.67522e-10
r_3098_3658_e 3098 3658 13758.3
r_3098_3658_i 3098_3658 3658 95645.6
c_3098_3658_i 3098 3098_3658 9.36084e-12
r_299_859_e 299 859 13376.4
r_299_859_i 299_859 859 93218.1
c_299_859_i 299 299_859 2.08965e-09
r_859_1419_e 859 1419 396.619
r_859_1419_i 859_1419 1419 1005.07
c_859_1419_i 859 859_1419 1.65828e-10
r_1419_1979_e 1419 1979 836.944
r_1419_1979_i 1419_1979 1979 4256.89
c_1419_1979_i 1419 1419_1979 4.67522e-10
r_1979_2539_e 1979 2539 836.944
r_1979_2539_i 1979_2539 2539 4256.89
c_1979_2539_i 1979 1979_2539 4.67522e-10
r_2539_3099_e 2539 3099 836.944
r_2539_3099_i 2539_3099 3099 4256.89
c_2539_3099_i 2539 2539_3099 4.67522e-10
r_3099_3659_e 3099 3659 13758.3
r_3099_3659_i 3099_3659 3659 95645.6
c_3099_3659_i 3099 3099_3659 9.36084e-12
r_300_860_e 300 860 13376.4
r_300_860_i 300_860 860 93218.1
c_300_860_i 300 300_860 2.08965e-09
r_860_1420_e 860 1420 396.619
r_860_1420_i 860_1420 1420 1005.07
c_860_1420_i 860 860_1420 1.65828e-10
r_1420_1980_e 1420 1980 836.944
r_1420_1980_i 1420_1980 1980 4256.89
c_1420_1980_i 1420 1420_1980 4.67522e-10
r_1980_2540_e 1980 2540 836.944
r_1980_2540_i 1980_2540 2540 4256.89
c_1980_2540_i 1980 1980_2540 4.67522e-10
r_2540_3100_e 2540 3100 836.944
r_2540_3100_i 2540_3100 3100 4256.89
c_2540_3100_i 2540 2540_3100 4.67522e-10
r_3100_3660_e 3100 3660 13758.3
r_3100_3660_i 3100_3660 3660 95645.6
c_3100_3660_i 3100 3100_3660 9.36084e-12
r_301_861_e 301 861 13376.4
r_301_861_i 301_861 861 93218.1
c_301_861_i 301 301_861 2.08965e-09
r_861_1421_e 861 1421 13376.4
r_861_1421_i 861_1421 1421 93218.1
c_861_1421_i 861 861_1421 2.08965e-09
r_1421_1981_e 1421 1981 836.944
r_1421_1981_i 1421_1981 1981 4256.89
c_1421_1981_i 1421 1421_1981 4.67522e-10
r_1981_2541_e 1981 2541 836.944
r_1981_2541_i 1981_2541 2541 4256.89
c_1981_2541_i 1981 1981_2541 4.67522e-10
r_2541_3101_e 2541 3101 836.944
r_2541_3101_i 2541_3101 3101 4256.89
c_2541_3101_i 2541 2541_3101 4.67522e-10
r_3101_3661_e 3101 3661 13758.3
r_3101_3661_i 3101_3661 3661 95645.6
c_3101_3661_i 3101 3101_3661 9.36084e-12
r_302_862_e 302 862 13376.4
r_302_862_i 302_862 862 93218.1
c_302_862_i 302 302_862 2.08965e-09
r_862_1422_e 862 1422 13376.4
r_862_1422_i 862_1422 1422 93218.1
c_862_1422_i 862 862_1422 2.08965e-09
r_1422_1982_e 1422 1982 836.944
r_1422_1982_i 1422_1982 1982 4256.89
c_1422_1982_i 1422 1422_1982 4.67522e-10
r_1982_2542_e 1982 2542 836.944
r_1982_2542_i 1982_2542 2542 4256.89
c_1982_2542_i 1982 1982_2542 4.67522e-10
r_2542_3102_e 2542 3102 836.944
r_2542_3102_i 2542_3102 3102 4256.89
c_2542_3102_i 2542 2542_3102 4.67522e-10
r_3102_3662_e 3102 3662 13758.3
r_3102_3662_i 3102_3662 3662 95645.6
c_3102_3662_i 3102 3102_3662 9.36084e-12
r_303_863_e 303 863 13376.4
r_303_863_i 303_863 863 93218.1
c_303_863_i 303 303_863 2.08965e-09
r_863_1423_e 863 1423 13376.4
r_863_1423_i 863_1423 1423 93218.1
c_863_1423_i 863 863_1423 2.08965e-09
r_1423_1983_e 1423 1983 836.944
r_1423_1983_i 1423_1983 1983 4256.89
c_1423_1983_i 1423 1423_1983 4.67522e-10
r_1983_2543_e 1983 2543 836.944
r_1983_2543_i 1983_2543 2543 4256.89
c_1983_2543_i 1983 1983_2543 4.67522e-10
r_2543_3103_e 2543 3103 836.944
r_2543_3103_i 2543_3103 3103 4256.89
c_2543_3103_i 2543 2543_3103 4.67522e-10
r_3103_3663_e 3103 3663 13758.3
r_3103_3663_i 3103_3663 3663 95645.6
c_3103_3663_i 3103 3103_3663 9.36084e-12
r_304_864_e 304 864 13376.4
r_304_864_i 304_864 864 93218.1
c_304_864_i 304 304_864 2.08965e-09
r_864_1424_e 864 1424 13376.4
r_864_1424_i 864_1424 1424 93218.1
c_864_1424_i 864 864_1424 2.08965e-09
r_1424_1984_e 1424 1984 836.944
r_1424_1984_i 1424_1984 1984 4256.89
c_1424_1984_i 1424 1424_1984 4.67522e-10
r_1984_2544_e 1984 2544 836.944
r_1984_2544_i 1984_2544 2544 4256.89
c_1984_2544_i 1984 1984_2544 4.67522e-10
r_2544_3104_e 2544 3104 836.944
r_2544_3104_i 2544_3104 3104 4256.89
c_2544_3104_i 2544 2544_3104 4.67522e-10
r_3104_3664_e 3104 3664 13758.3
r_3104_3664_i 3104_3664 3664 95645.6
c_3104_3664_i 3104 3104_3664 9.36084e-12
r_305_865_e 305 865 13376.4
r_305_865_i 305_865 865 93218.1
c_305_865_i 305 305_865 2.08965e-09
r_865_1425_e 865 1425 13376.4
r_865_1425_i 865_1425 1425 93218.1
c_865_1425_i 865 865_1425 2.08965e-09
r_1425_1985_e 1425 1985 13376.4
r_1425_1985_i 1425_1985 1985 93218.1
c_1425_1985_i 1425 1425_1985 2.08965e-09
r_1985_2545_e 1985 2545 13376.4
r_1985_2545_i 1985_2545 2545 93218.1
c_1985_2545_i 1985 1985_2545 2.08965e-09
r_2545_3105_e 2545 3105 13376.4
r_2545_3105_i 2545_3105 3105 93218.1
c_2545_3105_i 2545 2545_3105 2.08965e-09
r_3105_3665_e 3105 3665 13376.4
r_3105_3665_i 3105_3665 3665 93218.1
c_3105_3665_i 3105 3105_3665 2.08965e-09
r_306_866_e 306 866 13376.4
r_306_866_i 306_866 866 93218.1
c_306_866_i 306 306_866 2.08965e-09
r_866_1426_e 866 1426 13376.4
r_866_1426_i 866_1426 1426 93218.1
c_866_1426_i 866 866_1426 2.08965e-09
r_1426_1986_e 1426 1986 13376.4
r_1426_1986_i 1426_1986 1986 93218.1
c_1426_1986_i 1426 1426_1986 2.08965e-09
r_1986_2546_e 1986 2546 13376.4
r_1986_2546_i 1986_2546 2546 93218.1
c_1986_2546_i 1986 1986_2546 2.08965e-09
r_2546_3106_e 2546 3106 13376.4
r_2546_3106_i 2546_3106 3106 93218.1
c_2546_3106_i 2546 2546_3106 2.08965e-09
r_3106_3666_e 3106 3666 13376.4
r_3106_3666_i 3106_3666 3666 93218.1
c_3106_3666_i 3106 3106_3666 2.08965e-09
r_307_867_e 307 867 13376.4
r_307_867_i 307_867 867 93218.1
c_307_867_i 307 307_867 2.08965e-09
r_867_1427_e 867 1427 13376.4
r_867_1427_i 867_1427 1427 93218.1
c_867_1427_i 867 867_1427 2.08965e-09
r_1427_1987_e 1427 1987 836.944
r_1427_1987_i 1427_1987 1987 4256.89
c_1427_1987_i 1427 1427_1987 4.67522e-10
r_1987_2547_e 1987 2547 836.944
r_1987_2547_i 1987_2547 2547 4256.89
c_1987_2547_i 1987 1987_2547 4.67522e-10
r_2547_3107_e 2547 3107 836.944
r_2547_3107_i 2547_3107 3107 4256.89
c_2547_3107_i 2547 2547_3107 4.67522e-10
r_3107_3667_e 3107 3667 836.944
r_3107_3667_i 3107_3667 3667 4256.89
c_3107_3667_i 3107 3107_3667 4.67522e-10
r_308_868_e 308 868 13376.4
r_308_868_i 308_868 868 93218.1
c_308_868_i 308 308_868 2.08965e-09
r_868_1428_e 868 1428 13376.4
r_868_1428_i 868_1428 1428 93218.1
c_868_1428_i 868 868_1428 2.08965e-09
r_1428_1988_e 1428 1988 836.944
r_1428_1988_i 1428_1988 1988 4256.89
c_1428_1988_i 1428 1428_1988 4.67522e-10
r_1988_2548_e 1988 2548 836.944
r_1988_2548_i 1988_2548 2548 4256.89
c_1988_2548_i 1988 1988_2548 4.67522e-10
r_2548_3108_e 2548 3108 836.944
r_2548_3108_i 2548_3108 3108 4256.89
c_2548_3108_i 2548 2548_3108 4.67522e-10
r_3108_3668_e 3108 3668 13758.3
r_3108_3668_i 3108_3668 3668 95645.6
c_3108_3668_i 3108 3108_3668 9.36084e-12
r_309_869_e 309 869 13376.4
r_309_869_i 309_869 869 93218.1
c_309_869_i 309 309_869 2.08965e-09
r_869_1429_e 869 1429 13376.4
r_869_1429_i 869_1429 1429 93218.1
c_869_1429_i 869 869_1429 2.08965e-09
r_1429_1989_e 1429 1989 836.944
r_1429_1989_i 1429_1989 1989 4256.89
c_1429_1989_i 1429 1429_1989 4.67522e-10
r_1989_2549_e 1989 2549 836.944
r_1989_2549_i 1989_2549 2549 4256.89
c_1989_2549_i 1989 1989_2549 4.67522e-10
r_2549_3109_e 2549 3109 836.944
r_2549_3109_i 2549_3109 3109 4256.89
c_2549_3109_i 2549 2549_3109 4.67522e-10
r_3109_3669_e 3109 3669 13758.3
r_3109_3669_i 3109_3669 3669 95645.6
c_3109_3669_i 3109 3109_3669 9.36084e-12
r_310_870_e 310 870 13376.4
r_310_870_i 310_870 870 93218.1
c_310_870_i 310 310_870 2.08965e-09
r_870_1430_e 870 1430 13376.4
r_870_1430_i 870_1430 1430 93218.1
c_870_1430_i 870 870_1430 2.08965e-09
r_1430_1990_e 1430 1990 836.944
r_1430_1990_i 1430_1990 1990 4256.89
c_1430_1990_i 1430 1430_1990 4.67522e-10
r_1990_2550_e 1990 2550 836.944
r_1990_2550_i 1990_2550 2550 4256.89
c_1990_2550_i 1990 1990_2550 4.67522e-10
r_2550_3110_e 2550 3110 836.944
r_2550_3110_i 2550_3110 3110 4256.89
c_2550_3110_i 2550 2550_3110 4.67522e-10
r_3110_3670_e 3110 3670 13758.3
r_3110_3670_i 3110_3670 3670 95645.6
c_3110_3670_i 3110 3110_3670 9.36084e-12
r_311_871_e 311 871 13376.4
r_311_871_i 311_871 871 93218.1
c_311_871_i 311 311_871 2.08965e-09
r_871_1431_e 871 1431 13376.4
r_871_1431_i 871_1431 1431 93218.1
c_871_1431_i 871 871_1431 2.08965e-09
r_1431_1991_e 1431 1991 836.944
r_1431_1991_i 1431_1991 1991 4256.89
c_1431_1991_i 1431 1431_1991 4.67522e-10
r_1991_2551_e 1991 2551 836.944
r_1991_2551_i 1991_2551 2551 4256.89
c_1991_2551_i 1991 1991_2551 4.67522e-10
r_2551_3111_e 2551 3111 836.944
r_2551_3111_i 2551_3111 3111 4256.89
c_2551_3111_i 2551 2551_3111 4.67522e-10
r_3111_3671_e 3111 3671 13758.3
r_3111_3671_i 3111_3671 3671 95645.6
c_3111_3671_i 3111 3111_3671 9.36084e-12
r_312_872_e 312 872 13376.4
r_312_872_i 312_872 872 93218.1
c_312_872_i 312 312_872 2.08965e-09
r_872_1432_e 872 1432 13376.4
r_872_1432_i 872_1432 1432 93218.1
c_872_1432_i 872 872_1432 2.08965e-09
r_1432_1992_e 1432 1992 836.944
r_1432_1992_i 1432_1992 1992 4256.89
c_1432_1992_i 1432 1432_1992 4.67522e-10
r_1992_2552_e 1992 2552 836.944
r_1992_2552_i 1992_2552 2552 4256.89
c_1992_2552_i 1992 1992_2552 4.67522e-10
r_2552_3112_e 2552 3112 836.944
r_2552_3112_i 2552_3112 3112 4256.89
c_2552_3112_i 2552 2552_3112 4.67522e-10
r_3112_3672_e 3112 3672 13758.3
r_3112_3672_i 3112_3672 3672 95645.6
c_3112_3672_i 3112 3112_3672 9.36084e-12
r_313_873_e 313 873 13376.4
r_313_873_i 313_873 873 93218.1
c_313_873_i 313 313_873 2.08965e-09
r_873_1433_e 873 1433 13376.4
r_873_1433_i 873_1433 1433 93218.1
c_873_1433_i 873 873_1433 2.08965e-09
r_1433_1993_e 1433 1993 836.944
r_1433_1993_i 1433_1993 1993 4256.89
c_1433_1993_i 1433 1433_1993 4.67522e-10
r_1993_2553_e 1993 2553 836.944
r_1993_2553_i 1993_2553 2553 4256.89
c_1993_2553_i 1993 1993_2553 4.67522e-10
r_2553_3113_e 2553 3113 836.944
r_2553_3113_i 2553_3113 3113 4256.89
c_2553_3113_i 2553 2553_3113 4.67522e-10
r_3113_3673_e 3113 3673 13758.3
r_3113_3673_i 3113_3673 3673 95645.6
c_3113_3673_i 3113 3113_3673 9.36084e-12
r_314_874_e 314 874 13376.4
r_314_874_i 314_874 874 93218.1
c_314_874_i 314 314_874 2.08965e-09
r_874_1434_e 874 1434 13376.4
r_874_1434_i 874_1434 1434 93218.1
c_874_1434_i 874 874_1434 2.08965e-09
r_1434_1994_e 1434 1994 836.944
r_1434_1994_i 1434_1994 1994 4256.89
c_1434_1994_i 1434 1434_1994 4.67522e-10
r_1994_2554_e 1994 2554 836.944
r_1994_2554_i 1994_2554 2554 4256.89
c_1994_2554_i 1994 1994_2554 4.67522e-10
r_2554_3114_e 2554 3114 836.944
r_2554_3114_i 2554_3114 3114 4256.89
c_2554_3114_i 2554 2554_3114 4.67522e-10
r_3114_3674_e 3114 3674 13758.3
r_3114_3674_i 3114_3674 3674 95645.6
c_3114_3674_i 3114 3114_3674 9.36084e-12
r_315_875_e 315 875 13376.4
r_315_875_i 315_875 875 93218.1
c_315_875_i 315 315_875 2.08965e-09
r_875_1435_e 875 1435 396.61
r_875_1435_i 875_1435 1435 1005.05
c_875_1435_i 875 875_1435 1.65831e-10
r_1435_1995_e 1435 1995 836.944
r_1435_1995_i 1435_1995 1995 4256.89
c_1435_1995_i 1435 1435_1995 4.67522e-10
r_1995_2555_e 1995 2555 836.944
r_1995_2555_i 1995_2555 2555 4256.89
c_1995_2555_i 1995 1995_2555 4.67522e-10
r_2555_3115_e 2555 3115 836.944
r_2555_3115_i 2555_3115 3115 4256.89
c_2555_3115_i 2555 2555_3115 4.67522e-10
r_3115_3675_e 3115 3675 13758.3
r_3115_3675_i 3115_3675 3675 95645.6
c_3115_3675_i 3115 3115_3675 9.36084e-12
r_316_876_e 316 876 13376.4
r_316_876_i 316_876 876 93218.1
c_316_876_i 316 316_876 2.08965e-09
r_876_1436_e 876 1436 396.61
r_876_1436_i 876_1436 1436 1005.05
c_876_1436_i 876 876_1436 1.65831e-10
r_1436_1996_e 1436 1996 836.944
r_1436_1996_i 1436_1996 1996 4256.89
c_1436_1996_i 1436 1436_1996 4.67522e-10
r_1996_2556_e 1996 2556 836.944
r_1996_2556_i 1996_2556 2556 4256.89
c_1996_2556_i 1996 1996_2556 4.67522e-10
r_2556_3116_e 2556 3116 836.944
r_2556_3116_i 2556_3116 3116 4256.89
c_2556_3116_i 2556 2556_3116 4.67522e-10
r_3116_3676_e 3116 3676 13758.3
r_3116_3676_i 3116_3676 3676 95645.6
c_3116_3676_i 3116 3116_3676 9.36084e-12
r_317_877_e 317 877 13376.4
r_317_877_i 317_877 877 93218.1
c_317_877_i 317 317_877 2.08965e-09
r_877_1437_e 877 1437 13376.4
r_877_1437_i 877_1437 1437 93218.1
c_877_1437_i 877 877_1437 2.08965e-09
r_1437_1997_e 1437 1997 836.944
r_1437_1997_i 1437_1997 1997 4256.89
c_1437_1997_i 1437 1437_1997 4.67522e-10
r_1997_2557_e 1997 2557 836.944
r_1997_2557_i 1997_2557 2557 4256.89
c_1997_2557_i 1997 1997_2557 4.67522e-10
r_2557_3117_e 2557 3117 836.944
r_2557_3117_i 2557_3117 3117 4256.89
c_2557_3117_i 2557 2557_3117 4.67522e-10
r_3117_3677_e 3117 3677 13758.3
r_3117_3677_i 3117_3677 3677 95645.6
c_3117_3677_i 3117 3117_3677 9.36084e-12
r_318_878_e 318 878 13376.4
r_318_878_i 318_878 878 93218.1
c_318_878_i 318 318_878 2.08965e-09
r_878_1438_e 878 1438 13376.4
r_878_1438_i 878_1438 1438 93218.1
c_878_1438_i 878 878_1438 2.08965e-09
r_1438_1998_e 1438 1998 836.944
r_1438_1998_i 1438_1998 1998 4256.89
c_1438_1998_i 1438 1438_1998 4.67522e-10
r_1998_2558_e 1998 2558 836.944
r_1998_2558_i 1998_2558 2558 4256.89
c_1998_2558_i 1998 1998_2558 4.67522e-10
r_2558_3118_e 2558 3118 836.944
r_2558_3118_i 2558_3118 3118 4256.89
c_2558_3118_i 2558 2558_3118 4.67522e-10
r_3118_3678_e 3118 3678 13758.3
r_3118_3678_i 3118_3678 3678 95645.6
c_3118_3678_i 3118 3118_3678 9.36084e-12
r_319_879_e 319 879 13376.4
r_319_879_i 319_879 879 93218.1
c_319_879_i 319 319_879 2.08965e-09
r_879_1439_e 879 1439 13376.4
r_879_1439_i 879_1439 1439 93218.1
c_879_1439_i 879 879_1439 2.08965e-09
r_1439_1999_e 1439 1999 836.944
r_1439_1999_i 1439_1999 1999 4256.89
c_1439_1999_i 1439 1439_1999 4.67522e-10
r_1999_2559_e 1999 2559 836.944
r_1999_2559_i 1999_2559 2559 4256.89
c_1999_2559_i 1999 1999_2559 4.67522e-10
r_2559_3119_e 2559 3119 836.944
r_2559_3119_i 2559_3119 3119 4256.89
c_2559_3119_i 2559 2559_3119 4.67522e-10
r_3119_3679_e 3119 3679 13758.3
r_3119_3679_i 3119_3679 3679 95645.6
c_3119_3679_i 3119 3119_3679 9.36084e-12
r_320_880_e 320 880 13376.4
r_320_880_i 320_880 880 93218.1
c_320_880_i 320 320_880 2.08965e-09
r_880_1440_e 880 1440 13376.4
r_880_1440_i 880_1440 1440 93218.1
c_880_1440_i 880 880_1440 2.08965e-09
r_1440_2000_e 1440 2000 836.944
r_1440_2000_i 1440_2000 2000 4256.89
c_1440_2000_i 1440 1440_2000 4.67522e-10
r_2000_2560_e 2000 2560 836.944
r_2000_2560_i 2000_2560 2560 4256.89
c_2000_2560_i 2000 2000_2560 4.67522e-10
r_2560_3120_e 2560 3120 836.944
r_2560_3120_i 2560_3120 3120 4256.89
c_2560_3120_i 2560 2560_3120 4.67522e-10
r_3120_3680_e 3120 3680 13758.3
r_3120_3680_i 3120_3680 3680 95645.6
c_3120_3680_i 3120 3120_3680 9.36084e-12
r_321_881_e 321 881 13376.4
r_321_881_i 321_881 881 93218.1
c_321_881_i 321 321_881 2.08965e-09
r_881_1441_e 881 1441 13376.4
r_881_1441_i 881_1441 1441 93218.1
c_881_1441_i 881 881_1441 2.08965e-09
r_1441_2001_e 1441 2001 13376.4
r_1441_2001_i 1441_2001 2001 93218.1
c_1441_2001_i 1441 1441_2001 2.08965e-09
r_2001_2561_e 2001 2561 13376.4
r_2001_2561_i 2001_2561 2561 93218.1
c_2001_2561_i 2001 2001_2561 2.08965e-09
r_2561_3121_e 2561 3121 13376.4
r_2561_3121_i 2561_3121 3121 93218.1
c_2561_3121_i 2561 2561_3121 2.08965e-09
r_3121_3681_e 3121 3681 13376.4
r_3121_3681_i 3121_3681 3681 93218.1
c_3121_3681_i 3121 3121_3681 2.08965e-09
r_322_882_e 322 882 13376.4
r_322_882_i 322_882 882 93218.1
c_322_882_i 322 322_882 2.08965e-09
r_882_1442_e 882 1442 13376.4
r_882_1442_i 882_1442 1442 93218.1
c_882_1442_i 882 882_1442 2.08965e-09
r_1442_2002_e 1442 2002 13376.4
r_1442_2002_i 1442_2002 2002 93218.1
c_1442_2002_i 1442 1442_2002 2.08965e-09
r_2002_2562_e 2002 2562 13376.4
r_2002_2562_i 2002_2562 2562 93218.1
c_2002_2562_i 2002 2002_2562 2.08965e-09
r_2562_3122_e 2562 3122 13376.4
r_2562_3122_i 2562_3122 3122 93218.1
c_2562_3122_i 2562 2562_3122 2.08965e-09
r_3122_3682_e 3122 3682 13376.4
r_3122_3682_i 3122_3682 3682 93218.1
c_3122_3682_i 3122 3122_3682 2.08965e-09
r_323_883_e 323 883 13376.4
r_323_883_i 323_883 883 93218.1
c_323_883_i 323 323_883 2.08965e-09
r_883_1443_e 883 1443 13376.4
r_883_1443_i 883_1443 1443 93218.1
c_883_1443_i 883 883_1443 2.08965e-09
r_1443_2003_e 1443 2003 836.944
r_1443_2003_i 1443_2003 2003 4256.89
c_1443_2003_i 1443 1443_2003 4.67522e-10
r_2003_2563_e 2003 2563 836.944
r_2003_2563_i 2003_2563 2563 4256.89
c_2003_2563_i 2003 2003_2563 4.67522e-10
r_2563_3123_e 2563 3123 836.944
r_2563_3123_i 2563_3123 3123 4256.89
c_2563_3123_i 2563 2563_3123 4.67522e-10
r_3123_3683_e 3123 3683 836.944
r_3123_3683_i 3123_3683 3683 4256.89
c_3123_3683_i 3123 3123_3683 4.67522e-10
r_324_884_e 324 884 13376.4
r_324_884_i 324_884 884 93218.1
c_324_884_i 324 324_884 2.08965e-09
r_884_1444_e 884 1444 13376.4
r_884_1444_i 884_1444 1444 93218.1
c_884_1444_i 884 884_1444 2.08965e-09
r_1444_2004_e 1444 2004 836.944
r_1444_2004_i 1444_2004 2004 4256.89
c_1444_2004_i 1444 1444_2004 4.67522e-10
r_2004_2564_e 2004 2564 836.944
r_2004_2564_i 2004_2564 2564 4256.89
c_2004_2564_i 2004 2004_2564 4.67522e-10
r_2564_3124_e 2564 3124 836.944
r_2564_3124_i 2564_3124 3124 4256.89
c_2564_3124_i 2564 2564_3124 4.67522e-10
r_3124_3684_e 3124 3684 13758.3
r_3124_3684_i 3124_3684 3684 95645.6
c_3124_3684_i 3124 3124_3684 9.36084e-12
r_325_885_e 325 885 13376.4
r_325_885_i 325_885 885 93218.1
c_325_885_i 325 325_885 2.08965e-09
r_885_1445_e 885 1445 13376.4
r_885_1445_i 885_1445 1445 93218.1
c_885_1445_i 885 885_1445 2.08965e-09
r_1445_2005_e 1445 2005 836.944
r_1445_2005_i 1445_2005 2005 4256.89
c_1445_2005_i 1445 1445_2005 4.67522e-10
r_2005_2565_e 2005 2565 836.944
r_2005_2565_i 2005_2565 2565 4256.89
c_2005_2565_i 2005 2005_2565 4.67522e-10
r_2565_3125_e 2565 3125 836.944
r_2565_3125_i 2565_3125 3125 4256.89
c_2565_3125_i 2565 2565_3125 4.67522e-10
r_3125_3685_e 3125 3685 13758.3
r_3125_3685_i 3125_3685 3685 95645.6
c_3125_3685_i 3125 3125_3685 9.36084e-12
r_326_886_e 326 886 13376.4
r_326_886_i 326_886 886 93218.1
c_326_886_i 326 326_886 2.08965e-09
r_886_1446_e 886 1446 13376.4
r_886_1446_i 886_1446 1446 93218.1
c_886_1446_i 886 886_1446 2.08965e-09
r_1446_2006_e 1446 2006 836.944
r_1446_2006_i 1446_2006 2006 4256.89
c_1446_2006_i 1446 1446_2006 4.67522e-10
r_2006_2566_e 2006 2566 836.944
r_2006_2566_i 2006_2566 2566 4256.89
c_2006_2566_i 2006 2006_2566 4.67522e-10
r_2566_3126_e 2566 3126 836.944
r_2566_3126_i 2566_3126 3126 4256.89
c_2566_3126_i 2566 2566_3126 4.67522e-10
r_3126_3686_e 3126 3686 13758.3
r_3126_3686_i 3126_3686 3686 95645.6
c_3126_3686_i 3126 3126_3686 9.36084e-12
r_327_887_e 327 887 13376.4
r_327_887_i 327_887 887 93218.1
c_327_887_i 327 327_887 2.08965e-09
r_887_1447_e 887 1447 13376.4
r_887_1447_i 887_1447 1447 93218.1
c_887_1447_i 887 887_1447 2.08965e-09
r_1447_2007_e 1447 2007 836.944
r_1447_2007_i 1447_2007 2007 4256.89
c_1447_2007_i 1447 1447_2007 4.67522e-10
r_2007_2567_e 2007 2567 836.944
r_2007_2567_i 2007_2567 2567 4256.89
c_2007_2567_i 2007 2007_2567 4.67522e-10
r_2567_3127_e 2567 3127 836.944
r_2567_3127_i 2567_3127 3127 4256.89
c_2567_3127_i 2567 2567_3127 4.67522e-10
r_3127_3687_e 3127 3687 13758.3
r_3127_3687_i 3127_3687 3687 95645.6
c_3127_3687_i 3127 3127_3687 9.36084e-12
r_328_888_e 328 888 13376.4
r_328_888_i 328_888 888 93218.1
c_328_888_i 328 328_888 2.08965e-09
r_888_1448_e 888 1448 13376.4
r_888_1448_i 888_1448 1448 93218.1
c_888_1448_i 888 888_1448 2.08965e-09
r_1448_2008_e 1448 2008 836.944
r_1448_2008_i 1448_2008 2008 4256.89
c_1448_2008_i 1448 1448_2008 4.67522e-10
r_2008_2568_e 2008 2568 836.944
r_2008_2568_i 2008_2568 2568 4256.89
c_2008_2568_i 2008 2008_2568 4.67522e-10
r_2568_3128_e 2568 3128 836.944
r_2568_3128_i 2568_3128 3128 4256.89
c_2568_3128_i 2568 2568_3128 4.67522e-10
r_3128_3688_e 3128 3688 13758.3
r_3128_3688_i 3128_3688 3688 95645.6
c_3128_3688_i 3128 3128_3688 9.36084e-12
r_329_889_e 329 889 13376.4
r_329_889_i 329_889 889 93218.1
c_329_889_i 329 329_889 2.08965e-09
r_889_1449_e 889 1449 13376.4
r_889_1449_i 889_1449 1449 93218.1
c_889_1449_i 889 889_1449 2.08965e-09
r_1449_2009_e 1449 2009 836.944
r_1449_2009_i 1449_2009 2009 4256.89
c_1449_2009_i 1449 1449_2009 4.67522e-10
r_2009_2569_e 2009 2569 836.944
r_2009_2569_i 2009_2569 2569 4256.89
c_2009_2569_i 2009 2009_2569 4.67522e-10
r_2569_3129_e 2569 3129 836.944
r_2569_3129_i 2569_3129 3129 4256.89
c_2569_3129_i 2569 2569_3129 4.67522e-10
r_3129_3689_e 3129 3689 13758.3
r_3129_3689_i 3129_3689 3689 95645.6
c_3129_3689_i 3129 3129_3689 9.36084e-12
r_330_890_e 330 890 13376.4
r_330_890_i 330_890 890 93218.1
c_330_890_i 330 330_890 2.08965e-09
r_890_1450_e 890 1450 13376.4
r_890_1450_i 890_1450 1450 93218.1
c_890_1450_i 890 890_1450 2.08965e-09
r_1450_2010_e 1450 2010 836.944
r_1450_2010_i 1450_2010 2010 4256.89
c_1450_2010_i 1450 1450_2010 4.67522e-10
r_2010_2570_e 2010 2570 836.944
r_2010_2570_i 2010_2570 2570 4256.89
c_2010_2570_i 2010 2010_2570 4.67522e-10
r_2570_3130_e 2570 3130 836.944
r_2570_3130_i 2570_3130 3130 4256.89
c_2570_3130_i 2570 2570_3130 4.67522e-10
r_3130_3690_e 3130 3690 13758.3
r_3130_3690_i 3130_3690 3690 95645.6
c_3130_3690_i 3130 3130_3690 9.36084e-12
r_331_891_e 331 891 13376.4
r_331_891_i 331_891 891 93218.1
c_331_891_i 331 331_891 2.08965e-09
r_891_1451_e 891 1451 396.602
r_891_1451_i 891_1451 1451 1005.03
c_891_1451_i 891 891_1451 1.65835e-10
r_1451_2011_e 1451 2011 836.944
r_1451_2011_i 1451_2011 2011 4256.89
c_1451_2011_i 1451 1451_2011 4.67522e-10
r_2011_2571_e 2011 2571 836.944
r_2011_2571_i 2011_2571 2571 4256.89
c_2011_2571_i 2011 2011_2571 4.67522e-10
r_2571_3131_e 2571 3131 836.944
r_2571_3131_i 2571_3131 3131 4256.89
c_2571_3131_i 2571 2571_3131 4.67522e-10
r_3131_3691_e 3131 3691 13758.3
r_3131_3691_i 3131_3691 3691 95645.6
c_3131_3691_i 3131 3131_3691 9.36084e-12
r_332_892_e 332 892 13376.4
r_332_892_i 332_892 892 93218.1
c_332_892_i 332 332_892 2.08965e-09
r_892_1452_e 892 1452 396.602
r_892_1452_i 892_1452 1452 1005.03
c_892_1452_i 892 892_1452 1.65835e-10
r_1452_2012_e 1452 2012 836.944
r_1452_2012_i 1452_2012 2012 4256.89
c_1452_2012_i 1452 1452_2012 4.67522e-10
r_2012_2572_e 2012 2572 836.944
r_2012_2572_i 2012_2572 2572 4256.89
c_2012_2572_i 2012 2012_2572 4.67522e-10
r_2572_3132_e 2572 3132 836.944
r_2572_3132_i 2572_3132 3132 4256.89
c_2572_3132_i 2572 2572_3132 4.67522e-10
r_3132_3692_e 3132 3692 13758.3
r_3132_3692_i 3132_3692 3692 95645.6
c_3132_3692_i 3132 3132_3692 9.36084e-12
r_333_893_e 333 893 13376.4
r_333_893_i 333_893 893 93218.1
c_333_893_i 333 333_893 2.08965e-09
r_893_1453_e 893 1453 13376.4
r_893_1453_i 893_1453 1453 93218.1
c_893_1453_i 893 893_1453 2.08965e-09
r_1453_2013_e 1453 2013 836.944
r_1453_2013_i 1453_2013 2013 4256.89
c_1453_2013_i 1453 1453_2013 4.67522e-10
r_2013_2573_e 2013 2573 836.944
r_2013_2573_i 2013_2573 2573 4256.89
c_2013_2573_i 2013 2013_2573 4.67522e-10
r_2573_3133_e 2573 3133 836.944
r_2573_3133_i 2573_3133 3133 4256.89
c_2573_3133_i 2573 2573_3133 4.67522e-10
r_3133_3693_e 3133 3693 13758.3
r_3133_3693_i 3133_3693 3693 95645.6
c_3133_3693_i 3133 3133_3693 9.36084e-12
r_334_894_e 334 894 13376.4
r_334_894_i 334_894 894 93218.1
c_334_894_i 334 334_894 2.08965e-09
r_894_1454_e 894 1454 13376.4
r_894_1454_i 894_1454 1454 93218.1
c_894_1454_i 894 894_1454 2.08965e-09
r_1454_2014_e 1454 2014 836.944
r_1454_2014_i 1454_2014 2014 4256.89
c_1454_2014_i 1454 1454_2014 4.67522e-10
r_2014_2574_e 2014 2574 836.944
r_2014_2574_i 2014_2574 2574 4256.89
c_2014_2574_i 2014 2014_2574 4.67522e-10
r_2574_3134_e 2574 3134 836.944
r_2574_3134_i 2574_3134 3134 4256.89
c_2574_3134_i 2574 2574_3134 4.67522e-10
r_3134_3694_e 3134 3694 13758.3
r_3134_3694_i 3134_3694 3694 95645.6
c_3134_3694_i 3134 3134_3694 9.36084e-12
r_335_895_e 335 895 13376.4
r_335_895_i 335_895 895 93218.1
c_335_895_i 335 335_895 2.08965e-09
r_895_1455_e 895 1455 13376.4
r_895_1455_i 895_1455 1455 93218.1
c_895_1455_i 895 895_1455 2.08965e-09
r_1455_2015_e 1455 2015 836.944
r_1455_2015_i 1455_2015 2015 4256.89
c_1455_2015_i 1455 1455_2015 4.67522e-10
r_2015_2575_e 2015 2575 836.944
r_2015_2575_i 2015_2575 2575 4256.89
c_2015_2575_i 2015 2015_2575 4.67522e-10
r_2575_3135_e 2575 3135 836.944
r_2575_3135_i 2575_3135 3135 4256.89
c_2575_3135_i 2575 2575_3135 4.67522e-10
r_3135_3695_e 3135 3695 13758.3
r_3135_3695_i 3135_3695 3695 95645.6
c_3135_3695_i 3135 3135_3695 9.36084e-12
r_336_896_e 336 896 13376.4
r_336_896_i 336_896 896 93218.1
c_336_896_i 336 336_896 2.08965e-09
r_896_1456_e 896 1456 13376.4
r_896_1456_i 896_1456 1456 93218.1
c_896_1456_i 896 896_1456 2.08965e-09
r_1456_2016_e 1456 2016 836.944
r_1456_2016_i 1456_2016 2016 4256.89
c_1456_2016_i 1456 1456_2016 4.67522e-10
r_2016_2576_e 2016 2576 836.944
r_2016_2576_i 2016_2576 2576 4256.89
c_2016_2576_i 2016 2016_2576 4.67522e-10
r_2576_3136_e 2576 3136 836.944
r_2576_3136_i 2576_3136 3136 4256.89
c_2576_3136_i 2576 2576_3136 4.67522e-10
r_3136_3696_e 3136 3696 13758.3
r_3136_3696_i 3136_3696 3696 95645.6
c_3136_3696_i 3136 3136_3696 9.36084e-12
r_337_897_e 337 897 13376.4
r_337_897_i 337_897 897 93218.1
c_337_897_i 337 337_897 2.08965e-09
r_897_1457_e 897 1457 13376.4
r_897_1457_i 897_1457 1457 93218.1
c_897_1457_i 897 897_1457 2.08965e-09
r_1457_2017_e 1457 2017 13376.4
r_1457_2017_i 1457_2017 2017 93218.1
c_1457_2017_i 1457 1457_2017 2.08965e-09
r_2017_2577_e 2017 2577 13376.4
r_2017_2577_i 2017_2577 2577 93218.1
c_2017_2577_i 2017 2017_2577 2.08965e-09
r_2577_3137_e 2577 3137 13376.4
r_2577_3137_i 2577_3137 3137 93218.1
c_2577_3137_i 2577 2577_3137 2.08965e-09
r_3137_3697_e 3137 3697 13376.4
r_3137_3697_i 3137_3697 3697 93218.1
c_3137_3697_i 3137 3137_3697 2.08965e-09
r_338_898_e 338 898 13376.4
r_338_898_i 338_898 898 93218.1
c_338_898_i 338 338_898 2.08965e-09
r_898_1458_e 898 1458 13376.4
r_898_1458_i 898_1458 1458 93218.1
c_898_1458_i 898 898_1458 2.08965e-09
r_1458_2018_e 1458 2018 13376.4
r_1458_2018_i 1458_2018 2018 93218.1
c_1458_2018_i 1458 1458_2018 2.08965e-09
r_2018_2578_e 2018 2578 13376.4
r_2018_2578_i 2018_2578 2578 93218.1
c_2018_2578_i 2018 2018_2578 2.08965e-09
r_2578_3138_e 2578 3138 13376.4
r_2578_3138_i 2578_3138 3138 93218.1
c_2578_3138_i 2578 2578_3138 2.08965e-09
r_3138_3698_e 3138 3698 13376.4
r_3138_3698_i 3138_3698 3698 93218.1
c_3138_3698_i 3138 3138_3698 2.08965e-09
r_339_899_e 339 899 13376.4
r_339_899_i 339_899 899 93218.1
c_339_899_i 339 339_899 2.08965e-09
r_899_1459_e 899 1459 13376.4
r_899_1459_i 899_1459 1459 93218.1
c_899_1459_i 899 899_1459 2.08965e-09
r_1459_2019_e 1459 2019 836.944
r_1459_2019_i 1459_2019 2019 4256.89
c_1459_2019_i 1459 1459_2019 4.67522e-10
r_2019_2579_e 2019 2579 836.944
r_2019_2579_i 2019_2579 2579 4256.89
c_2019_2579_i 2019 2019_2579 4.67522e-10
r_2579_3139_e 2579 3139 836.944
r_2579_3139_i 2579_3139 3139 4256.89
c_2579_3139_i 2579 2579_3139 4.67522e-10
r_3139_3699_e 3139 3699 836.944
r_3139_3699_i 3139_3699 3699 4256.89
c_3139_3699_i 3139 3139_3699 4.67522e-10
r_340_900_e 340 900 13376.4
r_340_900_i 340_900 900 93218.1
c_340_900_i 340 340_900 2.08965e-09
r_900_1460_e 900 1460 13376.4
r_900_1460_i 900_1460 1460 93218.1
c_900_1460_i 900 900_1460 2.08965e-09
r_1460_2020_e 1460 2020 836.944
r_1460_2020_i 1460_2020 2020 4256.89
c_1460_2020_i 1460 1460_2020 4.67522e-10
r_2020_2580_e 2020 2580 836.944
r_2020_2580_i 2020_2580 2580 4256.89
c_2020_2580_i 2020 2020_2580 4.67522e-10
r_2580_3140_e 2580 3140 836.944
r_2580_3140_i 2580_3140 3140 4256.89
c_2580_3140_i 2580 2580_3140 4.67522e-10
r_3140_3700_e 3140 3700 13758.3
r_3140_3700_i 3140_3700 3700 95645.6
c_3140_3700_i 3140 3140_3700 9.36084e-12
r_341_901_e 341 901 13376.4
r_341_901_i 341_901 901 93218.1
c_341_901_i 341 341_901 2.08965e-09
r_901_1461_e 901 1461 13376.4
r_901_1461_i 901_1461 1461 93218.1
c_901_1461_i 901 901_1461 2.08965e-09
r_1461_2021_e 1461 2021 836.944
r_1461_2021_i 1461_2021 2021 4256.89
c_1461_2021_i 1461 1461_2021 4.67522e-10
r_2021_2581_e 2021 2581 836.944
r_2021_2581_i 2021_2581 2581 4256.89
c_2021_2581_i 2021 2021_2581 4.67522e-10
r_2581_3141_e 2581 3141 836.944
r_2581_3141_i 2581_3141 3141 4256.89
c_2581_3141_i 2581 2581_3141 4.67522e-10
r_3141_3701_e 3141 3701 13758.3
r_3141_3701_i 3141_3701 3701 95645.6
c_3141_3701_i 3141 3141_3701 9.36084e-12
r_342_902_e 342 902 13376.4
r_342_902_i 342_902 902 93218.1
c_342_902_i 342 342_902 2.08965e-09
r_902_1462_e 902 1462 13376.4
r_902_1462_i 902_1462 1462 93218.1
c_902_1462_i 902 902_1462 2.08965e-09
r_1462_2022_e 1462 2022 836.944
r_1462_2022_i 1462_2022 2022 4256.89
c_1462_2022_i 1462 1462_2022 4.67522e-10
r_2022_2582_e 2022 2582 836.944
r_2022_2582_i 2022_2582 2582 4256.89
c_2022_2582_i 2022 2022_2582 4.67522e-10
r_2582_3142_e 2582 3142 836.944
r_2582_3142_i 2582_3142 3142 4256.89
c_2582_3142_i 2582 2582_3142 4.67522e-10
r_3142_3702_e 3142 3702 13758.3
r_3142_3702_i 3142_3702 3702 95645.6
c_3142_3702_i 3142 3142_3702 9.36084e-12
r_343_903_e 343 903 13376.4
r_343_903_i 343_903 903 93218.1
c_343_903_i 343 343_903 2.08965e-09
r_903_1463_e 903 1463 13376.4
r_903_1463_i 903_1463 1463 93218.1
c_903_1463_i 903 903_1463 2.08965e-09
r_1463_2023_e 1463 2023 836.944
r_1463_2023_i 1463_2023 2023 4256.89
c_1463_2023_i 1463 1463_2023 4.67522e-10
r_2023_2583_e 2023 2583 836.944
r_2023_2583_i 2023_2583 2583 4256.89
c_2023_2583_i 2023 2023_2583 4.67522e-10
r_2583_3143_e 2583 3143 836.944
r_2583_3143_i 2583_3143 3143 4256.89
c_2583_3143_i 2583 2583_3143 4.67522e-10
r_3143_3703_e 3143 3703 13758.3
r_3143_3703_i 3143_3703 3703 95645.6
c_3143_3703_i 3143 3143_3703 9.36084e-12
r_344_904_e 344 904 13376.4
r_344_904_i 344_904 904 93218.1
c_344_904_i 344 344_904 2.08965e-09
r_904_1464_e 904 1464 13376.4
r_904_1464_i 904_1464 1464 93218.1
c_904_1464_i 904 904_1464 2.08965e-09
r_1464_2024_e 1464 2024 836.944
r_1464_2024_i 1464_2024 2024 4256.89
c_1464_2024_i 1464 1464_2024 4.67522e-10
r_2024_2584_e 2024 2584 836.944
r_2024_2584_i 2024_2584 2584 4256.89
c_2024_2584_i 2024 2024_2584 4.67522e-10
r_2584_3144_e 2584 3144 836.944
r_2584_3144_i 2584_3144 3144 4256.89
c_2584_3144_i 2584 2584_3144 4.67522e-10
r_3144_3704_e 3144 3704 13758.3
r_3144_3704_i 3144_3704 3704 95645.6
c_3144_3704_i 3144 3144_3704 9.36084e-12
r_345_905_e 345 905 13376.4
r_345_905_i 345_905 905 93218.1
c_345_905_i 345 345_905 2.08965e-09
r_905_1465_e 905 1465 13376.4
r_905_1465_i 905_1465 1465 93218.1
c_905_1465_i 905 905_1465 2.08965e-09
r_1465_2025_e 1465 2025 836.944
r_1465_2025_i 1465_2025 2025 4256.89
c_1465_2025_i 1465 1465_2025 4.67522e-10
r_2025_2585_e 2025 2585 836.944
r_2025_2585_i 2025_2585 2585 4256.89
c_2025_2585_i 2025 2025_2585 4.67522e-10
r_2585_3145_e 2585 3145 836.944
r_2585_3145_i 2585_3145 3145 4256.89
c_2585_3145_i 2585 2585_3145 4.67522e-10
r_3145_3705_e 3145 3705 13758.3
r_3145_3705_i 3145_3705 3705 95645.6
c_3145_3705_i 3145 3145_3705 9.36084e-12
r_346_906_e 346 906 13376.4
r_346_906_i 346_906 906 93218.1
c_346_906_i 346 346_906 2.08965e-09
r_906_1466_e 906 1466 13376.4
r_906_1466_i 906_1466 1466 93218.1
c_906_1466_i 906 906_1466 2.08965e-09
r_1466_2026_e 1466 2026 836.944
r_1466_2026_i 1466_2026 2026 4256.89
c_1466_2026_i 1466 1466_2026 4.67522e-10
r_2026_2586_e 2026 2586 836.944
r_2026_2586_i 2026_2586 2586 4256.89
c_2026_2586_i 2026 2026_2586 4.67522e-10
r_2586_3146_e 2586 3146 836.944
r_2586_3146_i 2586_3146 3146 4256.89
c_2586_3146_i 2586 2586_3146 4.67522e-10
r_3146_3706_e 3146 3706 13758.3
r_3146_3706_i 3146_3706 3706 95645.6
c_3146_3706_i 3146 3146_3706 9.36084e-12
r_347_907_e 347 907 13376.4
r_347_907_i 347_907 907 93218.1
c_347_907_i 347 347_907 2.08965e-09
r_907_1467_e 907 1467 396.593
r_907_1467_i 907_1467 1467 1005.01
c_907_1467_i 907 907_1467 1.65838e-10
r_1467_2027_e 1467 2027 836.944
r_1467_2027_i 1467_2027 2027 4256.89
c_1467_2027_i 1467 1467_2027 4.67522e-10
r_2027_2587_e 2027 2587 836.944
r_2027_2587_i 2027_2587 2587 4256.89
c_2027_2587_i 2027 2027_2587 4.67522e-10
r_2587_3147_e 2587 3147 836.944
r_2587_3147_i 2587_3147 3147 4256.89
c_2587_3147_i 2587 2587_3147 4.67522e-10
r_3147_3707_e 3147 3707 13758.3
r_3147_3707_i 3147_3707 3707 95645.6
c_3147_3707_i 3147 3147_3707 9.36084e-12
r_348_908_e 348 908 13376.4
r_348_908_i 348_908 908 93218.1
c_348_908_i 348 348_908 2.08965e-09
r_908_1468_e 908 1468 396.593
r_908_1468_i 908_1468 1468 1005.01
c_908_1468_i 908 908_1468 1.65838e-10
r_1468_2028_e 1468 2028 836.944
r_1468_2028_i 1468_2028 2028 4256.89
c_1468_2028_i 1468 1468_2028 4.67522e-10
r_2028_2588_e 2028 2588 836.944
r_2028_2588_i 2028_2588 2588 4256.89
c_2028_2588_i 2028 2028_2588 4.67522e-10
r_2588_3148_e 2588 3148 836.944
r_2588_3148_i 2588_3148 3148 4256.89
c_2588_3148_i 2588 2588_3148 4.67522e-10
r_3148_3708_e 3148 3708 13758.3
r_3148_3708_i 3148_3708 3708 95645.6
c_3148_3708_i 3148 3148_3708 9.36084e-12
r_349_909_e 349 909 13376.4
r_349_909_i 349_909 909 93218.1
c_349_909_i 349 349_909 2.08965e-09
r_909_1469_e 909 1469 13376.4
r_909_1469_i 909_1469 1469 93218.1
c_909_1469_i 909 909_1469 2.08965e-09
r_1469_2029_e 1469 2029 836.944
r_1469_2029_i 1469_2029 2029 4256.89
c_1469_2029_i 1469 1469_2029 4.67522e-10
r_2029_2589_e 2029 2589 836.944
r_2029_2589_i 2029_2589 2589 4256.89
c_2029_2589_i 2029 2029_2589 4.67522e-10
r_2589_3149_e 2589 3149 836.944
r_2589_3149_i 2589_3149 3149 4256.89
c_2589_3149_i 2589 2589_3149 4.67522e-10
r_3149_3709_e 3149 3709 13758.3
r_3149_3709_i 3149_3709 3709 95645.6
c_3149_3709_i 3149 3149_3709 9.36084e-12
r_350_910_e 350 910 13376.4
r_350_910_i 350_910 910 93218.1
c_350_910_i 350 350_910 2.08965e-09
r_910_1470_e 910 1470 13376.4
r_910_1470_i 910_1470 1470 93218.1
c_910_1470_i 910 910_1470 2.08965e-09
r_1470_2030_e 1470 2030 836.944
r_1470_2030_i 1470_2030 2030 4256.89
c_1470_2030_i 1470 1470_2030 4.67522e-10
r_2030_2590_e 2030 2590 836.944
r_2030_2590_i 2030_2590 2590 4256.89
c_2030_2590_i 2030 2030_2590 4.67522e-10
r_2590_3150_e 2590 3150 836.944
r_2590_3150_i 2590_3150 3150 4256.89
c_2590_3150_i 2590 2590_3150 4.67522e-10
r_3150_3710_e 3150 3710 13758.3
r_3150_3710_i 3150_3710 3710 95645.6
c_3150_3710_i 3150 3150_3710 9.36084e-12
r_351_911_e 351 911 13376.4
r_351_911_i 351_911 911 93218.1
c_351_911_i 351 351_911 2.08965e-09
r_911_1471_e 911 1471 13376.4
r_911_1471_i 911_1471 1471 93218.1
c_911_1471_i 911 911_1471 2.08965e-09
r_1471_2031_e 1471 2031 836.944
r_1471_2031_i 1471_2031 2031 4256.89
c_1471_2031_i 1471 1471_2031 4.67522e-10
r_2031_2591_e 2031 2591 836.944
r_2031_2591_i 2031_2591 2591 4256.89
c_2031_2591_i 2031 2031_2591 4.67522e-10
r_2591_3151_e 2591 3151 836.944
r_2591_3151_i 2591_3151 3151 4256.89
c_2591_3151_i 2591 2591_3151 4.67522e-10
r_3151_3711_e 3151 3711 13758.3
r_3151_3711_i 3151_3711 3711 95645.6
c_3151_3711_i 3151 3151_3711 9.36084e-12
r_352_912_e 352 912 13376.4
r_352_912_i 352_912 912 93218.1
c_352_912_i 352 352_912 2.08965e-09
r_912_1472_e 912 1472 13376.4
r_912_1472_i 912_1472 1472 93218.1
c_912_1472_i 912 912_1472 2.08965e-09
r_1472_2032_e 1472 2032 836.944
r_1472_2032_i 1472_2032 2032 4256.89
c_1472_2032_i 1472 1472_2032 4.67522e-10
r_2032_2592_e 2032 2592 836.944
r_2032_2592_i 2032_2592 2592 4256.89
c_2032_2592_i 2032 2032_2592 4.67522e-10
r_2592_3152_e 2592 3152 836.944
r_2592_3152_i 2592_3152 3152 4256.89
c_2592_3152_i 2592 2592_3152 4.67522e-10
r_3152_3712_e 3152 3712 13758.3
r_3152_3712_i 3152_3712 3712 95645.6
c_3152_3712_i 3152 3152_3712 9.36084e-12
r_353_913_e 353 913 13376.4
r_353_913_i 353_913 913 93218.1
c_353_913_i 353 353_913 2.08965e-09
r_913_1473_e 913 1473 13376.4
r_913_1473_i 913_1473 1473 93218.1
c_913_1473_i 913 913_1473 2.08965e-09
r_1473_2033_e 1473 2033 13376.4
r_1473_2033_i 1473_2033 2033 93218.1
c_1473_2033_i 1473 1473_2033 2.08965e-09
r_2033_2593_e 2033 2593 13376.4
r_2033_2593_i 2033_2593 2593 93218.1
c_2033_2593_i 2033 2033_2593 2.08965e-09
r_2593_3153_e 2593 3153 13376.4
r_2593_3153_i 2593_3153 3153 93218.1
c_2593_3153_i 2593 2593_3153 2.08965e-09
r_3153_3713_e 3153 3713 13376.4
r_3153_3713_i 3153_3713 3713 93218.1
c_3153_3713_i 3153 3153_3713 2.08965e-09
r_354_914_e 354 914 13376.4
r_354_914_i 354_914 914 93218.1
c_354_914_i 354 354_914 2.08965e-09
r_914_1474_e 914 1474 13376.4
r_914_1474_i 914_1474 1474 93218.1
c_914_1474_i 914 914_1474 2.08965e-09
r_1474_2034_e 1474 2034 13376.4
r_1474_2034_i 1474_2034 2034 93218.1
c_1474_2034_i 1474 1474_2034 2.08965e-09
r_2034_2594_e 2034 2594 13376.4
r_2034_2594_i 2034_2594 2594 93218.1
c_2034_2594_i 2034 2034_2594 2.08965e-09
r_2594_3154_e 2594 3154 13376.4
r_2594_3154_i 2594_3154 3154 93218.1
c_2594_3154_i 2594 2594_3154 2.08965e-09
r_3154_3714_e 3154 3714 13376.4
r_3154_3714_i 3154_3714 3714 93218.1
c_3154_3714_i 3154 3154_3714 2.08965e-09
r_355_915_e 355 915 13376.4
r_355_915_i 355_915 915 93218.1
c_355_915_i 355 355_915 2.08965e-09
r_915_1475_e 915 1475 13376.4
r_915_1475_i 915_1475 1475 93218.1
c_915_1475_i 915 915_1475 2.08965e-09
r_1475_2035_e 1475 2035 836.944
r_1475_2035_i 1475_2035 2035 4256.89
c_1475_2035_i 1475 1475_2035 4.67522e-10
r_2035_2595_e 2035 2595 836.944
r_2035_2595_i 2035_2595 2595 4256.89
c_2035_2595_i 2035 2035_2595 4.67522e-10
r_2595_3155_e 2595 3155 836.944
r_2595_3155_i 2595_3155 3155 4256.89
c_2595_3155_i 2595 2595_3155 4.67522e-10
r_3155_3715_e 3155 3715 836.944
r_3155_3715_i 3155_3715 3715 4256.89
c_3155_3715_i 3155 3155_3715 4.67522e-10
r_356_916_e 356 916 13376.4
r_356_916_i 356_916 916 93218.1
c_356_916_i 356 356_916 2.08965e-09
r_916_1476_e 916 1476 13376.4
r_916_1476_i 916_1476 1476 93218.1
c_916_1476_i 916 916_1476 2.08965e-09
r_1476_2036_e 1476 2036 836.944
r_1476_2036_i 1476_2036 2036 4256.89
c_1476_2036_i 1476 1476_2036 4.67522e-10
r_2036_2596_e 2036 2596 836.944
r_2036_2596_i 2036_2596 2596 4256.89
c_2036_2596_i 2036 2036_2596 4.67522e-10
r_2596_3156_e 2596 3156 836.944
r_2596_3156_i 2596_3156 3156 4256.89
c_2596_3156_i 2596 2596_3156 4.67522e-10
r_3156_3716_e 3156 3716 13758.3
r_3156_3716_i 3156_3716 3716 95645.6
c_3156_3716_i 3156 3156_3716 9.36084e-12
r_357_917_e 357 917 13376.4
r_357_917_i 357_917 917 93218.1
c_357_917_i 357 357_917 2.08965e-09
r_917_1477_e 917 1477 13376.4
r_917_1477_i 917_1477 1477 93218.1
c_917_1477_i 917 917_1477 2.08965e-09
r_1477_2037_e 1477 2037 836.944
r_1477_2037_i 1477_2037 2037 4256.89
c_1477_2037_i 1477 1477_2037 4.67522e-10
r_2037_2597_e 2037 2597 836.944
r_2037_2597_i 2037_2597 2597 4256.89
c_2037_2597_i 2037 2037_2597 4.67522e-10
r_2597_3157_e 2597 3157 836.944
r_2597_3157_i 2597_3157 3157 4256.89
c_2597_3157_i 2597 2597_3157 4.67522e-10
r_3157_3717_e 3157 3717 13758.3
r_3157_3717_i 3157_3717 3717 95645.6
c_3157_3717_i 3157 3157_3717 9.36084e-12
r_358_918_e 358 918 13376.4
r_358_918_i 358_918 918 93218.1
c_358_918_i 358 358_918 2.08965e-09
r_918_1478_e 918 1478 13376.4
r_918_1478_i 918_1478 1478 93218.1
c_918_1478_i 918 918_1478 2.08965e-09
r_1478_2038_e 1478 2038 836.944
r_1478_2038_i 1478_2038 2038 4256.89
c_1478_2038_i 1478 1478_2038 4.67522e-10
r_2038_2598_e 2038 2598 836.944
r_2038_2598_i 2038_2598 2598 4256.89
c_2038_2598_i 2038 2038_2598 4.67522e-10
r_2598_3158_e 2598 3158 836.944
r_2598_3158_i 2598_3158 3158 4256.89
c_2598_3158_i 2598 2598_3158 4.67522e-10
r_3158_3718_e 3158 3718 13758.3
r_3158_3718_i 3158_3718 3718 95645.6
c_3158_3718_i 3158 3158_3718 9.36084e-12
r_359_919_e 359 919 13376.4
r_359_919_i 359_919 919 93218.1
c_359_919_i 359 359_919 2.08965e-09
r_919_1479_e 919 1479 13376.4
r_919_1479_i 919_1479 1479 93218.1
c_919_1479_i 919 919_1479 2.08965e-09
r_1479_2039_e 1479 2039 836.944
r_1479_2039_i 1479_2039 2039 4256.89
c_1479_2039_i 1479 1479_2039 4.67522e-10
r_2039_2599_e 2039 2599 836.944
r_2039_2599_i 2039_2599 2599 4256.89
c_2039_2599_i 2039 2039_2599 4.67522e-10
r_2599_3159_e 2599 3159 836.944
r_2599_3159_i 2599_3159 3159 4256.89
c_2599_3159_i 2599 2599_3159 4.67522e-10
r_3159_3719_e 3159 3719 13758.3
r_3159_3719_i 3159_3719 3719 95645.6
c_3159_3719_i 3159 3159_3719 9.36084e-12
r_360_920_e 360 920 13376.4
r_360_920_i 360_920 920 93218.1
c_360_920_i 360 360_920 2.08965e-09
r_920_1480_e 920 1480 13376.4
r_920_1480_i 920_1480 1480 93218.1
c_920_1480_i 920 920_1480 2.08965e-09
r_1480_2040_e 1480 2040 836.944
r_1480_2040_i 1480_2040 2040 4256.89
c_1480_2040_i 1480 1480_2040 4.67522e-10
r_2040_2600_e 2040 2600 836.944
r_2040_2600_i 2040_2600 2600 4256.89
c_2040_2600_i 2040 2040_2600 4.67522e-10
r_2600_3160_e 2600 3160 836.944
r_2600_3160_i 2600_3160 3160 4256.89
c_2600_3160_i 2600 2600_3160 4.67522e-10
r_3160_3720_e 3160 3720 13758.3
r_3160_3720_i 3160_3720 3720 95645.6
c_3160_3720_i 3160 3160_3720 9.36084e-12
r_361_921_e 361 921 13376.4
r_361_921_i 361_921 921 93218.1
c_361_921_i 361 361_921 2.08965e-09
r_921_1481_e 921 1481 13376.4
r_921_1481_i 921_1481 1481 93218.1
c_921_1481_i 921 921_1481 2.08965e-09
r_1481_2041_e 1481 2041 836.944
r_1481_2041_i 1481_2041 2041 4256.89
c_1481_2041_i 1481 1481_2041 4.67522e-10
r_2041_2601_e 2041 2601 836.944
r_2041_2601_i 2041_2601 2601 4256.89
c_2041_2601_i 2041 2041_2601 4.67522e-10
r_2601_3161_e 2601 3161 836.944
r_2601_3161_i 2601_3161 3161 4256.89
c_2601_3161_i 2601 2601_3161 4.67522e-10
r_3161_3721_e 3161 3721 13758.3
r_3161_3721_i 3161_3721 3721 95645.6
c_3161_3721_i 3161 3161_3721 9.36084e-12
r_362_922_e 362 922 13376.4
r_362_922_i 362_922 922 93218.1
c_362_922_i 362 362_922 2.08965e-09
r_922_1482_e 922 1482 13376.4
r_922_1482_i 922_1482 1482 93218.1
c_922_1482_i 922 922_1482 2.08965e-09
r_1482_2042_e 1482 2042 836.944
r_1482_2042_i 1482_2042 2042 4256.89
c_1482_2042_i 1482 1482_2042 4.67522e-10
r_2042_2602_e 2042 2602 836.944
r_2042_2602_i 2042_2602 2602 4256.89
c_2042_2602_i 2042 2042_2602 4.67522e-10
r_2602_3162_e 2602 3162 836.944
r_2602_3162_i 2602_3162 3162 4256.89
c_2602_3162_i 2602 2602_3162 4.67522e-10
r_3162_3722_e 3162 3722 13758.3
r_3162_3722_i 3162_3722 3722 95645.6
c_3162_3722_i 3162 3162_3722 9.36084e-12
r_363_923_e 363 923 13376.4
r_363_923_i 363_923 923 93218.1
c_363_923_i 363 363_923 2.08965e-09
r_923_1483_e 923 1483 396.585
r_923_1483_i 923_1483 1483 1004.98
c_923_1483_i 923 923_1483 1.65842e-10
r_1483_2043_e 1483 2043 836.944
r_1483_2043_i 1483_2043 2043 4256.89
c_1483_2043_i 1483 1483_2043 4.67522e-10
r_2043_2603_e 2043 2603 836.944
r_2043_2603_i 2043_2603 2603 4256.89
c_2043_2603_i 2043 2043_2603 4.67522e-10
r_2603_3163_e 2603 3163 836.944
r_2603_3163_i 2603_3163 3163 4256.89
c_2603_3163_i 2603 2603_3163 4.67522e-10
r_3163_3723_e 3163 3723 13758.3
r_3163_3723_i 3163_3723 3723 95645.6
c_3163_3723_i 3163 3163_3723 9.36084e-12
r_364_924_e 364 924 13376.4
r_364_924_i 364_924 924 93218.1
c_364_924_i 364 364_924 2.08965e-09
r_924_1484_e 924 1484 396.585
r_924_1484_i 924_1484 1484 1004.98
c_924_1484_i 924 924_1484 1.65842e-10
r_1484_2044_e 1484 2044 836.944
r_1484_2044_i 1484_2044 2044 4256.89
c_1484_2044_i 1484 1484_2044 4.67522e-10
r_2044_2604_e 2044 2604 836.944
r_2044_2604_i 2044_2604 2604 4256.89
c_2044_2604_i 2044 2044_2604 4.67522e-10
r_2604_3164_e 2604 3164 836.944
r_2604_3164_i 2604_3164 3164 4256.89
c_2604_3164_i 2604 2604_3164 4.67522e-10
r_3164_3724_e 3164 3724 13758.3
r_3164_3724_i 3164_3724 3724 95645.6
c_3164_3724_i 3164 3164_3724 9.36084e-12
r_365_925_e 365 925 13376.4
r_365_925_i 365_925 925 93218.1
c_365_925_i 365 365_925 2.08965e-09
r_925_1485_e 925 1485 13376.4
r_925_1485_i 925_1485 1485 93218.1
c_925_1485_i 925 925_1485 2.08965e-09
r_1485_2045_e 1485 2045 836.944
r_1485_2045_i 1485_2045 2045 4256.89
c_1485_2045_i 1485 1485_2045 4.67522e-10
r_2045_2605_e 2045 2605 836.944
r_2045_2605_i 2045_2605 2605 4256.89
c_2045_2605_i 2045 2045_2605 4.67522e-10
r_2605_3165_e 2605 3165 836.944
r_2605_3165_i 2605_3165 3165 4256.89
c_2605_3165_i 2605 2605_3165 4.67522e-10
r_3165_3725_e 3165 3725 13758.3
r_3165_3725_i 3165_3725 3725 95645.6
c_3165_3725_i 3165 3165_3725 9.36084e-12
r_366_926_e 366 926 13376.4
r_366_926_i 366_926 926 93218.1
c_366_926_i 366 366_926 2.08965e-09
r_926_1486_e 926 1486 13376.4
r_926_1486_i 926_1486 1486 93218.1
c_926_1486_i 926 926_1486 2.08965e-09
r_1486_2046_e 1486 2046 836.944
r_1486_2046_i 1486_2046 2046 4256.89
c_1486_2046_i 1486 1486_2046 4.67522e-10
r_2046_2606_e 2046 2606 836.944
r_2046_2606_i 2046_2606 2606 4256.89
c_2046_2606_i 2046 2046_2606 4.67522e-10
r_2606_3166_e 2606 3166 836.944
r_2606_3166_i 2606_3166 3166 4256.89
c_2606_3166_i 2606 2606_3166 4.67522e-10
r_3166_3726_e 3166 3726 13758.3
r_3166_3726_i 3166_3726 3726 95645.6
c_3166_3726_i 3166 3166_3726 9.36084e-12
r_367_927_e 367 927 13376.4
r_367_927_i 367_927 927 93218.1
c_367_927_i 367 367_927 2.08965e-09
r_927_1487_e 927 1487 13376.4
r_927_1487_i 927_1487 1487 93218.1
c_927_1487_i 927 927_1487 2.08965e-09
r_1487_2047_e 1487 2047 836.944
r_1487_2047_i 1487_2047 2047 4256.89
c_1487_2047_i 1487 1487_2047 4.67522e-10
r_2047_2607_e 2047 2607 836.944
r_2047_2607_i 2047_2607 2607 4256.89
c_2047_2607_i 2047 2047_2607 4.67522e-10
r_2607_3167_e 2607 3167 836.944
r_2607_3167_i 2607_3167 3167 4256.89
c_2607_3167_i 2607 2607_3167 4.67522e-10
r_3167_3727_e 3167 3727 13758.3
r_3167_3727_i 3167_3727 3727 95645.6
c_3167_3727_i 3167 3167_3727 9.36084e-12
r_368_928_e 368 928 13376.4
r_368_928_i 368_928 928 93218.1
c_368_928_i 368 368_928 2.08965e-09
r_928_1488_e 928 1488 13376.4
r_928_1488_i 928_1488 1488 93218.1
c_928_1488_i 928 928_1488 2.08965e-09
r_1488_2048_e 1488 2048 836.944
r_1488_2048_i 1488_2048 2048 4256.89
c_1488_2048_i 1488 1488_2048 4.67522e-10
r_2048_2608_e 2048 2608 836.944
r_2048_2608_i 2048_2608 2608 4256.89
c_2048_2608_i 2048 2048_2608 4.67522e-10
r_2608_3168_e 2608 3168 836.944
r_2608_3168_i 2608_3168 3168 4256.89
c_2608_3168_i 2608 2608_3168 4.67522e-10
r_3168_3728_e 3168 3728 13758.3
r_3168_3728_i 3168_3728 3728 95645.6
c_3168_3728_i 3168 3168_3728 9.36084e-12
r_369_929_e 369 929 13376.4
r_369_929_i 369_929 929 93218.1
c_369_929_i 369 369_929 2.08965e-09
r_929_1489_e 929 1489 13376.4
r_929_1489_i 929_1489 1489 93218.1
c_929_1489_i 929 929_1489 2.08965e-09
r_1489_2049_e 1489 2049 13376.4
r_1489_2049_i 1489_2049 2049 93218.1
c_1489_2049_i 1489 1489_2049 2.08965e-09
r_2049_2609_e 2049 2609 13376.4
r_2049_2609_i 2049_2609 2609 93218.1
c_2049_2609_i 2049 2049_2609 2.08965e-09
r_2609_3169_e 2609 3169 13376.4
r_2609_3169_i 2609_3169 3169 93218.1
c_2609_3169_i 2609 2609_3169 2.08965e-09
r_3169_3729_e 3169 3729 13376.4
r_3169_3729_i 3169_3729 3729 93218.1
c_3169_3729_i 3169 3169_3729 2.08965e-09
r_370_930_e 370 930 13376.4
r_370_930_i 370_930 930 93218.1
c_370_930_i 370 370_930 2.08965e-09
r_930_1490_e 930 1490 13376.4
r_930_1490_i 930_1490 1490 93218.1
c_930_1490_i 930 930_1490 2.08965e-09
r_1490_2050_e 1490 2050 13376.4
r_1490_2050_i 1490_2050 2050 93218.1
c_1490_2050_i 1490 1490_2050 2.08965e-09
r_2050_2610_e 2050 2610 13376.4
r_2050_2610_i 2050_2610 2610 93218.1
c_2050_2610_i 2050 2050_2610 2.08965e-09
r_2610_3170_e 2610 3170 13376.4
r_2610_3170_i 2610_3170 3170 93218.1
c_2610_3170_i 2610 2610_3170 2.08965e-09
r_3170_3730_e 3170 3730 13376.4
r_3170_3730_i 3170_3730 3730 93218.1
c_3170_3730_i 3170 3170_3730 2.08965e-09
r_371_931_e 371 931 13376.4
r_371_931_i 371_931 931 93218.1
c_371_931_i 371 371_931 2.08965e-09
r_931_1491_e 931 1491 13376.4
r_931_1491_i 931_1491 1491 93218.1
c_931_1491_i 931 931_1491 2.08965e-09
r_1491_2051_e 1491 2051 836.944
r_1491_2051_i 1491_2051 2051 4256.89
c_1491_2051_i 1491 1491_2051 4.67522e-10
r_2051_2611_e 2051 2611 836.944
r_2051_2611_i 2051_2611 2611 4256.89
c_2051_2611_i 2051 2051_2611 4.67522e-10
r_2611_3171_e 2611 3171 836.944
r_2611_3171_i 2611_3171 3171 4256.89
c_2611_3171_i 2611 2611_3171 4.67522e-10
r_3171_3731_e 3171 3731 836.944
r_3171_3731_i 3171_3731 3731 4256.89
c_3171_3731_i 3171 3171_3731 4.67522e-10
r_372_932_e 372 932 13376.4
r_372_932_i 372_932 932 93218.1
c_372_932_i 372 372_932 2.08965e-09
r_932_1492_e 932 1492 13376.4
r_932_1492_i 932_1492 1492 93218.1
c_932_1492_i 932 932_1492 2.08965e-09
r_1492_2052_e 1492 2052 836.944
r_1492_2052_i 1492_2052 2052 4256.89
c_1492_2052_i 1492 1492_2052 4.67522e-10
r_2052_2612_e 2052 2612 836.944
r_2052_2612_i 2052_2612 2612 4256.89
c_2052_2612_i 2052 2052_2612 4.67522e-10
r_2612_3172_e 2612 3172 836.944
r_2612_3172_i 2612_3172 3172 4256.89
c_2612_3172_i 2612 2612_3172 4.67522e-10
r_3172_3732_e 3172 3732 13758.3
r_3172_3732_i 3172_3732 3732 95645.6
c_3172_3732_i 3172 3172_3732 9.36084e-12
r_373_933_e 373 933 13376.4
r_373_933_i 373_933 933 93218.1
c_373_933_i 373 373_933 2.08965e-09
r_933_1493_e 933 1493 13376.4
r_933_1493_i 933_1493 1493 93218.1
c_933_1493_i 933 933_1493 2.08965e-09
r_1493_2053_e 1493 2053 836.944
r_1493_2053_i 1493_2053 2053 4256.89
c_1493_2053_i 1493 1493_2053 4.67522e-10
r_2053_2613_e 2053 2613 836.944
r_2053_2613_i 2053_2613 2613 4256.89
c_2053_2613_i 2053 2053_2613 4.67522e-10
r_2613_3173_e 2613 3173 836.944
r_2613_3173_i 2613_3173 3173 4256.89
c_2613_3173_i 2613 2613_3173 4.67522e-10
r_3173_3733_e 3173 3733 13758.3
r_3173_3733_i 3173_3733 3733 95645.6
c_3173_3733_i 3173 3173_3733 9.36084e-12
r_374_934_e 374 934 13376.4
r_374_934_i 374_934 934 93218.1
c_374_934_i 374 374_934 2.08965e-09
r_934_1494_e 934 1494 13376.4
r_934_1494_i 934_1494 1494 93218.1
c_934_1494_i 934 934_1494 2.08965e-09
r_1494_2054_e 1494 2054 836.944
r_1494_2054_i 1494_2054 2054 4256.89
c_1494_2054_i 1494 1494_2054 4.67522e-10
r_2054_2614_e 2054 2614 836.944
r_2054_2614_i 2054_2614 2614 4256.89
c_2054_2614_i 2054 2054_2614 4.67522e-10
r_2614_3174_e 2614 3174 836.944
r_2614_3174_i 2614_3174 3174 4256.89
c_2614_3174_i 2614 2614_3174 4.67522e-10
r_3174_3734_e 3174 3734 13758.3
r_3174_3734_i 3174_3734 3734 95645.6
c_3174_3734_i 3174 3174_3734 9.36084e-12
r_375_935_e 375 935 13376.4
r_375_935_i 375_935 935 93218.1
c_375_935_i 375 375_935 2.08965e-09
r_935_1495_e 935 1495 13376.4
r_935_1495_i 935_1495 1495 93218.1
c_935_1495_i 935 935_1495 2.08965e-09
r_1495_2055_e 1495 2055 836.944
r_1495_2055_i 1495_2055 2055 4256.89
c_1495_2055_i 1495 1495_2055 4.67522e-10
r_2055_2615_e 2055 2615 836.944
r_2055_2615_i 2055_2615 2615 4256.89
c_2055_2615_i 2055 2055_2615 4.67522e-10
r_2615_3175_e 2615 3175 836.944
r_2615_3175_i 2615_3175 3175 4256.89
c_2615_3175_i 2615 2615_3175 4.67522e-10
r_3175_3735_e 3175 3735 13758.3
r_3175_3735_i 3175_3735 3735 95645.6
c_3175_3735_i 3175 3175_3735 9.36084e-12
r_376_936_e 376 936 13376.4
r_376_936_i 376_936 936 93218.1
c_376_936_i 376 376_936 2.08965e-09
r_936_1496_e 936 1496 13376.4
r_936_1496_i 936_1496 1496 93218.1
c_936_1496_i 936 936_1496 2.08965e-09
r_1496_2056_e 1496 2056 836.944
r_1496_2056_i 1496_2056 2056 4256.89
c_1496_2056_i 1496 1496_2056 4.67522e-10
r_2056_2616_e 2056 2616 836.944
r_2056_2616_i 2056_2616 2616 4256.89
c_2056_2616_i 2056 2056_2616 4.67522e-10
r_2616_3176_e 2616 3176 836.944
r_2616_3176_i 2616_3176 3176 4256.89
c_2616_3176_i 2616 2616_3176 4.67522e-10
r_3176_3736_e 3176 3736 13758.3
r_3176_3736_i 3176_3736 3736 95645.6
c_3176_3736_i 3176 3176_3736 9.36084e-12
r_377_937_e 377 937 13376.4
r_377_937_i 377_937 937 93218.1
c_377_937_i 377 377_937 2.08965e-09
r_937_1497_e 937 1497 13376.4
r_937_1497_i 937_1497 1497 93218.1
c_937_1497_i 937 937_1497 2.08965e-09
r_1497_2057_e 1497 2057 836.944
r_1497_2057_i 1497_2057 2057 4256.89
c_1497_2057_i 1497 1497_2057 4.67522e-10
r_2057_2617_e 2057 2617 836.944
r_2057_2617_i 2057_2617 2617 4256.89
c_2057_2617_i 2057 2057_2617 4.67522e-10
r_2617_3177_e 2617 3177 836.944
r_2617_3177_i 2617_3177 3177 4256.89
c_2617_3177_i 2617 2617_3177 4.67522e-10
r_3177_3737_e 3177 3737 13758.3
r_3177_3737_i 3177_3737 3737 95645.6
c_3177_3737_i 3177 3177_3737 9.36084e-12
r_378_938_e 378 938 13376.4
r_378_938_i 378_938 938 93218.1
c_378_938_i 378 378_938 2.08965e-09
r_938_1498_e 938 1498 13376.4
r_938_1498_i 938_1498 1498 93218.1
c_938_1498_i 938 938_1498 2.08965e-09
r_1498_2058_e 1498 2058 836.944
r_1498_2058_i 1498_2058 2058 4256.89
c_1498_2058_i 1498 1498_2058 4.67522e-10
r_2058_2618_e 2058 2618 836.944
r_2058_2618_i 2058_2618 2618 4256.89
c_2058_2618_i 2058 2058_2618 4.67522e-10
r_2618_3178_e 2618 3178 836.944
r_2618_3178_i 2618_3178 3178 4256.89
c_2618_3178_i 2618 2618_3178 4.67522e-10
r_3178_3738_e 3178 3738 13758.3
r_3178_3738_i 3178_3738 3738 95645.6
c_3178_3738_i 3178 3178_3738 9.36084e-12
r_379_939_e 379 939 13376.4
r_379_939_i 379_939 939 93218.1
c_379_939_i 379 379_939 2.08965e-09
r_939_1499_e 939 1499 396.576
r_939_1499_i 939_1499 1499 1004.96
c_939_1499_i 939 939_1499 1.65845e-10
r_1499_2059_e 1499 2059 836.944
r_1499_2059_i 1499_2059 2059 4256.89
c_1499_2059_i 1499 1499_2059 4.67522e-10
r_2059_2619_e 2059 2619 836.944
r_2059_2619_i 2059_2619 2619 4256.89
c_2059_2619_i 2059 2059_2619 4.67522e-10
r_2619_3179_e 2619 3179 836.944
r_2619_3179_i 2619_3179 3179 4256.89
c_2619_3179_i 2619 2619_3179 4.67522e-10
r_3179_3739_e 3179 3739 13758.3
r_3179_3739_i 3179_3739 3739 95645.6
c_3179_3739_i 3179 3179_3739 9.36084e-12
r_380_940_e 380 940 13376.4
r_380_940_i 380_940 940 93218.1
c_380_940_i 380 380_940 2.08965e-09
r_940_1500_e 940 1500 396.576
r_940_1500_i 940_1500 1500 1004.96
c_940_1500_i 940 940_1500 1.65845e-10
r_1500_2060_e 1500 2060 836.944
r_1500_2060_i 1500_2060 2060 4256.89
c_1500_2060_i 1500 1500_2060 4.67522e-10
r_2060_2620_e 2060 2620 836.944
r_2060_2620_i 2060_2620 2620 4256.89
c_2060_2620_i 2060 2060_2620 4.67522e-10
r_2620_3180_e 2620 3180 836.944
r_2620_3180_i 2620_3180 3180 4256.89
c_2620_3180_i 2620 2620_3180 4.67522e-10
r_3180_3740_e 3180 3740 13758.3
r_3180_3740_i 3180_3740 3740 95645.6
c_3180_3740_i 3180 3180_3740 9.36084e-12
r_381_941_e 381 941 13376.4
r_381_941_i 381_941 941 93218.1
c_381_941_i 381 381_941 2.08965e-09
r_941_1501_e 941 1501 13376.4
r_941_1501_i 941_1501 1501 93218.1
c_941_1501_i 941 941_1501 2.08965e-09
r_1501_2061_e 1501 2061 836.944
r_1501_2061_i 1501_2061 2061 4256.89
c_1501_2061_i 1501 1501_2061 4.67522e-10
r_2061_2621_e 2061 2621 836.944
r_2061_2621_i 2061_2621 2621 4256.89
c_2061_2621_i 2061 2061_2621 4.67522e-10
r_2621_3181_e 2621 3181 836.944
r_2621_3181_i 2621_3181 3181 4256.89
c_2621_3181_i 2621 2621_3181 4.67522e-10
r_3181_3741_e 3181 3741 13758.3
r_3181_3741_i 3181_3741 3741 95645.6
c_3181_3741_i 3181 3181_3741 9.36084e-12
r_382_942_e 382 942 13376.4
r_382_942_i 382_942 942 93218.1
c_382_942_i 382 382_942 2.08965e-09
r_942_1502_e 942 1502 13376.4
r_942_1502_i 942_1502 1502 93218.1
c_942_1502_i 942 942_1502 2.08965e-09
r_1502_2062_e 1502 2062 836.944
r_1502_2062_i 1502_2062 2062 4256.89
c_1502_2062_i 1502 1502_2062 4.67522e-10
r_2062_2622_e 2062 2622 836.944
r_2062_2622_i 2062_2622 2622 4256.89
c_2062_2622_i 2062 2062_2622 4.67522e-10
r_2622_3182_e 2622 3182 836.944
r_2622_3182_i 2622_3182 3182 4256.89
c_2622_3182_i 2622 2622_3182 4.67522e-10
r_3182_3742_e 3182 3742 13758.3
r_3182_3742_i 3182_3742 3742 95645.6
c_3182_3742_i 3182 3182_3742 9.36084e-12
r_383_943_e 383 943 13376.4
r_383_943_i 383_943 943 93218.1
c_383_943_i 383 383_943 2.08965e-09
r_943_1503_e 943 1503 13376.4
r_943_1503_i 943_1503 1503 93218.1
c_943_1503_i 943 943_1503 2.08965e-09
r_1503_2063_e 1503 2063 836.944
r_1503_2063_i 1503_2063 2063 4256.89
c_1503_2063_i 1503 1503_2063 4.67522e-10
r_2063_2623_e 2063 2623 836.944
r_2063_2623_i 2063_2623 2623 4256.89
c_2063_2623_i 2063 2063_2623 4.67522e-10
r_2623_3183_e 2623 3183 836.944
r_2623_3183_i 2623_3183 3183 4256.89
c_2623_3183_i 2623 2623_3183 4.67522e-10
r_3183_3743_e 3183 3743 13758.3
r_3183_3743_i 3183_3743 3743 95645.6
c_3183_3743_i 3183 3183_3743 9.36084e-12
r_384_944_e 384 944 13376.4
r_384_944_i 384_944 944 93218.1
c_384_944_i 384 384_944 2.08965e-09
r_944_1504_e 944 1504 13376.4
r_944_1504_i 944_1504 1504 93218.1
c_944_1504_i 944 944_1504 2.08965e-09
r_1504_2064_e 1504 2064 836.944
r_1504_2064_i 1504_2064 2064 4256.89
c_1504_2064_i 1504 1504_2064 4.67522e-10
r_2064_2624_e 2064 2624 836.944
r_2064_2624_i 2064_2624 2624 4256.89
c_2064_2624_i 2064 2064_2624 4.67522e-10
r_2624_3184_e 2624 3184 836.944
r_2624_3184_i 2624_3184 3184 4256.89
c_2624_3184_i 2624 2624_3184 4.67522e-10
r_3184_3744_e 3184 3744 13758.3
r_3184_3744_i 3184_3744 3744 95645.6
c_3184_3744_i 3184 3184_3744 9.36084e-12
r_385_945_e 385 945 13376.4
r_385_945_i 385_945 945 93218.1
c_385_945_i 385 385_945 2.08965e-09
r_945_1505_e 945 1505 13376.4
r_945_1505_i 945_1505 1505 93218.1
c_945_1505_i 945 945_1505 2.08965e-09
r_1505_2065_e 1505 2065 13376.4
r_1505_2065_i 1505_2065 2065 93218.1
c_1505_2065_i 1505 1505_2065 2.08965e-09
r_2065_2625_e 2065 2625 13376.4
r_2065_2625_i 2065_2625 2625 93218.1
c_2065_2625_i 2065 2065_2625 2.08965e-09
r_2625_3185_e 2625 3185 13376.4
r_2625_3185_i 2625_3185 3185 93218.1
c_2625_3185_i 2625 2625_3185 2.08965e-09
r_3185_3745_e 3185 3745 13376.4
r_3185_3745_i 3185_3745 3745 93218.1
c_3185_3745_i 3185 3185_3745 2.08965e-09
r_386_946_e 386 946 13376.4
r_386_946_i 386_946 946 93218.1
c_386_946_i 386 386_946 2.08965e-09
r_946_1506_e 946 1506 13376.4
r_946_1506_i 946_1506 1506 93218.1
c_946_1506_i 946 946_1506 2.08965e-09
r_1506_2066_e 1506 2066 13376.4
r_1506_2066_i 1506_2066 2066 93218.1
c_1506_2066_i 1506 1506_2066 2.08965e-09
r_2066_2626_e 2066 2626 13376.4
r_2066_2626_i 2066_2626 2626 93218.1
c_2066_2626_i 2066 2066_2626 2.08965e-09
r_2626_3186_e 2626 3186 13376.4
r_2626_3186_i 2626_3186 3186 93218.1
c_2626_3186_i 2626 2626_3186 2.08965e-09
r_3186_3746_e 3186 3746 13376.4
r_3186_3746_i 3186_3746 3746 93218.1
c_3186_3746_i 3186 3186_3746 2.08965e-09
r_387_947_e 387 947 13376.4
r_387_947_i 387_947 947 93218.1
c_387_947_i 387 387_947 2.08965e-09
r_947_1507_e 947 1507 13376.4
r_947_1507_i 947_1507 1507 93218.1
c_947_1507_i 947 947_1507 2.08965e-09
r_1507_2067_e 1507 2067 836.944
r_1507_2067_i 1507_2067 2067 4256.89
c_1507_2067_i 1507 1507_2067 4.67522e-10
r_2067_2627_e 2067 2627 836.944
r_2067_2627_i 2067_2627 2627 4256.89
c_2067_2627_i 2067 2067_2627 4.67522e-10
r_2627_3187_e 2627 3187 836.944
r_2627_3187_i 2627_3187 3187 4256.89
c_2627_3187_i 2627 2627_3187 4.67522e-10
r_3187_3747_e 3187 3747 836.944
r_3187_3747_i 3187_3747 3747 4256.89
c_3187_3747_i 3187 3187_3747 4.67522e-10
r_388_948_e 388 948 13376.4
r_388_948_i 388_948 948 93218.1
c_388_948_i 388 388_948 2.08965e-09
r_948_1508_e 948 1508 13376.4
r_948_1508_i 948_1508 1508 93218.1
c_948_1508_i 948 948_1508 2.08965e-09
r_1508_2068_e 1508 2068 836.944
r_1508_2068_i 1508_2068 2068 4256.89
c_1508_2068_i 1508 1508_2068 4.67522e-10
r_2068_2628_e 2068 2628 836.944
r_2068_2628_i 2068_2628 2628 4256.89
c_2068_2628_i 2068 2068_2628 4.67522e-10
r_2628_3188_e 2628 3188 836.944
r_2628_3188_i 2628_3188 3188 4256.89
c_2628_3188_i 2628 2628_3188 4.67522e-10
r_3188_3748_e 3188 3748 13758.3
r_3188_3748_i 3188_3748 3748 95645.6
c_3188_3748_i 3188 3188_3748 9.36084e-12
r_389_949_e 389 949 13376.4
r_389_949_i 389_949 949 93218.1
c_389_949_i 389 389_949 2.08965e-09
r_949_1509_e 949 1509 13376.4
r_949_1509_i 949_1509 1509 93218.1
c_949_1509_i 949 949_1509 2.08965e-09
r_1509_2069_e 1509 2069 836.944
r_1509_2069_i 1509_2069 2069 4256.89
c_1509_2069_i 1509 1509_2069 4.67522e-10
r_2069_2629_e 2069 2629 836.944
r_2069_2629_i 2069_2629 2629 4256.89
c_2069_2629_i 2069 2069_2629 4.67522e-10
r_2629_3189_e 2629 3189 836.944
r_2629_3189_i 2629_3189 3189 4256.89
c_2629_3189_i 2629 2629_3189 4.67522e-10
r_3189_3749_e 3189 3749 13758.3
r_3189_3749_i 3189_3749 3749 95645.6
c_3189_3749_i 3189 3189_3749 9.36084e-12
r_390_950_e 390 950 13376.4
r_390_950_i 390_950 950 93218.1
c_390_950_i 390 390_950 2.08965e-09
r_950_1510_e 950 1510 13376.4
r_950_1510_i 950_1510 1510 93218.1
c_950_1510_i 950 950_1510 2.08965e-09
r_1510_2070_e 1510 2070 836.944
r_1510_2070_i 1510_2070 2070 4256.89
c_1510_2070_i 1510 1510_2070 4.67522e-10
r_2070_2630_e 2070 2630 836.944
r_2070_2630_i 2070_2630 2630 4256.89
c_2070_2630_i 2070 2070_2630 4.67522e-10
r_2630_3190_e 2630 3190 836.944
r_2630_3190_i 2630_3190 3190 4256.89
c_2630_3190_i 2630 2630_3190 4.67522e-10
r_3190_3750_e 3190 3750 13758.3
r_3190_3750_i 3190_3750 3750 95645.6
c_3190_3750_i 3190 3190_3750 9.36084e-12
r_391_951_e 391 951 13376.4
r_391_951_i 391_951 951 93218.1
c_391_951_i 391 391_951 2.08965e-09
r_951_1511_e 951 1511 13376.4
r_951_1511_i 951_1511 1511 93218.1
c_951_1511_i 951 951_1511 2.08965e-09
r_1511_2071_e 1511 2071 836.944
r_1511_2071_i 1511_2071 2071 4256.89
c_1511_2071_i 1511 1511_2071 4.67522e-10
r_2071_2631_e 2071 2631 836.944
r_2071_2631_i 2071_2631 2631 4256.89
c_2071_2631_i 2071 2071_2631 4.67522e-10
r_2631_3191_e 2631 3191 836.944
r_2631_3191_i 2631_3191 3191 4256.89
c_2631_3191_i 2631 2631_3191 4.67522e-10
r_3191_3751_e 3191 3751 13758.3
r_3191_3751_i 3191_3751 3751 95645.6
c_3191_3751_i 3191 3191_3751 9.36084e-12
r_392_952_e 392 952 13376.4
r_392_952_i 392_952 952 93218.1
c_392_952_i 392 392_952 2.08965e-09
r_952_1512_e 952 1512 13376.4
r_952_1512_i 952_1512 1512 93218.1
c_952_1512_i 952 952_1512 2.08965e-09
r_1512_2072_e 1512 2072 836.944
r_1512_2072_i 1512_2072 2072 4256.89
c_1512_2072_i 1512 1512_2072 4.67522e-10
r_2072_2632_e 2072 2632 836.944
r_2072_2632_i 2072_2632 2632 4256.89
c_2072_2632_i 2072 2072_2632 4.67522e-10
r_2632_3192_e 2632 3192 836.944
r_2632_3192_i 2632_3192 3192 4256.89
c_2632_3192_i 2632 2632_3192 4.67522e-10
r_3192_3752_e 3192 3752 13758.3
r_3192_3752_i 3192_3752 3752 95645.6
c_3192_3752_i 3192 3192_3752 9.36084e-12
r_393_953_e 393 953 13376.4
r_393_953_i 393_953 953 93218.1
c_393_953_i 393 393_953 2.08965e-09
r_953_1513_e 953 1513 13376.4
r_953_1513_i 953_1513 1513 93218.1
c_953_1513_i 953 953_1513 2.08965e-09
r_1513_2073_e 1513 2073 836.944
r_1513_2073_i 1513_2073 2073 4256.89
c_1513_2073_i 1513 1513_2073 4.67522e-10
r_2073_2633_e 2073 2633 836.944
r_2073_2633_i 2073_2633 2633 4256.89
c_2073_2633_i 2073 2073_2633 4.67522e-10
r_2633_3193_e 2633 3193 836.944
r_2633_3193_i 2633_3193 3193 4256.89
c_2633_3193_i 2633 2633_3193 4.67522e-10
r_3193_3753_e 3193 3753 13758.3
r_3193_3753_i 3193_3753 3753 95645.6
c_3193_3753_i 3193 3193_3753 9.36084e-12
r_394_954_e 394 954 13376.4
r_394_954_i 394_954 954 93218.1
c_394_954_i 394 394_954 2.08965e-09
r_954_1514_e 954 1514 13376.4
r_954_1514_i 954_1514 1514 93218.1
c_954_1514_i 954 954_1514 2.08965e-09
r_1514_2074_e 1514 2074 836.944
r_1514_2074_i 1514_2074 2074 4256.89
c_1514_2074_i 1514 1514_2074 4.67522e-10
r_2074_2634_e 2074 2634 836.944
r_2074_2634_i 2074_2634 2634 4256.89
c_2074_2634_i 2074 2074_2634 4.67522e-10
r_2634_3194_e 2634 3194 836.944
r_2634_3194_i 2634_3194 3194 4256.89
c_2634_3194_i 2634 2634_3194 4.67522e-10
r_3194_3754_e 3194 3754 13758.3
r_3194_3754_i 3194_3754 3754 95645.6
c_3194_3754_i 3194 3194_3754 9.36084e-12
r_395_955_e 395 955 13376.4
r_395_955_i 395_955 955 93218.1
c_395_955_i 395 395_955 2.08965e-09
r_955_1515_e 955 1515 396.568
r_955_1515_i 955_1515 1515 1004.94
c_955_1515_i 955 955_1515 1.65849e-10
r_1515_2075_e 1515 2075 836.944
r_1515_2075_i 1515_2075 2075 4256.89
c_1515_2075_i 1515 1515_2075 4.67522e-10
r_2075_2635_e 2075 2635 836.944
r_2075_2635_i 2075_2635 2635 4256.89
c_2075_2635_i 2075 2075_2635 4.67522e-10
r_2635_3195_e 2635 3195 836.944
r_2635_3195_i 2635_3195 3195 4256.89
c_2635_3195_i 2635 2635_3195 4.67522e-10
r_3195_3755_e 3195 3755 13758.3
r_3195_3755_i 3195_3755 3755 95645.6
c_3195_3755_i 3195 3195_3755 9.36084e-12
r_396_956_e 396 956 13376.4
r_396_956_i 396_956 956 93218.1
c_396_956_i 396 396_956 2.08965e-09
r_956_1516_e 956 1516 396.568
r_956_1516_i 956_1516 1516 1004.94
c_956_1516_i 956 956_1516 1.65849e-10
r_1516_2076_e 1516 2076 836.944
r_1516_2076_i 1516_2076 2076 4256.89
c_1516_2076_i 1516 1516_2076 4.67522e-10
r_2076_2636_e 2076 2636 836.944
r_2076_2636_i 2076_2636 2636 4256.89
c_2076_2636_i 2076 2076_2636 4.67522e-10
r_2636_3196_e 2636 3196 836.944
r_2636_3196_i 2636_3196 3196 4256.89
c_2636_3196_i 2636 2636_3196 4.67522e-10
r_3196_3756_e 3196 3756 13758.3
r_3196_3756_i 3196_3756 3756 95645.6
c_3196_3756_i 3196 3196_3756 9.36084e-12
r_397_957_e 397 957 13376.4
r_397_957_i 397_957 957 93218.1
c_397_957_i 397 397_957 2.08965e-09
r_957_1517_e 957 1517 13376.4
r_957_1517_i 957_1517 1517 93218.1
c_957_1517_i 957 957_1517 2.08965e-09
r_1517_2077_e 1517 2077 836.944
r_1517_2077_i 1517_2077 2077 4256.89
c_1517_2077_i 1517 1517_2077 4.67522e-10
r_2077_2637_e 2077 2637 836.944
r_2077_2637_i 2077_2637 2637 4256.89
c_2077_2637_i 2077 2077_2637 4.67522e-10
r_2637_3197_e 2637 3197 836.944
r_2637_3197_i 2637_3197 3197 4256.89
c_2637_3197_i 2637 2637_3197 4.67522e-10
r_3197_3757_e 3197 3757 13758.3
r_3197_3757_i 3197_3757 3757 95645.6
c_3197_3757_i 3197 3197_3757 9.36084e-12
r_398_958_e 398 958 13376.4
r_398_958_i 398_958 958 93218.1
c_398_958_i 398 398_958 2.08965e-09
r_958_1518_e 958 1518 13376.4
r_958_1518_i 958_1518 1518 93218.1
c_958_1518_i 958 958_1518 2.08965e-09
r_1518_2078_e 1518 2078 836.944
r_1518_2078_i 1518_2078 2078 4256.89
c_1518_2078_i 1518 1518_2078 4.67522e-10
r_2078_2638_e 2078 2638 836.944
r_2078_2638_i 2078_2638 2638 4256.89
c_2078_2638_i 2078 2078_2638 4.67522e-10
r_2638_3198_e 2638 3198 836.944
r_2638_3198_i 2638_3198 3198 4256.89
c_2638_3198_i 2638 2638_3198 4.67522e-10
r_3198_3758_e 3198 3758 13758.3
r_3198_3758_i 3198_3758 3758 95645.6
c_3198_3758_i 3198 3198_3758 9.36084e-12
r_399_959_e 399 959 13376.4
r_399_959_i 399_959 959 93218.1
c_399_959_i 399 399_959 2.08965e-09
r_959_1519_e 959 1519 13376.4
r_959_1519_i 959_1519 1519 93218.1
c_959_1519_i 959 959_1519 2.08965e-09
r_1519_2079_e 1519 2079 836.944
r_1519_2079_i 1519_2079 2079 4256.89
c_1519_2079_i 1519 1519_2079 4.67522e-10
r_2079_2639_e 2079 2639 836.944
r_2079_2639_i 2079_2639 2639 4256.89
c_2079_2639_i 2079 2079_2639 4.67522e-10
r_2639_3199_e 2639 3199 836.944
r_2639_3199_i 2639_3199 3199 4256.89
c_2639_3199_i 2639 2639_3199 4.67522e-10
r_3199_3759_e 3199 3759 13758.3
r_3199_3759_i 3199_3759 3759 95645.6
c_3199_3759_i 3199 3199_3759 9.36084e-12
r_400_960_e 400 960 13376.4
r_400_960_i 400_960 960 93218.1
c_400_960_i 400 400_960 2.08965e-09
r_960_1520_e 960 1520 13376.4
r_960_1520_i 960_1520 1520 93218.1
c_960_1520_i 960 960_1520 2.08965e-09
r_1520_2080_e 1520 2080 836.944
r_1520_2080_i 1520_2080 2080 4256.89
c_1520_2080_i 1520 1520_2080 4.67522e-10
r_2080_2640_e 2080 2640 836.944
r_2080_2640_i 2080_2640 2640 4256.89
c_2080_2640_i 2080 2080_2640 4.67522e-10
r_2640_3200_e 2640 3200 836.944
r_2640_3200_i 2640_3200 3200 4256.89
c_2640_3200_i 2640 2640_3200 4.67522e-10
r_3200_3760_e 3200 3760 13758.3
r_3200_3760_i 3200_3760 3760 95645.6
c_3200_3760_i 3200 3200_3760 9.36084e-12
r_401_961_e 401 961 13376.4
r_401_961_i 401_961 961 93218.1
c_401_961_i 401 401_961 2.08965e-09
r_961_1521_e 961 1521 13376.4
r_961_1521_i 961_1521 1521 93218.1
c_961_1521_i 961 961_1521 2.08965e-09
r_1521_2081_e 1521 2081 13376.4
r_1521_2081_i 1521_2081 2081 93218.1
c_1521_2081_i 1521 1521_2081 2.08965e-09
r_2081_2641_e 2081 2641 13376.4
r_2081_2641_i 2081_2641 2641 93218.1
c_2081_2641_i 2081 2081_2641 2.08965e-09
r_2641_3201_e 2641 3201 13376.4
r_2641_3201_i 2641_3201 3201 93218.1
c_2641_3201_i 2641 2641_3201 2.08965e-09
r_3201_3761_e 3201 3761 13376.4
r_3201_3761_i 3201_3761 3761 93218.1
c_3201_3761_i 3201 3201_3761 2.08965e-09
r_402_962_e 402 962 13376.4
r_402_962_i 402_962 962 93218.1
c_402_962_i 402 402_962 2.08965e-09
r_962_1522_e 962 1522 13376.4
r_962_1522_i 962_1522 1522 93218.1
c_962_1522_i 962 962_1522 2.08965e-09
r_1522_2082_e 1522 2082 13376.4
r_1522_2082_i 1522_2082 2082 93218.1
c_1522_2082_i 1522 1522_2082 2.08965e-09
r_2082_2642_e 2082 2642 13376.4
r_2082_2642_i 2082_2642 2642 93218.1
c_2082_2642_i 2082 2082_2642 2.08965e-09
r_2642_3202_e 2642 3202 13376.4
r_2642_3202_i 2642_3202 3202 93218.1
c_2642_3202_i 2642 2642_3202 2.08965e-09
r_3202_3762_e 3202 3762 13376.4
r_3202_3762_i 3202_3762 3762 93218.1
c_3202_3762_i 3202 3202_3762 2.08965e-09
r_403_963_e 403 963 13376.4
r_403_963_i 403_963 963 93218.1
c_403_963_i 403 403_963 2.08965e-09
r_963_1523_e 963 1523 13376.4
r_963_1523_i 963_1523 1523 93218.1
c_963_1523_i 963 963_1523 2.08965e-09
r_1523_2083_e 1523 2083 836.944
r_1523_2083_i 1523_2083 2083 4256.89
c_1523_2083_i 1523 1523_2083 4.67522e-10
r_2083_2643_e 2083 2643 836.944
r_2083_2643_i 2083_2643 2643 4256.89
c_2083_2643_i 2083 2083_2643 4.67522e-10
r_2643_3203_e 2643 3203 836.944
r_2643_3203_i 2643_3203 3203 4256.89
c_2643_3203_i 2643 2643_3203 4.67522e-10
r_3203_3763_e 3203 3763 836.944
r_3203_3763_i 3203_3763 3763 4256.89
c_3203_3763_i 3203 3203_3763 4.67522e-10
r_404_964_e 404 964 13376.4
r_404_964_i 404_964 964 93218.1
c_404_964_i 404 404_964 2.08965e-09
r_964_1524_e 964 1524 13376.4
r_964_1524_i 964_1524 1524 93218.1
c_964_1524_i 964 964_1524 2.08965e-09
r_1524_2084_e 1524 2084 836.944
r_1524_2084_i 1524_2084 2084 4256.89
c_1524_2084_i 1524 1524_2084 4.67522e-10
r_2084_2644_e 2084 2644 836.944
r_2084_2644_i 2084_2644 2644 4256.89
c_2084_2644_i 2084 2084_2644 4.67522e-10
r_2644_3204_e 2644 3204 836.944
r_2644_3204_i 2644_3204 3204 4256.89
c_2644_3204_i 2644 2644_3204 4.67522e-10
r_3204_3764_e 3204 3764 13758.3
r_3204_3764_i 3204_3764 3764 95645.6
c_3204_3764_i 3204 3204_3764 9.36084e-12
r_405_965_e 405 965 13376.4
r_405_965_i 405_965 965 93218.1
c_405_965_i 405 405_965 2.08965e-09
r_965_1525_e 965 1525 13376.4
r_965_1525_i 965_1525 1525 93218.1
c_965_1525_i 965 965_1525 2.08965e-09
r_1525_2085_e 1525 2085 836.944
r_1525_2085_i 1525_2085 2085 4256.89
c_1525_2085_i 1525 1525_2085 4.67522e-10
r_2085_2645_e 2085 2645 836.944
r_2085_2645_i 2085_2645 2645 4256.89
c_2085_2645_i 2085 2085_2645 4.67522e-10
r_2645_3205_e 2645 3205 836.944
r_2645_3205_i 2645_3205 3205 4256.89
c_2645_3205_i 2645 2645_3205 4.67522e-10
r_3205_3765_e 3205 3765 13758.3
r_3205_3765_i 3205_3765 3765 95645.6
c_3205_3765_i 3205 3205_3765 9.36084e-12
r_406_966_e 406 966 13376.4
r_406_966_i 406_966 966 93218.1
c_406_966_i 406 406_966 2.08965e-09
r_966_1526_e 966 1526 13376.4
r_966_1526_i 966_1526 1526 93218.1
c_966_1526_i 966 966_1526 2.08965e-09
r_1526_2086_e 1526 2086 836.944
r_1526_2086_i 1526_2086 2086 4256.89
c_1526_2086_i 1526 1526_2086 4.67522e-10
r_2086_2646_e 2086 2646 836.944
r_2086_2646_i 2086_2646 2646 4256.89
c_2086_2646_i 2086 2086_2646 4.67522e-10
r_2646_3206_e 2646 3206 836.944
r_2646_3206_i 2646_3206 3206 4256.89
c_2646_3206_i 2646 2646_3206 4.67522e-10
r_3206_3766_e 3206 3766 13758.3
r_3206_3766_i 3206_3766 3766 95645.6
c_3206_3766_i 3206 3206_3766 9.36084e-12
r_407_967_e 407 967 13376.4
r_407_967_i 407_967 967 93218.1
c_407_967_i 407 407_967 2.08965e-09
r_967_1527_e 967 1527 13376.4
r_967_1527_i 967_1527 1527 93218.1
c_967_1527_i 967 967_1527 2.08965e-09
r_1527_2087_e 1527 2087 836.944
r_1527_2087_i 1527_2087 2087 4256.89
c_1527_2087_i 1527 1527_2087 4.67522e-10
r_2087_2647_e 2087 2647 836.944
r_2087_2647_i 2087_2647 2647 4256.89
c_2087_2647_i 2087 2087_2647 4.67522e-10
r_2647_3207_e 2647 3207 836.944
r_2647_3207_i 2647_3207 3207 4256.89
c_2647_3207_i 2647 2647_3207 4.67522e-10
r_3207_3767_e 3207 3767 13758.3
r_3207_3767_i 3207_3767 3767 95645.6
c_3207_3767_i 3207 3207_3767 9.36084e-12
r_408_968_e 408 968 13376.4
r_408_968_i 408_968 968 93218.1
c_408_968_i 408 408_968 2.08965e-09
r_968_1528_e 968 1528 13376.4
r_968_1528_i 968_1528 1528 93218.1
c_968_1528_i 968 968_1528 2.08965e-09
r_1528_2088_e 1528 2088 836.944
r_1528_2088_i 1528_2088 2088 4256.89
c_1528_2088_i 1528 1528_2088 4.67522e-10
r_2088_2648_e 2088 2648 836.944
r_2088_2648_i 2088_2648 2648 4256.89
c_2088_2648_i 2088 2088_2648 4.67522e-10
r_2648_3208_e 2648 3208 836.944
r_2648_3208_i 2648_3208 3208 4256.89
c_2648_3208_i 2648 2648_3208 4.67522e-10
r_3208_3768_e 3208 3768 13758.3
r_3208_3768_i 3208_3768 3768 95645.6
c_3208_3768_i 3208 3208_3768 9.36084e-12
r_409_969_e 409 969 13376.4
r_409_969_i 409_969 969 93218.1
c_409_969_i 409 409_969 2.08965e-09
r_969_1529_e 969 1529 13376.4
r_969_1529_i 969_1529 1529 93218.1
c_969_1529_i 969 969_1529 2.08965e-09
r_1529_2089_e 1529 2089 836.944
r_1529_2089_i 1529_2089 2089 4256.89
c_1529_2089_i 1529 1529_2089 4.67522e-10
r_2089_2649_e 2089 2649 836.944
r_2089_2649_i 2089_2649 2649 4256.89
c_2089_2649_i 2089 2089_2649 4.67522e-10
r_2649_3209_e 2649 3209 836.944
r_2649_3209_i 2649_3209 3209 4256.89
c_2649_3209_i 2649 2649_3209 4.67522e-10
r_3209_3769_e 3209 3769 13758.3
r_3209_3769_i 3209_3769 3769 95645.6
c_3209_3769_i 3209 3209_3769 9.36084e-12
r_410_970_e 410 970 13376.4
r_410_970_i 410_970 970 93218.1
c_410_970_i 410 410_970 2.08965e-09
r_970_1530_e 970 1530 13376.4
r_970_1530_i 970_1530 1530 93218.1
c_970_1530_i 970 970_1530 2.08965e-09
r_1530_2090_e 1530 2090 836.944
r_1530_2090_i 1530_2090 2090 4256.89
c_1530_2090_i 1530 1530_2090 4.67522e-10
r_2090_2650_e 2090 2650 836.944
r_2090_2650_i 2090_2650 2650 4256.89
c_2090_2650_i 2090 2090_2650 4.67522e-10
r_2650_3210_e 2650 3210 836.944
r_2650_3210_i 2650_3210 3210 4256.89
c_2650_3210_i 2650 2650_3210 4.67522e-10
r_3210_3770_e 3210 3770 13758.3
r_3210_3770_i 3210_3770 3770 95645.6
c_3210_3770_i 3210 3210_3770 9.36084e-12
r_411_971_e 411 971 13376.4
r_411_971_i 411_971 971 93218.1
c_411_971_i 411 411_971 2.08965e-09
r_971_1531_e 971 1531 396.56
r_971_1531_i 971_1531 1531 1004.92
c_971_1531_i 971 971_1531 1.65852e-10
r_1531_2091_e 1531 2091 836.944
r_1531_2091_i 1531_2091 2091 4256.89
c_1531_2091_i 1531 1531_2091 4.67522e-10
r_2091_2651_e 2091 2651 836.944
r_2091_2651_i 2091_2651 2651 4256.89
c_2091_2651_i 2091 2091_2651 4.67522e-10
r_2651_3211_e 2651 3211 836.944
r_2651_3211_i 2651_3211 3211 4256.89
c_2651_3211_i 2651 2651_3211 4.67522e-10
r_3211_3771_e 3211 3771 13758.3
r_3211_3771_i 3211_3771 3771 95645.6
c_3211_3771_i 3211 3211_3771 9.36084e-12
r_412_972_e 412 972 13376.4
r_412_972_i 412_972 972 93218.1
c_412_972_i 412 412_972 2.08965e-09
r_972_1532_e 972 1532 396.56
r_972_1532_i 972_1532 1532 1004.92
c_972_1532_i 972 972_1532 1.65852e-10
r_1532_2092_e 1532 2092 836.944
r_1532_2092_i 1532_2092 2092 4256.89
c_1532_2092_i 1532 1532_2092 4.67522e-10
r_2092_2652_e 2092 2652 836.944
r_2092_2652_i 2092_2652 2652 4256.89
c_2092_2652_i 2092 2092_2652 4.67522e-10
r_2652_3212_e 2652 3212 836.944
r_2652_3212_i 2652_3212 3212 4256.89
c_2652_3212_i 2652 2652_3212 4.67522e-10
r_3212_3772_e 3212 3772 13758.3
r_3212_3772_i 3212_3772 3772 95645.6
c_3212_3772_i 3212 3212_3772 9.36084e-12
r_413_973_e 413 973 13376.4
r_413_973_i 413_973 973 93218.1
c_413_973_i 413 413_973 2.08965e-09
r_973_1533_e 973 1533 13376.4
r_973_1533_i 973_1533 1533 93218.1
c_973_1533_i 973 973_1533 2.08965e-09
r_1533_2093_e 1533 2093 836.944
r_1533_2093_i 1533_2093 2093 4256.89
c_1533_2093_i 1533 1533_2093 4.67522e-10
r_2093_2653_e 2093 2653 836.944
r_2093_2653_i 2093_2653 2653 4256.89
c_2093_2653_i 2093 2093_2653 4.67522e-10
r_2653_3213_e 2653 3213 836.944
r_2653_3213_i 2653_3213 3213 4256.89
c_2653_3213_i 2653 2653_3213 4.67522e-10
r_3213_3773_e 3213 3773 13758.3
r_3213_3773_i 3213_3773 3773 95645.6
c_3213_3773_i 3213 3213_3773 9.36084e-12
r_414_974_e 414 974 13376.4
r_414_974_i 414_974 974 93218.1
c_414_974_i 414 414_974 2.08965e-09
r_974_1534_e 974 1534 13376.4
r_974_1534_i 974_1534 1534 93218.1
c_974_1534_i 974 974_1534 2.08965e-09
r_1534_2094_e 1534 2094 836.944
r_1534_2094_i 1534_2094 2094 4256.89
c_1534_2094_i 1534 1534_2094 4.67522e-10
r_2094_2654_e 2094 2654 836.944
r_2094_2654_i 2094_2654 2654 4256.89
c_2094_2654_i 2094 2094_2654 4.67522e-10
r_2654_3214_e 2654 3214 836.944
r_2654_3214_i 2654_3214 3214 4256.89
c_2654_3214_i 2654 2654_3214 4.67522e-10
r_3214_3774_e 3214 3774 13758.3
r_3214_3774_i 3214_3774 3774 95645.6
c_3214_3774_i 3214 3214_3774 9.36084e-12
r_415_975_e 415 975 13376.4
r_415_975_i 415_975 975 93218.1
c_415_975_i 415 415_975 2.08965e-09
r_975_1535_e 975 1535 13376.4
r_975_1535_i 975_1535 1535 93218.1
c_975_1535_i 975 975_1535 2.08965e-09
r_1535_2095_e 1535 2095 836.944
r_1535_2095_i 1535_2095 2095 4256.89
c_1535_2095_i 1535 1535_2095 4.67522e-10
r_2095_2655_e 2095 2655 836.944
r_2095_2655_i 2095_2655 2655 4256.89
c_2095_2655_i 2095 2095_2655 4.67522e-10
r_2655_3215_e 2655 3215 836.944
r_2655_3215_i 2655_3215 3215 4256.89
c_2655_3215_i 2655 2655_3215 4.67522e-10
r_3215_3775_e 3215 3775 13758.3
r_3215_3775_i 3215_3775 3775 95645.6
c_3215_3775_i 3215 3215_3775 9.36084e-12
r_416_976_e 416 976 13376.4
r_416_976_i 416_976 976 93218.1
c_416_976_i 416 416_976 2.08965e-09
r_976_1536_e 976 1536 13376.4
r_976_1536_i 976_1536 1536 93218.1
c_976_1536_i 976 976_1536 2.08965e-09
r_1536_2096_e 1536 2096 836.944
r_1536_2096_i 1536_2096 2096 4256.89
c_1536_2096_i 1536 1536_2096 4.67522e-10
r_2096_2656_e 2096 2656 836.944
r_2096_2656_i 2096_2656 2656 4256.89
c_2096_2656_i 2096 2096_2656 4.67522e-10
r_2656_3216_e 2656 3216 836.944
r_2656_3216_i 2656_3216 3216 4256.89
c_2656_3216_i 2656 2656_3216 4.67522e-10
r_3216_3776_e 3216 3776 13758.3
r_3216_3776_i 3216_3776 3776 95645.6
c_3216_3776_i 3216 3216_3776 9.36084e-12
r_417_977_e 417 977 13376.4
r_417_977_i 417_977 977 93218.1
c_417_977_i 417 417_977 2.08965e-09
r_977_1537_e 977 1537 13376.4
r_977_1537_i 977_1537 1537 93218.1
c_977_1537_i 977 977_1537 2.08965e-09
r_1537_2097_e 1537 2097 13376.4
r_1537_2097_i 1537_2097 2097 93218.1
c_1537_2097_i 1537 1537_2097 2.08965e-09
r_2097_2657_e 2097 2657 13376.4
r_2097_2657_i 2097_2657 2657 93218.1
c_2097_2657_i 2097 2097_2657 2.08965e-09
r_2657_3217_e 2657 3217 13376.4
r_2657_3217_i 2657_3217 3217 93218.1
c_2657_3217_i 2657 2657_3217 2.08965e-09
r_3217_3777_e 3217 3777 13376.4
r_3217_3777_i 3217_3777 3777 93218.1
c_3217_3777_i 3217 3217_3777 2.08965e-09
r_418_978_e 418 978 13376.4
r_418_978_i 418_978 978 93218.1
c_418_978_i 418 418_978 2.08965e-09
r_978_1538_e 978 1538 13376.4
r_978_1538_i 978_1538 1538 93218.1
c_978_1538_i 978 978_1538 2.08965e-09
r_1538_2098_e 1538 2098 13376.4
r_1538_2098_i 1538_2098 2098 93218.1
c_1538_2098_i 1538 1538_2098 2.08965e-09
r_2098_2658_e 2098 2658 13376.4
r_2098_2658_i 2098_2658 2658 93218.1
c_2098_2658_i 2098 2098_2658 2.08965e-09
r_2658_3218_e 2658 3218 13376.4
r_2658_3218_i 2658_3218 3218 93218.1
c_2658_3218_i 2658 2658_3218 2.08965e-09
r_3218_3778_e 3218 3778 13376.4
r_3218_3778_i 3218_3778 3778 93218.1
c_3218_3778_i 3218 3218_3778 2.08965e-09
r_419_979_e 419 979 13376.4
r_419_979_i 419_979 979 93218.1
c_419_979_i 419 419_979 2.08965e-09
r_979_1539_e 979 1539 13376.4
r_979_1539_i 979_1539 1539 93218.1
c_979_1539_i 979 979_1539 2.08965e-09
r_1539_2099_e 1539 2099 836.944
r_1539_2099_i 1539_2099 2099 4256.89
c_1539_2099_i 1539 1539_2099 4.67522e-10
r_2099_2659_e 2099 2659 836.944
r_2099_2659_i 2099_2659 2659 4256.89
c_2099_2659_i 2099 2099_2659 4.67522e-10
r_2659_3219_e 2659 3219 836.944
r_2659_3219_i 2659_3219 3219 4256.89
c_2659_3219_i 2659 2659_3219 4.67522e-10
r_3219_3779_e 3219 3779 836.944
r_3219_3779_i 3219_3779 3779 4256.89
c_3219_3779_i 3219 3219_3779 4.67522e-10
r_420_980_e 420 980 13376.4
r_420_980_i 420_980 980 93218.1
c_420_980_i 420 420_980 2.08965e-09
r_980_1540_e 980 1540 13376.4
r_980_1540_i 980_1540 1540 93218.1
c_980_1540_i 980 980_1540 2.08965e-09
r_1540_2100_e 1540 2100 836.944
r_1540_2100_i 1540_2100 2100 4256.89
c_1540_2100_i 1540 1540_2100 4.67522e-10
r_2100_2660_e 2100 2660 836.944
r_2100_2660_i 2100_2660 2660 4256.89
c_2100_2660_i 2100 2100_2660 4.67522e-10
r_2660_3220_e 2660 3220 836.944
r_2660_3220_i 2660_3220 3220 4256.89
c_2660_3220_i 2660 2660_3220 4.67522e-10
r_3220_3780_e 3220 3780 13758.3
r_3220_3780_i 3220_3780 3780 95645.6
c_3220_3780_i 3220 3220_3780 9.36084e-12
r_421_981_e 421 981 13376.4
r_421_981_i 421_981 981 93218.1
c_421_981_i 421 421_981 2.08965e-09
r_981_1541_e 981 1541 13376.4
r_981_1541_i 981_1541 1541 93218.1
c_981_1541_i 981 981_1541 2.08965e-09
r_1541_2101_e 1541 2101 836.944
r_1541_2101_i 1541_2101 2101 4256.89
c_1541_2101_i 1541 1541_2101 4.67522e-10
r_2101_2661_e 2101 2661 836.944
r_2101_2661_i 2101_2661 2661 4256.89
c_2101_2661_i 2101 2101_2661 4.67522e-10
r_2661_3221_e 2661 3221 836.944
r_2661_3221_i 2661_3221 3221 4256.89
c_2661_3221_i 2661 2661_3221 4.67522e-10
r_3221_3781_e 3221 3781 13758.3
r_3221_3781_i 3221_3781 3781 95645.6
c_3221_3781_i 3221 3221_3781 9.36084e-12
r_422_982_e 422 982 13376.4
r_422_982_i 422_982 982 93218.1
c_422_982_i 422 422_982 2.08965e-09
r_982_1542_e 982 1542 13376.4
r_982_1542_i 982_1542 1542 93218.1
c_982_1542_i 982 982_1542 2.08965e-09
r_1542_2102_e 1542 2102 836.944
r_1542_2102_i 1542_2102 2102 4256.89
c_1542_2102_i 1542 1542_2102 4.67522e-10
r_2102_2662_e 2102 2662 836.944
r_2102_2662_i 2102_2662 2662 4256.89
c_2102_2662_i 2102 2102_2662 4.67522e-10
r_2662_3222_e 2662 3222 836.944
r_2662_3222_i 2662_3222 3222 4256.89
c_2662_3222_i 2662 2662_3222 4.67522e-10
r_3222_3782_e 3222 3782 13758.3
r_3222_3782_i 3222_3782 3782 95645.6
c_3222_3782_i 3222 3222_3782 9.36084e-12
r_423_983_e 423 983 13376.4
r_423_983_i 423_983 983 93218.1
c_423_983_i 423 423_983 2.08965e-09
r_983_1543_e 983 1543 13376.4
r_983_1543_i 983_1543 1543 93218.1
c_983_1543_i 983 983_1543 2.08965e-09
r_1543_2103_e 1543 2103 836.944
r_1543_2103_i 1543_2103 2103 4256.89
c_1543_2103_i 1543 1543_2103 4.67522e-10
r_2103_2663_e 2103 2663 836.944
r_2103_2663_i 2103_2663 2663 4256.89
c_2103_2663_i 2103 2103_2663 4.67522e-10
r_2663_3223_e 2663 3223 836.944
r_2663_3223_i 2663_3223 3223 4256.89
c_2663_3223_i 2663 2663_3223 4.67522e-10
r_3223_3783_e 3223 3783 13758.3
r_3223_3783_i 3223_3783 3783 95645.6
c_3223_3783_i 3223 3223_3783 9.36084e-12
r_424_984_e 424 984 13376.4
r_424_984_i 424_984 984 93218.1
c_424_984_i 424 424_984 2.08965e-09
r_984_1544_e 984 1544 13376.4
r_984_1544_i 984_1544 1544 93218.1
c_984_1544_i 984 984_1544 2.08965e-09
r_1544_2104_e 1544 2104 836.944
r_1544_2104_i 1544_2104 2104 4256.89
c_1544_2104_i 1544 1544_2104 4.67522e-10
r_2104_2664_e 2104 2664 836.944
r_2104_2664_i 2104_2664 2664 4256.89
c_2104_2664_i 2104 2104_2664 4.67522e-10
r_2664_3224_e 2664 3224 836.944
r_2664_3224_i 2664_3224 3224 4256.89
c_2664_3224_i 2664 2664_3224 4.67522e-10
r_3224_3784_e 3224 3784 13758.3
r_3224_3784_i 3224_3784 3784 95645.6
c_3224_3784_i 3224 3224_3784 9.36084e-12
r_425_985_e 425 985 13376.4
r_425_985_i 425_985 985 93218.1
c_425_985_i 425 425_985 2.08965e-09
r_985_1545_e 985 1545 13376.4
r_985_1545_i 985_1545 1545 93218.1
c_985_1545_i 985 985_1545 2.08965e-09
r_1545_2105_e 1545 2105 836.944
r_1545_2105_i 1545_2105 2105 4256.89
c_1545_2105_i 1545 1545_2105 4.67522e-10
r_2105_2665_e 2105 2665 836.944
r_2105_2665_i 2105_2665 2665 4256.89
c_2105_2665_i 2105 2105_2665 4.67522e-10
r_2665_3225_e 2665 3225 836.944
r_2665_3225_i 2665_3225 3225 4256.89
c_2665_3225_i 2665 2665_3225 4.67522e-10
r_3225_3785_e 3225 3785 13758.3
r_3225_3785_i 3225_3785 3785 95645.6
c_3225_3785_i 3225 3225_3785 9.36084e-12
r_426_986_e 426 986 13376.4
r_426_986_i 426_986 986 93218.1
c_426_986_i 426 426_986 2.08965e-09
r_986_1546_e 986 1546 13376.4
r_986_1546_i 986_1546 1546 93218.1
c_986_1546_i 986 986_1546 2.08965e-09
r_1546_2106_e 1546 2106 836.944
r_1546_2106_i 1546_2106 2106 4256.89
c_1546_2106_i 1546 1546_2106 4.67522e-10
r_2106_2666_e 2106 2666 836.944
r_2106_2666_i 2106_2666 2666 4256.89
c_2106_2666_i 2106 2106_2666 4.67522e-10
r_2666_3226_e 2666 3226 836.944
r_2666_3226_i 2666_3226 3226 4256.89
c_2666_3226_i 2666 2666_3226 4.67522e-10
r_3226_3786_e 3226 3786 13758.3
r_3226_3786_i 3226_3786 3786 95645.6
c_3226_3786_i 3226 3226_3786 9.36084e-12
r_427_987_e 427 987 13376.4
r_427_987_i 427_987 987 93218.1
c_427_987_i 427 427_987 2.08965e-09
r_987_1547_e 987 1547 396.551
r_987_1547_i 987_1547 1547 1004.9
c_987_1547_i 987 987_1547 1.65856e-10
r_1547_2107_e 1547 2107 836.944
r_1547_2107_i 1547_2107 2107 4256.89
c_1547_2107_i 1547 1547_2107 4.67522e-10
r_2107_2667_e 2107 2667 836.944
r_2107_2667_i 2107_2667 2667 4256.89
c_2107_2667_i 2107 2107_2667 4.67522e-10
r_2667_3227_e 2667 3227 836.944
r_2667_3227_i 2667_3227 3227 4256.89
c_2667_3227_i 2667 2667_3227 4.67522e-10
r_3227_3787_e 3227 3787 13758.3
r_3227_3787_i 3227_3787 3787 95645.6
c_3227_3787_i 3227 3227_3787 9.36084e-12
r_428_988_e 428 988 13376.4
r_428_988_i 428_988 988 93218.1
c_428_988_i 428 428_988 2.08965e-09
r_988_1548_e 988 1548 396.551
r_988_1548_i 988_1548 1548 1004.9
c_988_1548_i 988 988_1548 1.65856e-10
r_1548_2108_e 1548 2108 836.944
r_1548_2108_i 1548_2108 2108 4256.89
c_1548_2108_i 1548 1548_2108 4.67522e-10
r_2108_2668_e 2108 2668 836.944
r_2108_2668_i 2108_2668 2668 4256.89
c_2108_2668_i 2108 2108_2668 4.67522e-10
r_2668_3228_e 2668 3228 836.944
r_2668_3228_i 2668_3228 3228 4256.89
c_2668_3228_i 2668 2668_3228 4.67522e-10
r_3228_3788_e 3228 3788 13758.3
r_3228_3788_i 3228_3788 3788 95645.6
c_3228_3788_i 3228 3228_3788 9.36084e-12
r_429_989_e 429 989 13376.4
r_429_989_i 429_989 989 93218.1
c_429_989_i 429 429_989 2.08965e-09
r_989_1549_e 989 1549 13376.4
r_989_1549_i 989_1549 1549 93218.1
c_989_1549_i 989 989_1549 2.08965e-09
r_1549_2109_e 1549 2109 836.944
r_1549_2109_i 1549_2109 2109 4256.89
c_1549_2109_i 1549 1549_2109 4.67522e-10
r_2109_2669_e 2109 2669 836.944
r_2109_2669_i 2109_2669 2669 4256.89
c_2109_2669_i 2109 2109_2669 4.67522e-10
r_2669_3229_e 2669 3229 836.944
r_2669_3229_i 2669_3229 3229 4256.89
c_2669_3229_i 2669 2669_3229 4.67522e-10
r_3229_3789_e 3229 3789 13758.3
r_3229_3789_i 3229_3789 3789 95645.6
c_3229_3789_i 3229 3229_3789 9.36084e-12
r_430_990_e 430 990 13376.4
r_430_990_i 430_990 990 93218.1
c_430_990_i 430 430_990 2.08965e-09
r_990_1550_e 990 1550 13376.4
r_990_1550_i 990_1550 1550 93218.1
c_990_1550_i 990 990_1550 2.08965e-09
r_1550_2110_e 1550 2110 836.944
r_1550_2110_i 1550_2110 2110 4256.89
c_1550_2110_i 1550 1550_2110 4.67522e-10
r_2110_2670_e 2110 2670 836.944
r_2110_2670_i 2110_2670 2670 4256.89
c_2110_2670_i 2110 2110_2670 4.67522e-10
r_2670_3230_e 2670 3230 836.944
r_2670_3230_i 2670_3230 3230 4256.89
c_2670_3230_i 2670 2670_3230 4.67522e-10
r_3230_3790_e 3230 3790 13758.3
r_3230_3790_i 3230_3790 3790 95645.6
c_3230_3790_i 3230 3230_3790 9.36084e-12
r_431_991_e 431 991 13376.4
r_431_991_i 431_991 991 93218.1
c_431_991_i 431 431_991 2.08965e-09
r_991_1551_e 991 1551 13376.4
r_991_1551_i 991_1551 1551 93218.1
c_991_1551_i 991 991_1551 2.08965e-09
r_1551_2111_e 1551 2111 836.944
r_1551_2111_i 1551_2111 2111 4256.89
c_1551_2111_i 1551 1551_2111 4.67522e-10
r_2111_2671_e 2111 2671 836.944
r_2111_2671_i 2111_2671 2671 4256.89
c_2111_2671_i 2111 2111_2671 4.67522e-10
r_2671_3231_e 2671 3231 836.944
r_2671_3231_i 2671_3231 3231 4256.89
c_2671_3231_i 2671 2671_3231 4.67522e-10
r_3231_3791_e 3231 3791 13758.3
r_3231_3791_i 3231_3791 3791 95645.6
c_3231_3791_i 3231 3231_3791 9.36084e-12
r_432_992_e 432 992 13376.4
r_432_992_i 432_992 992 93218.1
c_432_992_i 432 432_992 2.08965e-09
r_992_1552_e 992 1552 13376.4
r_992_1552_i 992_1552 1552 93218.1
c_992_1552_i 992 992_1552 2.08965e-09
r_1552_2112_e 1552 2112 836.944
r_1552_2112_i 1552_2112 2112 4256.89
c_1552_2112_i 1552 1552_2112 4.67522e-10
r_2112_2672_e 2112 2672 836.944
r_2112_2672_i 2112_2672 2672 4256.89
c_2112_2672_i 2112 2112_2672 4.67522e-10
r_2672_3232_e 2672 3232 836.944
r_2672_3232_i 2672_3232 3232 4256.89
c_2672_3232_i 2672 2672_3232 4.67522e-10
r_3232_3792_e 3232 3792 13758.3
r_3232_3792_i 3232_3792 3792 95645.6
c_3232_3792_i 3232 3232_3792 9.36084e-12
r_433_993_e 433 993 13376.4
r_433_993_i 433_993 993 93218.1
c_433_993_i 433 433_993 2.08965e-09
r_993_1553_e 993 1553 13376.4
r_993_1553_i 993_1553 1553 93218.1
c_993_1553_i 993 993_1553 2.08965e-09
r_1553_2113_e 1553 2113 13376.4
r_1553_2113_i 1553_2113 2113 93218.1
c_1553_2113_i 1553 1553_2113 2.08965e-09
r_2113_2673_e 2113 2673 13376.4
r_2113_2673_i 2113_2673 2673 93218.1
c_2113_2673_i 2113 2113_2673 2.08965e-09
r_2673_3233_e 2673 3233 13376.4
r_2673_3233_i 2673_3233 3233 93218.1
c_2673_3233_i 2673 2673_3233 2.08965e-09
r_3233_3793_e 3233 3793 13376.4
r_3233_3793_i 3233_3793 3793 93218.1
c_3233_3793_i 3233 3233_3793 2.08965e-09
r_434_994_e 434 994 13376.4
r_434_994_i 434_994 994 93218.1
c_434_994_i 434 434_994 2.08965e-09
r_994_1554_e 994 1554 13376.4
r_994_1554_i 994_1554 1554 93218.1
c_994_1554_i 994 994_1554 2.08965e-09
r_1554_2114_e 1554 2114 13376.4
r_1554_2114_i 1554_2114 2114 93218.1
c_1554_2114_i 1554 1554_2114 2.08965e-09
r_2114_2674_e 2114 2674 13376.4
r_2114_2674_i 2114_2674 2674 93218.1
c_2114_2674_i 2114 2114_2674 2.08965e-09
r_2674_3234_e 2674 3234 13376.4
r_2674_3234_i 2674_3234 3234 93218.1
c_2674_3234_i 2674 2674_3234 2.08965e-09
r_3234_3794_e 3234 3794 13376.4
r_3234_3794_i 3234_3794 3794 93218.1
c_3234_3794_i 3234 3234_3794 2.08965e-09
r_435_995_e 435 995 13376.4
r_435_995_i 435_995 995 93218.1
c_435_995_i 435 435_995 2.08965e-09
r_995_1555_e 995 1555 13376.4
r_995_1555_i 995_1555 1555 93218.1
c_995_1555_i 995 995_1555 2.08965e-09
r_1555_2115_e 1555 2115 836.944
r_1555_2115_i 1555_2115 2115 4256.89
c_1555_2115_i 1555 1555_2115 4.67522e-10
r_2115_2675_e 2115 2675 836.944
r_2115_2675_i 2115_2675 2675 4256.89
c_2115_2675_i 2115 2115_2675 4.67522e-10
r_2675_3235_e 2675 3235 836.944
r_2675_3235_i 2675_3235 3235 4256.89
c_2675_3235_i 2675 2675_3235 4.67522e-10
r_3235_3795_e 3235 3795 836.944
r_3235_3795_i 3235_3795 3795 4256.89
c_3235_3795_i 3235 3235_3795 4.67522e-10
r_436_996_e 436 996 13376.4
r_436_996_i 436_996 996 93218.1
c_436_996_i 436 436_996 2.08965e-09
r_996_1556_e 996 1556 13376.4
r_996_1556_i 996_1556 1556 93218.1
c_996_1556_i 996 996_1556 2.08965e-09
r_1556_2116_e 1556 2116 836.944
r_1556_2116_i 1556_2116 2116 4256.89
c_1556_2116_i 1556 1556_2116 4.67522e-10
r_2116_2676_e 2116 2676 836.944
r_2116_2676_i 2116_2676 2676 4256.89
c_2116_2676_i 2116 2116_2676 4.67522e-10
r_2676_3236_e 2676 3236 836.944
r_2676_3236_i 2676_3236 3236 4256.89
c_2676_3236_i 2676 2676_3236 4.67522e-10
r_3236_3796_e 3236 3796 13758.3
r_3236_3796_i 3236_3796 3796 95645.6
c_3236_3796_i 3236 3236_3796 9.36084e-12
r_437_997_e 437 997 13376.4
r_437_997_i 437_997 997 93218.1
c_437_997_i 437 437_997 2.08965e-09
r_997_1557_e 997 1557 13376.4
r_997_1557_i 997_1557 1557 93218.1
c_997_1557_i 997 997_1557 2.08965e-09
r_1557_2117_e 1557 2117 836.944
r_1557_2117_i 1557_2117 2117 4256.89
c_1557_2117_i 1557 1557_2117 4.67522e-10
r_2117_2677_e 2117 2677 836.944
r_2117_2677_i 2117_2677 2677 4256.89
c_2117_2677_i 2117 2117_2677 4.67522e-10
r_2677_3237_e 2677 3237 836.944
r_2677_3237_i 2677_3237 3237 4256.89
c_2677_3237_i 2677 2677_3237 4.67522e-10
r_3237_3797_e 3237 3797 13758.3
r_3237_3797_i 3237_3797 3797 95645.6
c_3237_3797_i 3237 3237_3797 9.36084e-12
r_438_998_e 438 998 13376.4
r_438_998_i 438_998 998 93218.1
c_438_998_i 438 438_998 2.08965e-09
r_998_1558_e 998 1558 13376.4
r_998_1558_i 998_1558 1558 93218.1
c_998_1558_i 998 998_1558 2.08965e-09
r_1558_2118_e 1558 2118 836.944
r_1558_2118_i 1558_2118 2118 4256.89
c_1558_2118_i 1558 1558_2118 4.67522e-10
r_2118_2678_e 2118 2678 836.944
r_2118_2678_i 2118_2678 2678 4256.89
c_2118_2678_i 2118 2118_2678 4.67522e-10
r_2678_3238_e 2678 3238 836.944
r_2678_3238_i 2678_3238 3238 4256.89
c_2678_3238_i 2678 2678_3238 4.67522e-10
r_3238_3798_e 3238 3798 13758.3
r_3238_3798_i 3238_3798 3798 95645.6
c_3238_3798_i 3238 3238_3798 9.36084e-12
r_439_999_e 439 999 13376.4
r_439_999_i 439_999 999 93218.1
c_439_999_i 439 439_999 2.08965e-09
r_999_1559_e 999 1559 13376.4
r_999_1559_i 999_1559 1559 93218.1
c_999_1559_i 999 999_1559 2.08965e-09
r_1559_2119_e 1559 2119 836.944
r_1559_2119_i 1559_2119 2119 4256.89
c_1559_2119_i 1559 1559_2119 4.67522e-10
r_2119_2679_e 2119 2679 836.944
r_2119_2679_i 2119_2679 2679 4256.89
c_2119_2679_i 2119 2119_2679 4.67522e-10
r_2679_3239_e 2679 3239 836.944
r_2679_3239_i 2679_3239 3239 4256.89
c_2679_3239_i 2679 2679_3239 4.67522e-10
r_3239_3799_e 3239 3799 13758.3
r_3239_3799_i 3239_3799 3799 95645.6
c_3239_3799_i 3239 3239_3799 9.36084e-12
r_440_1000_e 440 1000 13376.4
r_440_1000_i 440_1000 1000 93218.1
c_440_1000_i 440 440_1000 2.08965e-09
r_1000_1560_e 1000 1560 13376.4
r_1000_1560_i 1000_1560 1560 93218.1
c_1000_1560_i 1000 1000_1560 2.08965e-09
r_1560_2120_e 1560 2120 836.944
r_1560_2120_i 1560_2120 2120 4256.89
c_1560_2120_i 1560 1560_2120 4.67522e-10
r_2120_2680_e 2120 2680 836.944
r_2120_2680_i 2120_2680 2680 4256.89
c_2120_2680_i 2120 2120_2680 4.67522e-10
r_2680_3240_e 2680 3240 836.944
r_2680_3240_i 2680_3240 3240 4256.89
c_2680_3240_i 2680 2680_3240 4.67522e-10
r_3240_3800_e 3240 3800 13758.3
r_3240_3800_i 3240_3800 3800 95645.6
c_3240_3800_i 3240 3240_3800 9.36084e-12
r_441_1001_e 441 1001 13376.4
r_441_1001_i 441_1001 1001 93218.1
c_441_1001_i 441 441_1001 2.08965e-09
r_1001_1561_e 1001 1561 13376.4
r_1001_1561_i 1001_1561 1561 93218.1
c_1001_1561_i 1001 1001_1561 2.08965e-09
r_1561_2121_e 1561 2121 836.944
r_1561_2121_i 1561_2121 2121 4256.89
c_1561_2121_i 1561 1561_2121 4.67522e-10
r_2121_2681_e 2121 2681 836.944
r_2121_2681_i 2121_2681 2681 4256.89
c_2121_2681_i 2121 2121_2681 4.67522e-10
r_2681_3241_e 2681 3241 836.944
r_2681_3241_i 2681_3241 3241 4256.89
c_2681_3241_i 2681 2681_3241 4.67522e-10
r_3241_3801_e 3241 3801 13758.3
r_3241_3801_i 3241_3801 3801 95645.6
c_3241_3801_i 3241 3241_3801 9.36084e-12
r_442_1002_e 442 1002 13376.4
r_442_1002_i 442_1002 1002 93218.1
c_442_1002_i 442 442_1002 2.08965e-09
r_1002_1562_e 1002 1562 13376.4
r_1002_1562_i 1002_1562 1562 93218.1
c_1002_1562_i 1002 1002_1562 2.08965e-09
r_1562_2122_e 1562 2122 836.944
r_1562_2122_i 1562_2122 2122 4256.89
c_1562_2122_i 1562 1562_2122 4.67522e-10
r_2122_2682_e 2122 2682 836.944
r_2122_2682_i 2122_2682 2682 4256.89
c_2122_2682_i 2122 2122_2682 4.67522e-10
r_2682_3242_e 2682 3242 836.944
r_2682_3242_i 2682_3242 3242 4256.89
c_2682_3242_i 2682 2682_3242 4.67522e-10
r_3242_3802_e 3242 3802 13758.3
r_3242_3802_i 3242_3802 3802 95645.6
c_3242_3802_i 3242 3242_3802 9.36084e-12
r_443_1003_e 443 1003 13376.4
r_443_1003_i 443_1003 1003 93218.1
c_443_1003_i 443 443_1003 2.08965e-09
r_1003_1563_e 1003 1563 396.543
r_1003_1563_i 1003_1563 1563 1004.88
c_1003_1563_i 1003 1003_1563 1.65859e-10
r_1563_2123_e 1563 2123 836.944
r_1563_2123_i 1563_2123 2123 4256.89
c_1563_2123_i 1563 1563_2123 4.67522e-10
r_2123_2683_e 2123 2683 836.944
r_2123_2683_i 2123_2683 2683 4256.89
c_2123_2683_i 2123 2123_2683 4.67522e-10
r_2683_3243_e 2683 3243 836.944
r_2683_3243_i 2683_3243 3243 4256.89
c_2683_3243_i 2683 2683_3243 4.67522e-10
r_3243_3803_e 3243 3803 13758.3
r_3243_3803_i 3243_3803 3803 95645.6
c_3243_3803_i 3243 3243_3803 9.36084e-12
r_444_1004_e 444 1004 13376.4
r_444_1004_i 444_1004 1004 93218.1
c_444_1004_i 444 444_1004 2.08965e-09
r_1004_1564_e 1004 1564 396.543
r_1004_1564_i 1004_1564 1564 1004.88
c_1004_1564_i 1004 1004_1564 1.65859e-10
r_1564_2124_e 1564 2124 836.944
r_1564_2124_i 1564_2124 2124 4256.89
c_1564_2124_i 1564 1564_2124 4.67522e-10
r_2124_2684_e 2124 2684 836.944
r_2124_2684_i 2124_2684 2684 4256.89
c_2124_2684_i 2124 2124_2684 4.67522e-10
r_2684_3244_e 2684 3244 836.944
r_2684_3244_i 2684_3244 3244 4256.89
c_2684_3244_i 2684 2684_3244 4.67522e-10
r_3244_3804_e 3244 3804 13758.3
r_3244_3804_i 3244_3804 3804 95645.6
c_3244_3804_i 3244 3244_3804 9.36084e-12
r_445_1005_e 445 1005 13376.4
r_445_1005_i 445_1005 1005 93218.1
c_445_1005_i 445 445_1005 2.08965e-09
r_1005_1565_e 1005 1565 13376.4
r_1005_1565_i 1005_1565 1565 93218.1
c_1005_1565_i 1005 1005_1565 2.08965e-09
r_1565_2125_e 1565 2125 836.944
r_1565_2125_i 1565_2125 2125 4256.89
c_1565_2125_i 1565 1565_2125 4.67522e-10
r_2125_2685_e 2125 2685 836.944
r_2125_2685_i 2125_2685 2685 4256.89
c_2125_2685_i 2125 2125_2685 4.67522e-10
r_2685_3245_e 2685 3245 836.944
r_2685_3245_i 2685_3245 3245 4256.89
c_2685_3245_i 2685 2685_3245 4.67522e-10
r_3245_3805_e 3245 3805 13758.3
r_3245_3805_i 3245_3805 3805 95645.6
c_3245_3805_i 3245 3245_3805 9.36084e-12
r_446_1006_e 446 1006 13376.4
r_446_1006_i 446_1006 1006 93218.1
c_446_1006_i 446 446_1006 2.08965e-09
r_1006_1566_e 1006 1566 13376.4
r_1006_1566_i 1006_1566 1566 93218.1
c_1006_1566_i 1006 1006_1566 2.08965e-09
r_1566_2126_e 1566 2126 836.944
r_1566_2126_i 1566_2126 2126 4256.89
c_1566_2126_i 1566 1566_2126 4.67522e-10
r_2126_2686_e 2126 2686 836.944
r_2126_2686_i 2126_2686 2686 4256.89
c_2126_2686_i 2126 2126_2686 4.67522e-10
r_2686_3246_e 2686 3246 836.944
r_2686_3246_i 2686_3246 3246 4256.89
c_2686_3246_i 2686 2686_3246 4.67522e-10
r_3246_3806_e 3246 3806 13758.3
r_3246_3806_i 3246_3806 3806 95645.6
c_3246_3806_i 3246 3246_3806 9.36084e-12
r_447_1007_e 447 1007 13376.4
r_447_1007_i 447_1007 1007 93218.1
c_447_1007_i 447 447_1007 2.08965e-09
r_1007_1567_e 1007 1567 13376.4
r_1007_1567_i 1007_1567 1567 93218.1
c_1007_1567_i 1007 1007_1567 2.08965e-09
r_1567_2127_e 1567 2127 836.944
r_1567_2127_i 1567_2127 2127 4256.89
c_1567_2127_i 1567 1567_2127 4.67522e-10
r_2127_2687_e 2127 2687 836.944
r_2127_2687_i 2127_2687 2687 4256.89
c_2127_2687_i 2127 2127_2687 4.67522e-10
r_2687_3247_e 2687 3247 836.944
r_2687_3247_i 2687_3247 3247 4256.89
c_2687_3247_i 2687 2687_3247 4.67522e-10
r_3247_3807_e 3247 3807 13758.3
r_3247_3807_i 3247_3807 3807 95645.6
c_3247_3807_i 3247 3247_3807 9.36084e-12
r_448_1008_e 448 1008 13376.4
r_448_1008_i 448_1008 1008 93218.1
c_448_1008_i 448 448_1008 2.08965e-09
r_1008_1568_e 1008 1568 13376.4
r_1008_1568_i 1008_1568 1568 93218.1
c_1008_1568_i 1008 1008_1568 2.08965e-09
r_1568_2128_e 1568 2128 836.944
r_1568_2128_i 1568_2128 2128 4256.89
c_1568_2128_i 1568 1568_2128 4.67522e-10
r_2128_2688_e 2128 2688 836.944
r_2128_2688_i 2128_2688 2688 4256.89
c_2128_2688_i 2128 2128_2688 4.67522e-10
r_2688_3248_e 2688 3248 836.944
r_2688_3248_i 2688_3248 3248 4256.89
c_2688_3248_i 2688 2688_3248 4.67522e-10
r_3248_3808_e 3248 3808 13758.3
r_3248_3808_i 3248_3808 3808 95645.6
c_3248_3808_i 3248 3248_3808 9.36084e-12
r_449_1009_e 449 1009 13376.4
r_449_1009_i 449_1009 1009 93218.1
c_449_1009_i 449 449_1009 2.08965e-09
r_1009_1569_e 1009 1569 13376.4
r_1009_1569_i 1009_1569 1569 93218.1
c_1009_1569_i 1009 1009_1569 2.08965e-09
r_1569_2129_e 1569 2129 13376.4
r_1569_2129_i 1569_2129 2129 93218.1
c_1569_2129_i 1569 1569_2129 2.08965e-09
r_2129_2689_e 2129 2689 13376.4
r_2129_2689_i 2129_2689 2689 93218.1
c_2129_2689_i 2129 2129_2689 2.08965e-09
r_2689_3249_e 2689 3249 13376.4
r_2689_3249_i 2689_3249 3249 93218.1
c_2689_3249_i 2689 2689_3249 2.08965e-09
r_3249_3809_e 3249 3809 13376.4
r_3249_3809_i 3249_3809 3809 93218.1
c_3249_3809_i 3249 3249_3809 2.08965e-09
r_450_1010_e 450 1010 13376.4
r_450_1010_i 450_1010 1010 93218.1
c_450_1010_i 450 450_1010 2.08965e-09
r_1010_1570_e 1010 1570 13376.4
r_1010_1570_i 1010_1570 1570 93218.1
c_1010_1570_i 1010 1010_1570 2.08965e-09
r_1570_2130_e 1570 2130 13376.4
r_1570_2130_i 1570_2130 2130 93218.1
c_1570_2130_i 1570 1570_2130 2.08965e-09
r_2130_2690_e 2130 2690 13376.4
r_2130_2690_i 2130_2690 2690 93218.1
c_2130_2690_i 2130 2130_2690 2.08965e-09
r_2690_3250_e 2690 3250 13376.4
r_2690_3250_i 2690_3250 3250 93218.1
c_2690_3250_i 2690 2690_3250 2.08965e-09
r_3250_3810_e 3250 3810 13376.4
r_3250_3810_i 3250_3810 3810 93218.1
c_3250_3810_i 3250 3250_3810 2.08965e-09
r_451_1011_e 451 1011 13376.4
r_451_1011_i 451_1011 1011 93218.1
c_451_1011_i 451 451_1011 2.08965e-09
r_1011_1571_e 1011 1571 13376.4
r_1011_1571_i 1011_1571 1571 93218.1
c_1011_1571_i 1011 1011_1571 2.08965e-09
r_1571_2131_e 1571 2131 836.944
r_1571_2131_i 1571_2131 2131 4256.89
c_1571_2131_i 1571 1571_2131 4.67522e-10
r_2131_2691_e 2131 2691 836.944
r_2131_2691_i 2131_2691 2691 4256.89
c_2131_2691_i 2131 2131_2691 4.67522e-10
r_2691_3251_e 2691 3251 836.944
r_2691_3251_i 2691_3251 3251 4256.89
c_2691_3251_i 2691 2691_3251 4.67522e-10
r_3251_3811_e 3251 3811 836.944
r_3251_3811_i 3251_3811 3811 4256.89
c_3251_3811_i 3251 3251_3811 4.67522e-10
r_452_1012_e 452 1012 13376.4
r_452_1012_i 452_1012 1012 93218.1
c_452_1012_i 452 452_1012 2.08965e-09
r_1012_1572_e 1012 1572 13376.4
r_1012_1572_i 1012_1572 1572 93218.1
c_1012_1572_i 1012 1012_1572 2.08965e-09
r_1572_2132_e 1572 2132 836.944
r_1572_2132_i 1572_2132 2132 4256.89
c_1572_2132_i 1572 1572_2132 4.67522e-10
r_2132_2692_e 2132 2692 836.944
r_2132_2692_i 2132_2692 2692 4256.89
c_2132_2692_i 2132 2132_2692 4.67522e-10
r_2692_3252_e 2692 3252 836.944
r_2692_3252_i 2692_3252 3252 4256.89
c_2692_3252_i 2692 2692_3252 4.67522e-10
r_3252_3812_e 3252 3812 13758.3
r_3252_3812_i 3252_3812 3812 95645.6
c_3252_3812_i 3252 3252_3812 9.36084e-12
r_453_1013_e 453 1013 13376.4
r_453_1013_i 453_1013 1013 93218.1
c_453_1013_i 453 453_1013 2.08965e-09
r_1013_1573_e 1013 1573 13376.4
r_1013_1573_i 1013_1573 1573 93218.1
c_1013_1573_i 1013 1013_1573 2.08965e-09
r_1573_2133_e 1573 2133 836.944
r_1573_2133_i 1573_2133 2133 4256.89
c_1573_2133_i 1573 1573_2133 4.67522e-10
r_2133_2693_e 2133 2693 836.944
r_2133_2693_i 2133_2693 2693 4256.89
c_2133_2693_i 2133 2133_2693 4.67522e-10
r_2693_3253_e 2693 3253 836.944
r_2693_3253_i 2693_3253 3253 4256.89
c_2693_3253_i 2693 2693_3253 4.67522e-10
r_3253_3813_e 3253 3813 13758.3
r_3253_3813_i 3253_3813 3813 95645.6
c_3253_3813_i 3253 3253_3813 9.36084e-12
r_454_1014_e 454 1014 13376.4
r_454_1014_i 454_1014 1014 93218.1
c_454_1014_i 454 454_1014 2.08965e-09
r_1014_1574_e 1014 1574 13376.4
r_1014_1574_i 1014_1574 1574 93218.1
c_1014_1574_i 1014 1014_1574 2.08965e-09
r_1574_2134_e 1574 2134 836.944
r_1574_2134_i 1574_2134 2134 4256.89
c_1574_2134_i 1574 1574_2134 4.67522e-10
r_2134_2694_e 2134 2694 836.944
r_2134_2694_i 2134_2694 2694 4256.89
c_2134_2694_i 2134 2134_2694 4.67522e-10
r_2694_3254_e 2694 3254 836.944
r_2694_3254_i 2694_3254 3254 4256.89
c_2694_3254_i 2694 2694_3254 4.67522e-10
r_3254_3814_e 3254 3814 13758.3
r_3254_3814_i 3254_3814 3814 95645.6
c_3254_3814_i 3254 3254_3814 9.36084e-12
r_455_1015_e 455 1015 13376.4
r_455_1015_i 455_1015 1015 93218.1
c_455_1015_i 455 455_1015 2.08965e-09
r_1015_1575_e 1015 1575 13376.4
r_1015_1575_i 1015_1575 1575 93218.1
c_1015_1575_i 1015 1015_1575 2.08965e-09
r_1575_2135_e 1575 2135 836.944
r_1575_2135_i 1575_2135 2135 4256.89
c_1575_2135_i 1575 1575_2135 4.67522e-10
r_2135_2695_e 2135 2695 836.944
r_2135_2695_i 2135_2695 2695 4256.89
c_2135_2695_i 2135 2135_2695 4.67522e-10
r_2695_3255_e 2695 3255 836.944
r_2695_3255_i 2695_3255 3255 4256.89
c_2695_3255_i 2695 2695_3255 4.67522e-10
r_3255_3815_e 3255 3815 13758.3
r_3255_3815_i 3255_3815 3815 95645.6
c_3255_3815_i 3255 3255_3815 9.36084e-12
r_456_1016_e 456 1016 13376.4
r_456_1016_i 456_1016 1016 93218.1
c_456_1016_i 456 456_1016 2.08965e-09
r_1016_1576_e 1016 1576 13376.4
r_1016_1576_i 1016_1576 1576 93218.1
c_1016_1576_i 1016 1016_1576 2.08965e-09
r_1576_2136_e 1576 2136 836.944
r_1576_2136_i 1576_2136 2136 4256.89
c_1576_2136_i 1576 1576_2136 4.67522e-10
r_2136_2696_e 2136 2696 836.944
r_2136_2696_i 2136_2696 2696 4256.89
c_2136_2696_i 2136 2136_2696 4.67522e-10
r_2696_3256_e 2696 3256 836.944
r_2696_3256_i 2696_3256 3256 4256.89
c_2696_3256_i 2696 2696_3256 4.67522e-10
r_3256_3816_e 3256 3816 13758.3
r_3256_3816_i 3256_3816 3816 95645.6
c_3256_3816_i 3256 3256_3816 9.36084e-12
r_457_1017_e 457 1017 13376.4
r_457_1017_i 457_1017 1017 93218.1
c_457_1017_i 457 457_1017 2.08965e-09
r_1017_1577_e 1017 1577 13376.4
r_1017_1577_i 1017_1577 1577 93218.1
c_1017_1577_i 1017 1017_1577 2.08965e-09
r_1577_2137_e 1577 2137 836.944
r_1577_2137_i 1577_2137 2137 4256.89
c_1577_2137_i 1577 1577_2137 4.67522e-10
r_2137_2697_e 2137 2697 836.944
r_2137_2697_i 2137_2697 2697 4256.89
c_2137_2697_i 2137 2137_2697 4.67522e-10
r_2697_3257_e 2697 3257 836.944
r_2697_3257_i 2697_3257 3257 4256.89
c_2697_3257_i 2697 2697_3257 4.67522e-10
r_3257_3817_e 3257 3817 13758.3
r_3257_3817_i 3257_3817 3817 95645.6
c_3257_3817_i 3257 3257_3817 9.36084e-12
r_458_1018_e 458 1018 13376.4
r_458_1018_i 458_1018 1018 93218.1
c_458_1018_i 458 458_1018 2.08965e-09
r_1018_1578_e 1018 1578 13376.4
r_1018_1578_i 1018_1578 1578 93218.1
c_1018_1578_i 1018 1018_1578 2.08965e-09
r_1578_2138_e 1578 2138 836.944
r_1578_2138_i 1578_2138 2138 4256.89
c_1578_2138_i 1578 1578_2138 4.67522e-10
r_2138_2698_e 2138 2698 836.944
r_2138_2698_i 2138_2698 2698 4256.89
c_2138_2698_i 2138 2138_2698 4.67522e-10
r_2698_3258_e 2698 3258 836.944
r_2698_3258_i 2698_3258 3258 4256.89
c_2698_3258_i 2698 2698_3258 4.67522e-10
r_3258_3818_e 3258 3818 13758.3
r_3258_3818_i 3258_3818 3818 95645.6
c_3258_3818_i 3258 3258_3818 9.36084e-12
r_459_1019_e 459 1019 13376.4
r_459_1019_i 459_1019 1019 93218.1
c_459_1019_i 459 459_1019 2.08965e-09
r_1019_1579_e 1019 1579 396.535
r_1019_1579_i 1019_1579 1579 1004.86
c_1019_1579_i 1019 1019_1579 1.65863e-10
r_1579_2139_e 1579 2139 836.944
r_1579_2139_i 1579_2139 2139 4256.89
c_1579_2139_i 1579 1579_2139 4.67522e-10
r_2139_2699_e 2139 2699 836.944
r_2139_2699_i 2139_2699 2699 4256.89
c_2139_2699_i 2139 2139_2699 4.67522e-10
r_2699_3259_e 2699 3259 836.944
r_2699_3259_i 2699_3259 3259 4256.89
c_2699_3259_i 2699 2699_3259 4.67522e-10
r_3259_3819_e 3259 3819 13758.3
r_3259_3819_i 3259_3819 3819 95645.6
c_3259_3819_i 3259 3259_3819 9.36084e-12
r_460_1020_e 460 1020 13376.4
r_460_1020_i 460_1020 1020 93218.1
c_460_1020_i 460 460_1020 2.08965e-09
r_1020_1580_e 1020 1580 396.535
r_1020_1580_i 1020_1580 1580 1004.86
c_1020_1580_i 1020 1020_1580 1.65863e-10
r_1580_2140_e 1580 2140 836.944
r_1580_2140_i 1580_2140 2140 4256.89
c_1580_2140_i 1580 1580_2140 4.67522e-10
r_2140_2700_e 2140 2700 836.944
r_2140_2700_i 2140_2700 2700 4256.89
c_2140_2700_i 2140 2140_2700 4.67522e-10
r_2700_3260_e 2700 3260 836.944
r_2700_3260_i 2700_3260 3260 4256.89
c_2700_3260_i 2700 2700_3260 4.67522e-10
r_3260_3820_e 3260 3820 13758.3
r_3260_3820_i 3260_3820 3820 95645.6
c_3260_3820_i 3260 3260_3820 9.36084e-12
r_461_1021_e 461 1021 13376.4
r_461_1021_i 461_1021 1021 93218.1
c_461_1021_i 461 461_1021 2.08965e-09
r_1021_1581_e 1021 1581 13376.4
r_1021_1581_i 1021_1581 1581 93218.1
c_1021_1581_i 1021 1021_1581 2.08965e-09
r_1581_2141_e 1581 2141 836.944
r_1581_2141_i 1581_2141 2141 4256.89
c_1581_2141_i 1581 1581_2141 4.67522e-10
r_2141_2701_e 2141 2701 836.944
r_2141_2701_i 2141_2701 2701 4256.89
c_2141_2701_i 2141 2141_2701 4.67522e-10
r_2701_3261_e 2701 3261 836.944
r_2701_3261_i 2701_3261 3261 4256.89
c_2701_3261_i 2701 2701_3261 4.67522e-10
r_3261_3821_e 3261 3821 13758.3
r_3261_3821_i 3261_3821 3821 95645.6
c_3261_3821_i 3261 3261_3821 9.36084e-12
r_462_1022_e 462 1022 13376.4
r_462_1022_i 462_1022 1022 93218.1
c_462_1022_i 462 462_1022 2.08965e-09
r_1022_1582_e 1022 1582 13376.4
r_1022_1582_i 1022_1582 1582 93218.1
c_1022_1582_i 1022 1022_1582 2.08965e-09
r_1582_2142_e 1582 2142 836.944
r_1582_2142_i 1582_2142 2142 4256.89
c_1582_2142_i 1582 1582_2142 4.67522e-10
r_2142_2702_e 2142 2702 836.944
r_2142_2702_i 2142_2702 2702 4256.89
c_2142_2702_i 2142 2142_2702 4.67522e-10
r_2702_3262_e 2702 3262 836.944
r_2702_3262_i 2702_3262 3262 4256.89
c_2702_3262_i 2702 2702_3262 4.67522e-10
r_3262_3822_e 3262 3822 13758.3
r_3262_3822_i 3262_3822 3822 95645.6
c_3262_3822_i 3262 3262_3822 9.36084e-12
r_463_1023_e 463 1023 13376.4
r_463_1023_i 463_1023 1023 93218.1
c_463_1023_i 463 463_1023 2.08965e-09
r_1023_1583_e 1023 1583 13376.4
r_1023_1583_i 1023_1583 1583 93218.1
c_1023_1583_i 1023 1023_1583 2.08965e-09
r_1583_2143_e 1583 2143 836.944
r_1583_2143_i 1583_2143 2143 4256.89
c_1583_2143_i 1583 1583_2143 4.67522e-10
r_2143_2703_e 2143 2703 836.944
r_2143_2703_i 2143_2703 2703 4256.89
c_2143_2703_i 2143 2143_2703 4.67522e-10
r_2703_3263_e 2703 3263 836.944
r_2703_3263_i 2703_3263 3263 4256.89
c_2703_3263_i 2703 2703_3263 4.67522e-10
r_3263_3823_e 3263 3823 13758.3
r_3263_3823_i 3263_3823 3823 95645.6
c_3263_3823_i 3263 3263_3823 9.36084e-12
r_464_1024_e 464 1024 13376.4
r_464_1024_i 464_1024 1024 93218.1
c_464_1024_i 464 464_1024 2.08965e-09
r_1024_1584_e 1024 1584 13376.4
r_1024_1584_i 1024_1584 1584 93218.1
c_1024_1584_i 1024 1024_1584 2.08965e-09
r_1584_2144_e 1584 2144 836.944
r_1584_2144_i 1584_2144 2144 4256.89
c_1584_2144_i 1584 1584_2144 4.67522e-10
r_2144_2704_e 2144 2704 836.944
r_2144_2704_i 2144_2704 2704 4256.89
c_2144_2704_i 2144 2144_2704 4.67522e-10
r_2704_3264_e 2704 3264 836.944
r_2704_3264_i 2704_3264 3264 4256.89
c_2704_3264_i 2704 2704_3264 4.67522e-10
r_3264_3824_e 3264 3824 13758.3
r_3264_3824_i 3264_3824 3824 95645.6
c_3264_3824_i 3264 3264_3824 9.36084e-12
r_465_1025_e 465 1025 13376.4
r_465_1025_i 465_1025 1025 93218.1
c_465_1025_i 465 465_1025 2.08965e-09
r_1025_1585_e 1025 1585 13376.4
r_1025_1585_i 1025_1585 1585 93218.1
c_1025_1585_i 1025 1025_1585 2.08965e-09
r_1585_2145_e 1585 2145 13376.4
r_1585_2145_i 1585_2145 2145 93218.1
c_1585_2145_i 1585 1585_2145 2.08965e-09
r_2145_2705_e 2145 2705 13376.4
r_2145_2705_i 2145_2705 2705 93218.1
c_2145_2705_i 2145 2145_2705 2.08965e-09
r_2705_3265_e 2705 3265 13376.4
r_2705_3265_i 2705_3265 3265 93218.1
c_2705_3265_i 2705 2705_3265 2.08965e-09
r_3265_3825_e 3265 3825 13376.4
r_3265_3825_i 3265_3825 3825 93218.1
c_3265_3825_i 3265 3265_3825 2.08965e-09
r_466_1026_e 466 1026 13376.4
r_466_1026_i 466_1026 1026 93218.1
c_466_1026_i 466 466_1026 2.08965e-09
r_1026_1586_e 1026 1586 13376.4
r_1026_1586_i 1026_1586 1586 93218.1
c_1026_1586_i 1026 1026_1586 2.08965e-09
r_1586_2146_e 1586 2146 13376.4
r_1586_2146_i 1586_2146 2146 93218.1
c_1586_2146_i 1586 1586_2146 2.08965e-09
r_2146_2706_e 2146 2706 13376.4
r_2146_2706_i 2146_2706 2706 93218.1
c_2146_2706_i 2146 2146_2706 2.08965e-09
r_2706_3266_e 2706 3266 13376.4
r_2706_3266_i 2706_3266 3266 93218.1
c_2706_3266_i 2706 2706_3266 2.08965e-09
r_3266_3826_e 3266 3826 13376.4
r_3266_3826_i 3266_3826 3826 93218.1
c_3266_3826_i 3266 3266_3826 2.08965e-09
r_467_1027_e 467 1027 13376.4
r_467_1027_i 467_1027 1027 93218.1
c_467_1027_i 467 467_1027 2.08965e-09
r_1027_1587_e 1027 1587 13376.4
r_1027_1587_i 1027_1587 1587 93218.1
c_1027_1587_i 1027 1027_1587 2.08965e-09
r_1587_2147_e 1587 2147 836.944
r_1587_2147_i 1587_2147 2147 4256.89
c_1587_2147_i 1587 1587_2147 4.67522e-10
r_2147_2707_e 2147 2707 836.944
r_2147_2707_i 2147_2707 2707 4256.89
c_2147_2707_i 2147 2147_2707 4.67522e-10
r_2707_3267_e 2707 3267 836.944
r_2707_3267_i 2707_3267 3267 4256.89
c_2707_3267_i 2707 2707_3267 4.67522e-10
r_3267_3827_e 3267 3827 836.944
r_3267_3827_i 3267_3827 3827 4256.89
c_3267_3827_i 3267 3267_3827 4.67522e-10
r_468_1028_e 468 1028 13376.4
r_468_1028_i 468_1028 1028 93218.1
c_468_1028_i 468 468_1028 2.08965e-09
r_1028_1588_e 1028 1588 13376.4
r_1028_1588_i 1028_1588 1588 93218.1
c_1028_1588_i 1028 1028_1588 2.08965e-09
r_1588_2148_e 1588 2148 836.944
r_1588_2148_i 1588_2148 2148 4256.89
c_1588_2148_i 1588 1588_2148 4.67522e-10
r_2148_2708_e 2148 2708 836.944
r_2148_2708_i 2148_2708 2708 4256.89
c_2148_2708_i 2148 2148_2708 4.67522e-10
r_2708_3268_e 2708 3268 836.944
r_2708_3268_i 2708_3268 3268 4256.89
c_2708_3268_i 2708 2708_3268 4.67522e-10
r_3268_3828_e 3268 3828 13758.3
r_3268_3828_i 3268_3828 3828 95645.6
c_3268_3828_i 3268 3268_3828 9.36084e-12
r_469_1029_e 469 1029 13376.4
r_469_1029_i 469_1029 1029 93218.1
c_469_1029_i 469 469_1029 2.08965e-09
r_1029_1589_e 1029 1589 13376.4
r_1029_1589_i 1029_1589 1589 93218.1
c_1029_1589_i 1029 1029_1589 2.08965e-09
r_1589_2149_e 1589 2149 836.944
r_1589_2149_i 1589_2149 2149 4256.89
c_1589_2149_i 1589 1589_2149 4.67522e-10
r_2149_2709_e 2149 2709 836.944
r_2149_2709_i 2149_2709 2709 4256.89
c_2149_2709_i 2149 2149_2709 4.67522e-10
r_2709_3269_e 2709 3269 836.944
r_2709_3269_i 2709_3269 3269 4256.89
c_2709_3269_i 2709 2709_3269 4.67522e-10
r_3269_3829_e 3269 3829 13758.3
r_3269_3829_i 3269_3829 3829 95645.6
c_3269_3829_i 3269 3269_3829 9.36084e-12
r_470_1030_e 470 1030 13376.4
r_470_1030_i 470_1030 1030 93218.1
c_470_1030_i 470 470_1030 2.08965e-09
r_1030_1590_e 1030 1590 13376.4
r_1030_1590_i 1030_1590 1590 93218.1
c_1030_1590_i 1030 1030_1590 2.08965e-09
r_1590_2150_e 1590 2150 836.944
r_1590_2150_i 1590_2150 2150 4256.89
c_1590_2150_i 1590 1590_2150 4.67522e-10
r_2150_2710_e 2150 2710 836.944
r_2150_2710_i 2150_2710 2710 4256.89
c_2150_2710_i 2150 2150_2710 4.67522e-10
r_2710_3270_e 2710 3270 836.944
r_2710_3270_i 2710_3270 3270 4256.89
c_2710_3270_i 2710 2710_3270 4.67522e-10
r_3270_3830_e 3270 3830 13758.3
r_3270_3830_i 3270_3830 3830 95645.6
c_3270_3830_i 3270 3270_3830 9.36084e-12
r_471_1031_e 471 1031 13376.4
r_471_1031_i 471_1031 1031 93218.1
c_471_1031_i 471 471_1031 2.08965e-09
r_1031_1591_e 1031 1591 13376.4
r_1031_1591_i 1031_1591 1591 93218.1
c_1031_1591_i 1031 1031_1591 2.08965e-09
r_1591_2151_e 1591 2151 836.944
r_1591_2151_i 1591_2151 2151 4256.89
c_1591_2151_i 1591 1591_2151 4.67522e-10
r_2151_2711_e 2151 2711 836.944
r_2151_2711_i 2151_2711 2711 4256.89
c_2151_2711_i 2151 2151_2711 4.67522e-10
r_2711_3271_e 2711 3271 836.944
r_2711_3271_i 2711_3271 3271 4256.89
c_2711_3271_i 2711 2711_3271 4.67522e-10
r_3271_3831_e 3271 3831 13758.3
r_3271_3831_i 3271_3831 3831 95645.6
c_3271_3831_i 3271 3271_3831 9.36084e-12
r_472_1032_e 472 1032 13376.4
r_472_1032_i 472_1032 1032 93218.1
c_472_1032_i 472 472_1032 2.08965e-09
r_1032_1592_e 1032 1592 13376.4
r_1032_1592_i 1032_1592 1592 93218.1
c_1032_1592_i 1032 1032_1592 2.08965e-09
r_1592_2152_e 1592 2152 836.944
r_1592_2152_i 1592_2152 2152 4256.89
c_1592_2152_i 1592 1592_2152 4.67522e-10
r_2152_2712_e 2152 2712 836.944
r_2152_2712_i 2152_2712 2712 4256.89
c_2152_2712_i 2152 2152_2712 4.67522e-10
r_2712_3272_e 2712 3272 836.944
r_2712_3272_i 2712_3272 3272 4256.89
c_2712_3272_i 2712 2712_3272 4.67522e-10
r_3272_3832_e 3272 3832 13758.3
r_3272_3832_i 3272_3832 3832 95645.6
c_3272_3832_i 3272 3272_3832 9.36084e-12
r_473_1033_e 473 1033 13376.4
r_473_1033_i 473_1033 1033 93218.1
c_473_1033_i 473 473_1033 2.08965e-09
r_1033_1593_e 1033 1593 13376.4
r_1033_1593_i 1033_1593 1593 93218.1
c_1033_1593_i 1033 1033_1593 2.08965e-09
r_1593_2153_e 1593 2153 836.944
r_1593_2153_i 1593_2153 2153 4256.89
c_1593_2153_i 1593 1593_2153 4.67522e-10
r_2153_2713_e 2153 2713 836.944
r_2153_2713_i 2153_2713 2713 4256.89
c_2153_2713_i 2153 2153_2713 4.67522e-10
r_2713_3273_e 2713 3273 836.944
r_2713_3273_i 2713_3273 3273 4256.89
c_2713_3273_i 2713 2713_3273 4.67522e-10
r_3273_3833_e 3273 3833 13758.3
r_3273_3833_i 3273_3833 3833 95645.6
c_3273_3833_i 3273 3273_3833 9.36084e-12
r_474_1034_e 474 1034 13376.4
r_474_1034_i 474_1034 1034 93218.1
c_474_1034_i 474 474_1034 2.08965e-09
r_1034_1594_e 1034 1594 13376.4
r_1034_1594_i 1034_1594 1594 93218.1
c_1034_1594_i 1034 1034_1594 2.08965e-09
r_1594_2154_e 1594 2154 836.944
r_1594_2154_i 1594_2154 2154 4256.89
c_1594_2154_i 1594 1594_2154 4.67522e-10
r_2154_2714_e 2154 2714 836.944
r_2154_2714_i 2154_2714 2714 4256.89
c_2154_2714_i 2154 2154_2714 4.67522e-10
r_2714_3274_e 2714 3274 836.944
r_2714_3274_i 2714_3274 3274 4256.89
c_2714_3274_i 2714 2714_3274 4.67522e-10
r_3274_3834_e 3274 3834 13758.3
r_3274_3834_i 3274_3834 3834 95645.6
c_3274_3834_i 3274 3274_3834 9.36084e-12
r_475_1035_e 475 1035 13376.4
r_475_1035_i 475_1035 1035 93218.1
c_475_1035_i 475 475_1035 2.08965e-09
r_1035_1595_e 1035 1595 396.526
r_1035_1595_i 1035_1595 1595 1004.84
c_1035_1595_i 1035 1035_1595 1.65866e-10
r_1595_2155_e 1595 2155 836.944
r_1595_2155_i 1595_2155 2155 4256.89
c_1595_2155_i 1595 1595_2155 4.67522e-10
r_2155_2715_e 2155 2715 836.944
r_2155_2715_i 2155_2715 2715 4256.89
c_2155_2715_i 2155 2155_2715 4.67522e-10
r_2715_3275_e 2715 3275 836.944
r_2715_3275_i 2715_3275 3275 4256.89
c_2715_3275_i 2715 2715_3275 4.67522e-10
r_3275_3835_e 3275 3835 13758.3
r_3275_3835_i 3275_3835 3835 95645.6
c_3275_3835_i 3275 3275_3835 9.36084e-12
r_476_1036_e 476 1036 13376.4
r_476_1036_i 476_1036 1036 93218.1
c_476_1036_i 476 476_1036 2.08965e-09
r_1036_1596_e 1036 1596 396.526
r_1036_1596_i 1036_1596 1596 1004.84
c_1036_1596_i 1036 1036_1596 1.65866e-10
r_1596_2156_e 1596 2156 836.944
r_1596_2156_i 1596_2156 2156 4256.89
c_1596_2156_i 1596 1596_2156 4.67522e-10
r_2156_2716_e 2156 2716 836.944
r_2156_2716_i 2156_2716 2716 4256.89
c_2156_2716_i 2156 2156_2716 4.67522e-10
r_2716_3276_e 2716 3276 836.944
r_2716_3276_i 2716_3276 3276 4256.89
c_2716_3276_i 2716 2716_3276 4.67522e-10
r_3276_3836_e 3276 3836 13758.3
r_3276_3836_i 3276_3836 3836 95645.6
c_3276_3836_i 3276 3276_3836 9.36084e-12
r_477_1037_e 477 1037 13376.4
r_477_1037_i 477_1037 1037 93218.1
c_477_1037_i 477 477_1037 2.08965e-09
r_1037_1597_e 1037 1597 13376.4
r_1037_1597_i 1037_1597 1597 93218.1
c_1037_1597_i 1037 1037_1597 2.08965e-09
r_1597_2157_e 1597 2157 836.944
r_1597_2157_i 1597_2157 2157 4256.89
c_1597_2157_i 1597 1597_2157 4.67522e-10
r_2157_2717_e 2157 2717 836.944
r_2157_2717_i 2157_2717 2717 4256.89
c_2157_2717_i 2157 2157_2717 4.67522e-10
r_2717_3277_e 2717 3277 836.944
r_2717_3277_i 2717_3277 3277 4256.89
c_2717_3277_i 2717 2717_3277 4.67522e-10
r_3277_3837_e 3277 3837 13758.3
r_3277_3837_i 3277_3837 3837 95645.6
c_3277_3837_i 3277 3277_3837 9.36084e-12
r_478_1038_e 478 1038 13376.4
r_478_1038_i 478_1038 1038 93218.1
c_478_1038_i 478 478_1038 2.08965e-09
r_1038_1598_e 1038 1598 13376.4
r_1038_1598_i 1038_1598 1598 93218.1
c_1038_1598_i 1038 1038_1598 2.08965e-09
r_1598_2158_e 1598 2158 836.944
r_1598_2158_i 1598_2158 2158 4256.89
c_1598_2158_i 1598 1598_2158 4.67522e-10
r_2158_2718_e 2158 2718 836.944
r_2158_2718_i 2158_2718 2718 4256.89
c_2158_2718_i 2158 2158_2718 4.67522e-10
r_2718_3278_e 2718 3278 836.944
r_2718_3278_i 2718_3278 3278 4256.89
c_2718_3278_i 2718 2718_3278 4.67522e-10
r_3278_3838_e 3278 3838 13758.3
r_3278_3838_i 3278_3838 3838 95645.6
c_3278_3838_i 3278 3278_3838 9.36084e-12
r_479_1039_e 479 1039 13376.4
r_479_1039_i 479_1039 1039 93218.1
c_479_1039_i 479 479_1039 2.08965e-09
r_1039_1599_e 1039 1599 13376.4
r_1039_1599_i 1039_1599 1599 93218.1
c_1039_1599_i 1039 1039_1599 2.08965e-09
r_1599_2159_e 1599 2159 836.944
r_1599_2159_i 1599_2159 2159 4256.89
c_1599_2159_i 1599 1599_2159 4.67522e-10
r_2159_2719_e 2159 2719 836.944
r_2159_2719_i 2159_2719 2719 4256.89
c_2159_2719_i 2159 2159_2719 4.67522e-10
r_2719_3279_e 2719 3279 836.944
r_2719_3279_i 2719_3279 3279 4256.89
c_2719_3279_i 2719 2719_3279 4.67522e-10
r_3279_3839_e 3279 3839 13758.3
r_3279_3839_i 3279_3839 3839 95645.6
c_3279_3839_i 3279 3279_3839 9.36084e-12
r_480_1040_e 480 1040 13376.4
r_480_1040_i 480_1040 1040 93218.1
c_480_1040_i 480 480_1040 2.08965e-09
r_1040_1600_e 1040 1600 13376.4
r_1040_1600_i 1040_1600 1600 93218.1
c_1040_1600_i 1040 1040_1600 2.08965e-09
r_1600_2160_e 1600 2160 836.944
r_1600_2160_i 1600_2160 2160 4256.89
c_1600_2160_i 1600 1600_2160 4.67522e-10
r_2160_2720_e 2160 2720 836.944
r_2160_2720_i 2160_2720 2720 4256.89
c_2160_2720_i 2160 2160_2720 4.67522e-10
r_2720_3280_e 2720 3280 836.944
r_2720_3280_i 2720_3280 3280 4256.89
c_2720_3280_i 2720 2720_3280 4.67522e-10
r_3280_3840_e 3280 3840 13758.3
r_3280_3840_i 3280_3840 3840 95645.6
c_3280_3840_i 3280 3280_3840 9.36084e-12
r_481_1041_e 481 1041 13376.4
r_481_1041_i 481_1041 1041 93218.1
c_481_1041_i 481 481_1041 2.08965e-09
r_1041_1601_e 1041 1601 13376.4
r_1041_1601_i 1041_1601 1601 93218.1
c_1041_1601_i 1041 1041_1601 2.08965e-09
r_1601_2161_e 1601 2161 13376.4
r_1601_2161_i 1601_2161 2161 93218.1
c_1601_2161_i 1601 1601_2161 2.08965e-09
r_2161_2721_e 2161 2721 13376.4
r_2161_2721_i 2161_2721 2721 93218.1
c_2161_2721_i 2161 2161_2721 2.08965e-09
r_2721_3281_e 2721 3281 13376.4
r_2721_3281_i 2721_3281 3281 93218.1
c_2721_3281_i 2721 2721_3281 2.08965e-09
r_3281_3841_e 3281 3841 13376.4
r_3281_3841_i 3281_3841 3841 93218.1
c_3281_3841_i 3281 3281_3841 2.08965e-09
r_482_1042_e 482 1042 13376.4
r_482_1042_i 482_1042 1042 93218.1
c_482_1042_i 482 482_1042 2.08965e-09
r_1042_1602_e 1042 1602 13376.4
r_1042_1602_i 1042_1602 1602 93218.1
c_1042_1602_i 1042 1042_1602 2.08965e-09
r_1602_2162_e 1602 2162 13376.4
r_1602_2162_i 1602_2162 2162 93218.1
c_1602_2162_i 1602 1602_2162 2.08965e-09
r_2162_2722_e 2162 2722 13376.4
r_2162_2722_i 2162_2722 2722 93218.1
c_2162_2722_i 2162 2162_2722 2.08965e-09
r_2722_3282_e 2722 3282 13376.4
r_2722_3282_i 2722_3282 3282 93218.1
c_2722_3282_i 2722 2722_3282 2.08965e-09
r_3282_3842_e 3282 3842 13376.4
r_3282_3842_i 3282_3842 3842 93218.1
c_3282_3842_i 3282 3282_3842 2.08965e-09
r_483_1043_e 483 1043 13376.4
r_483_1043_i 483_1043 1043 93218.1
c_483_1043_i 483 483_1043 2.08965e-09
r_1043_1603_e 1043 1603 13376.4
r_1043_1603_i 1043_1603 1603 93218.1
c_1043_1603_i 1043 1043_1603 2.08965e-09
r_1603_2163_e 1603 2163 836.944
r_1603_2163_i 1603_2163 2163 4256.89
c_1603_2163_i 1603 1603_2163 4.67522e-10
r_2163_2723_e 2163 2723 836.944
r_2163_2723_i 2163_2723 2723 4256.89
c_2163_2723_i 2163 2163_2723 4.67522e-10
r_2723_3283_e 2723 3283 836.944
r_2723_3283_i 2723_3283 3283 4256.89
c_2723_3283_i 2723 2723_3283 4.67522e-10
r_3283_3843_e 3283 3843 836.944
r_3283_3843_i 3283_3843 3843 4256.89
c_3283_3843_i 3283 3283_3843 4.67522e-10
r_484_1044_e 484 1044 13376.4
r_484_1044_i 484_1044 1044 93218.1
c_484_1044_i 484 484_1044 2.08965e-09
r_1044_1604_e 1044 1604 13376.4
r_1044_1604_i 1044_1604 1604 93218.1
c_1044_1604_i 1044 1044_1604 2.08965e-09
r_1604_2164_e 1604 2164 836.944
r_1604_2164_i 1604_2164 2164 4256.89
c_1604_2164_i 1604 1604_2164 4.67522e-10
r_2164_2724_e 2164 2724 836.944
r_2164_2724_i 2164_2724 2724 4256.89
c_2164_2724_i 2164 2164_2724 4.67522e-10
r_2724_3284_e 2724 3284 836.944
r_2724_3284_i 2724_3284 3284 4256.89
c_2724_3284_i 2724 2724_3284 4.67522e-10
r_3284_3844_e 3284 3844 13758.3
r_3284_3844_i 3284_3844 3844 95645.6
c_3284_3844_i 3284 3284_3844 9.36084e-12
r_485_1045_e 485 1045 13376.4
r_485_1045_i 485_1045 1045 93218.1
c_485_1045_i 485 485_1045 2.08965e-09
r_1045_1605_e 1045 1605 13376.4
r_1045_1605_i 1045_1605 1605 93218.1
c_1045_1605_i 1045 1045_1605 2.08965e-09
r_1605_2165_e 1605 2165 836.944
r_1605_2165_i 1605_2165 2165 4256.89
c_1605_2165_i 1605 1605_2165 4.67522e-10
r_2165_2725_e 2165 2725 836.944
r_2165_2725_i 2165_2725 2725 4256.89
c_2165_2725_i 2165 2165_2725 4.67522e-10
r_2725_3285_e 2725 3285 836.944
r_2725_3285_i 2725_3285 3285 4256.89
c_2725_3285_i 2725 2725_3285 4.67522e-10
r_3285_3845_e 3285 3845 13758.3
r_3285_3845_i 3285_3845 3845 95645.6
c_3285_3845_i 3285 3285_3845 9.36084e-12
r_486_1046_e 486 1046 13376.4
r_486_1046_i 486_1046 1046 93218.1
c_486_1046_i 486 486_1046 2.08965e-09
r_1046_1606_e 1046 1606 13376.4
r_1046_1606_i 1046_1606 1606 93218.1
c_1046_1606_i 1046 1046_1606 2.08965e-09
r_1606_2166_e 1606 2166 836.944
r_1606_2166_i 1606_2166 2166 4256.89
c_1606_2166_i 1606 1606_2166 4.67522e-10
r_2166_2726_e 2166 2726 836.944
r_2166_2726_i 2166_2726 2726 4256.89
c_2166_2726_i 2166 2166_2726 4.67522e-10
r_2726_3286_e 2726 3286 836.944
r_2726_3286_i 2726_3286 3286 4256.89
c_2726_3286_i 2726 2726_3286 4.67522e-10
r_3286_3846_e 3286 3846 13758.3
r_3286_3846_i 3286_3846 3846 95645.6
c_3286_3846_i 3286 3286_3846 9.36084e-12
r_487_1047_e 487 1047 13376.4
r_487_1047_i 487_1047 1047 93218.1
c_487_1047_i 487 487_1047 2.08965e-09
r_1047_1607_e 1047 1607 13376.4
r_1047_1607_i 1047_1607 1607 93218.1
c_1047_1607_i 1047 1047_1607 2.08965e-09
r_1607_2167_e 1607 2167 836.944
r_1607_2167_i 1607_2167 2167 4256.89
c_1607_2167_i 1607 1607_2167 4.67522e-10
r_2167_2727_e 2167 2727 836.944
r_2167_2727_i 2167_2727 2727 4256.89
c_2167_2727_i 2167 2167_2727 4.67522e-10
r_2727_3287_e 2727 3287 836.944
r_2727_3287_i 2727_3287 3287 4256.89
c_2727_3287_i 2727 2727_3287 4.67522e-10
r_3287_3847_e 3287 3847 13758.3
r_3287_3847_i 3287_3847 3847 95645.6
c_3287_3847_i 3287 3287_3847 9.36084e-12
r_488_1048_e 488 1048 13376.4
r_488_1048_i 488_1048 1048 93218.1
c_488_1048_i 488 488_1048 2.08965e-09
r_1048_1608_e 1048 1608 13376.4
r_1048_1608_i 1048_1608 1608 93218.1
c_1048_1608_i 1048 1048_1608 2.08965e-09
r_1608_2168_e 1608 2168 836.944
r_1608_2168_i 1608_2168 2168 4256.89
c_1608_2168_i 1608 1608_2168 4.67522e-10
r_2168_2728_e 2168 2728 836.944
r_2168_2728_i 2168_2728 2728 4256.89
c_2168_2728_i 2168 2168_2728 4.67522e-10
r_2728_3288_e 2728 3288 836.944
r_2728_3288_i 2728_3288 3288 4256.89
c_2728_3288_i 2728 2728_3288 4.67522e-10
r_3288_3848_e 3288 3848 13758.3
r_3288_3848_i 3288_3848 3848 95645.6
c_3288_3848_i 3288 3288_3848 9.36084e-12
r_489_1049_e 489 1049 13376.4
r_489_1049_i 489_1049 1049 93218.1
c_489_1049_i 489 489_1049 2.08965e-09
r_1049_1609_e 1049 1609 13376.4
r_1049_1609_i 1049_1609 1609 93218.1
c_1049_1609_i 1049 1049_1609 2.08965e-09
r_1609_2169_e 1609 2169 836.944
r_1609_2169_i 1609_2169 2169 4256.89
c_1609_2169_i 1609 1609_2169 4.67522e-10
r_2169_2729_e 2169 2729 836.944
r_2169_2729_i 2169_2729 2729 4256.89
c_2169_2729_i 2169 2169_2729 4.67522e-10
r_2729_3289_e 2729 3289 836.944
r_2729_3289_i 2729_3289 3289 4256.89
c_2729_3289_i 2729 2729_3289 4.67522e-10
r_3289_3849_e 3289 3849 13758.3
r_3289_3849_i 3289_3849 3849 95645.6
c_3289_3849_i 3289 3289_3849 9.36084e-12
r_490_1050_e 490 1050 13376.4
r_490_1050_i 490_1050 1050 93218.1
c_490_1050_i 490 490_1050 2.08965e-09
r_1050_1610_e 1050 1610 13376.4
r_1050_1610_i 1050_1610 1610 93218.1
c_1050_1610_i 1050 1050_1610 2.08965e-09
r_1610_2170_e 1610 2170 836.944
r_1610_2170_i 1610_2170 2170 4256.89
c_1610_2170_i 1610 1610_2170 4.67522e-10
r_2170_2730_e 2170 2730 836.944
r_2170_2730_i 2170_2730 2730 4256.89
c_2170_2730_i 2170 2170_2730 4.67522e-10
r_2730_3290_e 2730 3290 836.944
r_2730_3290_i 2730_3290 3290 4256.89
c_2730_3290_i 2730 2730_3290 4.67522e-10
r_3290_3850_e 3290 3850 13758.3
r_3290_3850_i 3290_3850 3850 95645.6
c_3290_3850_i 3290 3290_3850 9.36084e-12
r_491_1051_e 491 1051 13376.4
r_491_1051_i 491_1051 1051 93218.1
c_491_1051_i 491 491_1051 2.08965e-09
r_1051_1611_e 1051 1611 396.518
r_1051_1611_i 1051_1611 1611 1004.81
c_1051_1611_i 1051 1051_1611 1.65869e-10
r_1611_2171_e 1611 2171 836.944
r_1611_2171_i 1611_2171 2171 4256.89
c_1611_2171_i 1611 1611_2171 4.67522e-10
r_2171_2731_e 2171 2731 836.944
r_2171_2731_i 2171_2731 2731 4256.89
c_2171_2731_i 2171 2171_2731 4.67522e-10
r_2731_3291_e 2731 3291 836.944
r_2731_3291_i 2731_3291 3291 4256.89
c_2731_3291_i 2731 2731_3291 4.67522e-10
r_3291_3851_e 3291 3851 13758.3
r_3291_3851_i 3291_3851 3851 95645.6
c_3291_3851_i 3291 3291_3851 9.36084e-12
r_492_1052_e 492 1052 13376.4
r_492_1052_i 492_1052 1052 93218.1
c_492_1052_i 492 492_1052 2.08965e-09
r_1052_1612_e 1052 1612 396.518
r_1052_1612_i 1052_1612 1612 1004.81
c_1052_1612_i 1052 1052_1612 1.65869e-10
r_1612_2172_e 1612 2172 836.944
r_1612_2172_i 1612_2172 2172 4256.89
c_1612_2172_i 1612 1612_2172 4.67522e-10
r_2172_2732_e 2172 2732 836.944
r_2172_2732_i 2172_2732 2732 4256.89
c_2172_2732_i 2172 2172_2732 4.67522e-10
r_2732_3292_e 2732 3292 836.944
r_2732_3292_i 2732_3292 3292 4256.89
c_2732_3292_i 2732 2732_3292 4.67522e-10
r_3292_3852_e 3292 3852 13758.3
r_3292_3852_i 3292_3852 3852 95645.6
c_3292_3852_i 3292 3292_3852 9.36084e-12
r_493_1053_e 493 1053 13376.4
r_493_1053_i 493_1053 1053 93218.1
c_493_1053_i 493 493_1053 2.08965e-09
r_1053_1613_e 1053 1613 13376.4
r_1053_1613_i 1053_1613 1613 93218.1
c_1053_1613_i 1053 1053_1613 2.08965e-09
r_1613_2173_e 1613 2173 836.944
r_1613_2173_i 1613_2173 2173 4256.89
c_1613_2173_i 1613 1613_2173 4.67522e-10
r_2173_2733_e 2173 2733 836.944
r_2173_2733_i 2173_2733 2733 4256.89
c_2173_2733_i 2173 2173_2733 4.67522e-10
r_2733_3293_e 2733 3293 836.944
r_2733_3293_i 2733_3293 3293 4256.89
c_2733_3293_i 2733 2733_3293 4.67522e-10
r_3293_3853_e 3293 3853 13758.3
r_3293_3853_i 3293_3853 3853 95645.6
c_3293_3853_i 3293 3293_3853 9.36084e-12
r_494_1054_e 494 1054 13376.4
r_494_1054_i 494_1054 1054 93218.1
c_494_1054_i 494 494_1054 2.08965e-09
r_1054_1614_e 1054 1614 13376.4
r_1054_1614_i 1054_1614 1614 93218.1
c_1054_1614_i 1054 1054_1614 2.08965e-09
r_1614_2174_e 1614 2174 836.944
r_1614_2174_i 1614_2174 2174 4256.89
c_1614_2174_i 1614 1614_2174 4.67522e-10
r_2174_2734_e 2174 2734 836.944
r_2174_2734_i 2174_2734 2734 4256.89
c_2174_2734_i 2174 2174_2734 4.67522e-10
r_2734_3294_e 2734 3294 836.944
r_2734_3294_i 2734_3294 3294 4256.89
c_2734_3294_i 2734 2734_3294 4.67522e-10
r_3294_3854_e 3294 3854 13758.3
r_3294_3854_i 3294_3854 3854 95645.6
c_3294_3854_i 3294 3294_3854 9.36084e-12
r_495_1055_e 495 1055 13376.4
r_495_1055_i 495_1055 1055 93218.1
c_495_1055_i 495 495_1055 2.08965e-09
r_1055_1615_e 1055 1615 13376.4
r_1055_1615_i 1055_1615 1615 93218.1
c_1055_1615_i 1055 1055_1615 2.08965e-09
r_1615_2175_e 1615 2175 836.944
r_1615_2175_i 1615_2175 2175 4256.89
c_1615_2175_i 1615 1615_2175 4.67522e-10
r_2175_2735_e 2175 2735 836.944
r_2175_2735_i 2175_2735 2735 4256.89
c_2175_2735_i 2175 2175_2735 4.67522e-10
r_2735_3295_e 2735 3295 836.944
r_2735_3295_i 2735_3295 3295 4256.89
c_2735_3295_i 2735 2735_3295 4.67522e-10
r_3295_3855_e 3295 3855 13758.3
r_3295_3855_i 3295_3855 3855 95645.6
c_3295_3855_i 3295 3295_3855 9.36084e-12
r_496_1056_e 496 1056 13376.4
r_496_1056_i 496_1056 1056 93218.1
c_496_1056_i 496 496_1056 2.08965e-09
r_1056_1616_e 1056 1616 13376.4
r_1056_1616_i 1056_1616 1616 93218.1
c_1056_1616_i 1056 1056_1616 2.08965e-09
r_1616_2176_e 1616 2176 836.944
r_1616_2176_i 1616_2176 2176 4256.89
c_1616_2176_i 1616 1616_2176 4.67522e-10
r_2176_2736_e 2176 2736 836.944
r_2176_2736_i 2176_2736 2736 4256.89
c_2176_2736_i 2176 2176_2736 4.67522e-10
r_2736_3296_e 2736 3296 836.944
r_2736_3296_i 2736_3296 3296 4256.89
c_2736_3296_i 2736 2736_3296 4.67522e-10
r_3296_3856_e 3296 3856 13758.3
r_3296_3856_i 3296_3856 3856 95645.6
c_3296_3856_i 3296 3296_3856 9.36084e-12
r_497_1057_e 497 1057 13376.4
r_497_1057_i 497_1057 1057 93218.1
c_497_1057_i 497 497_1057 2.08965e-09
r_1057_1617_e 1057 1617 13376.4
r_1057_1617_i 1057_1617 1617 93218.1
c_1057_1617_i 1057 1057_1617 2.08965e-09
r_1617_2177_e 1617 2177 13376.4
r_1617_2177_i 1617_2177 2177 93218.1
c_1617_2177_i 1617 1617_2177 2.08965e-09
r_2177_2737_e 2177 2737 13376.4
r_2177_2737_i 2177_2737 2737 93218.1
c_2177_2737_i 2177 2177_2737 2.08965e-09
r_2737_3297_e 2737 3297 13376.4
r_2737_3297_i 2737_3297 3297 93218.1
c_2737_3297_i 2737 2737_3297 2.08965e-09
r_3297_3857_e 3297 3857 13376.4
r_3297_3857_i 3297_3857 3857 93218.1
c_3297_3857_i 3297 3297_3857 2.08965e-09
r_498_1058_e 498 1058 13376.4
r_498_1058_i 498_1058 1058 93218.1
c_498_1058_i 498 498_1058 2.08965e-09
r_1058_1618_e 1058 1618 13376.4
r_1058_1618_i 1058_1618 1618 93218.1
c_1058_1618_i 1058 1058_1618 2.08965e-09
r_1618_2178_e 1618 2178 13376.4
r_1618_2178_i 1618_2178 2178 93218.1
c_1618_2178_i 1618 1618_2178 2.08965e-09
r_2178_2738_e 2178 2738 13376.4
r_2178_2738_i 2178_2738 2738 93218.1
c_2178_2738_i 2178 2178_2738 2.08965e-09
r_2738_3298_e 2738 3298 13376.4
r_2738_3298_i 2738_3298 3298 93218.1
c_2738_3298_i 2738 2738_3298 2.08965e-09
r_3298_3858_e 3298 3858 13376.4
r_3298_3858_i 3298_3858 3858 93218.1
c_3298_3858_i 3298 3298_3858 2.08965e-09
r_499_1059_e 499 1059 13376.4
r_499_1059_i 499_1059 1059 93218.1
c_499_1059_i 499 499_1059 2.08965e-09
r_1059_1619_e 1059 1619 13376.4
r_1059_1619_i 1059_1619 1619 93218.1
c_1059_1619_i 1059 1059_1619 2.08965e-09
r_1619_2179_e 1619 2179 836.944
r_1619_2179_i 1619_2179 2179 4256.89
c_1619_2179_i 1619 1619_2179 4.67522e-10
r_2179_2739_e 2179 2739 836.944
r_2179_2739_i 2179_2739 2739 4256.89
c_2179_2739_i 2179 2179_2739 4.67522e-10
r_2739_3299_e 2739 3299 836.944
r_2739_3299_i 2739_3299 3299 4256.89
c_2739_3299_i 2739 2739_3299 4.67522e-10
r_3299_3859_e 3299 3859 836.944
r_3299_3859_i 3299_3859 3859 4256.89
c_3299_3859_i 3299 3299_3859 4.67522e-10
r_500_1060_e 500 1060 13376.4
r_500_1060_i 500_1060 1060 93218.1
c_500_1060_i 500 500_1060 2.08965e-09
r_1060_1620_e 1060 1620 13376.4
r_1060_1620_i 1060_1620 1620 93218.1
c_1060_1620_i 1060 1060_1620 2.08965e-09
r_1620_2180_e 1620 2180 836.944
r_1620_2180_i 1620_2180 2180 4256.89
c_1620_2180_i 1620 1620_2180 4.67522e-10
r_2180_2740_e 2180 2740 836.944
r_2180_2740_i 2180_2740 2740 4256.89
c_2180_2740_i 2180 2180_2740 4.67522e-10
r_2740_3300_e 2740 3300 836.944
r_2740_3300_i 2740_3300 3300 4256.89
c_2740_3300_i 2740 2740_3300 4.67522e-10
r_3300_3860_e 3300 3860 13758.3
r_3300_3860_i 3300_3860 3860 95645.6
c_3300_3860_i 3300 3300_3860 9.36084e-12
r_501_1061_e 501 1061 13376.4
r_501_1061_i 501_1061 1061 93218.1
c_501_1061_i 501 501_1061 2.08965e-09
r_1061_1621_e 1061 1621 13376.4
r_1061_1621_i 1061_1621 1621 93218.1
c_1061_1621_i 1061 1061_1621 2.08965e-09
r_1621_2181_e 1621 2181 836.944
r_1621_2181_i 1621_2181 2181 4256.89
c_1621_2181_i 1621 1621_2181 4.67522e-10
r_2181_2741_e 2181 2741 836.944
r_2181_2741_i 2181_2741 2741 4256.89
c_2181_2741_i 2181 2181_2741 4.67522e-10
r_2741_3301_e 2741 3301 836.944
r_2741_3301_i 2741_3301 3301 4256.89
c_2741_3301_i 2741 2741_3301 4.67522e-10
r_3301_3861_e 3301 3861 13758.3
r_3301_3861_i 3301_3861 3861 95645.6
c_3301_3861_i 3301 3301_3861 9.36084e-12
r_502_1062_e 502 1062 13376.4
r_502_1062_i 502_1062 1062 93218.1
c_502_1062_i 502 502_1062 2.08965e-09
r_1062_1622_e 1062 1622 13376.4
r_1062_1622_i 1062_1622 1622 93218.1
c_1062_1622_i 1062 1062_1622 2.08965e-09
r_1622_2182_e 1622 2182 836.944
r_1622_2182_i 1622_2182 2182 4256.89
c_1622_2182_i 1622 1622_2182 4.67522e-10
r_2182_2742_e 2182 2742 836.944
r_2182_2742_i 2182_2742 2742 4256.89
c_2182_2742_i 2182 2182_2742 4.67522e-10
r_2742_3302_e 2742 3302 836.944
r_2742_3302_i 2742_3302 3302 4256.89
c_2742_3302_i 2742 2742_3302 4.67522e-10
r_3302_3862_e 3302 3862 13758.3
r_3302_3862_i 3302_3862 3862 95645.6
c_3302_3862_i 3302 3302_3862 9.36084e-12
r_503_1063_e 503 1063 13376.4
r_503_1063_i 503_1063 1063 93218.1
c_503_1063_i 503 503_1063 2.08965e-09
r_1063_1623_e 1063 1623 13376.4
r_1063_1623_i 1063_1623 1623 93218.1
c_1063_1623_i 1063 1063_1623 2.08965e-09
r_1623_2183_e 1623 2183 836.944
r_1623_2183_i 1623_2183 2183 4256.89
c_1623_2183_i 1623 1623_2183 4.67522e-10
r_2183_2743_e 2183 2743 836.944
r_2183_2743_i 2183_2743 2743 4256.89
c_2183_2743_i 2183 2183_2743 4.67522e-10
r_2743_3303_e 2743 3303 836.944
r_2743_3303_i 2743_3303 3303 4256.89
c_2743_3303_i 2743 2743_3303 4.67522e-10
r_3303_3863_e 3303 3863 13758.3
r_3303_3863_i 3303_3863 3863 95645.6
c_3303_3863_i 3303 3303_3863 9.36084e-12
r_504_1064_e 504 1064 13376.4
r_504_1064_i 504_1064 1064 93218.1
c_504_1064_i 504 504_1064 2.08965e-09
r_1064_1624_e 1064 1624 13376.4
r_1064_1624_i 1064_1624 1624 93218.1
c_1064_1624_i 1064 1064_1624 2.08965e-09
r_1624_2184_e 1624 2184 836.944
r_1624_2184_i 1624_2184 2184 4256.89
c_1624_2184_i 1624 1624_2184 4.67522e-10
r_2184_2744_e 2184 2744 836.944
r_2184_2744_i 2184_2744 2744 4256.89
c_2184_2744_i 2184 2184_2744 4.67522e-10
r_2744_3304_e 2744 3304 836.944
r_2744_3304_i 2744_3304 3304 4256.89
c_2744_3304_i 2744 2744_3304 4.67522e-10
r_3304_3864_e 3304 3864 13758.3
r_3304_3864_i 3304_3864 3864 95645.6
c_3304_3864_i 3304 3304_3864 9.36084e-12
r_505_1065_e 505 1065 13376.4
r_505_1065_i 505_1065 1065 93218.1
c_505_1065_i 505 505_1065 2.08965e-09
r_1065_1625_e 1065 1625 13376.4
r_1065_1625_i 1065_1625 1625 93218.1
c_1065_1625_i 1065 1065_1625 2.08965e-09
r_1625_2185_e 1625 2185 836.944
r_1625_2185_i 1625_2185 2185 4256.89
c_1625_2185_i 1625 1625_2185 4.67522e-10
r_2185_2745_e 2185 2745 836.944
r_2185_2745_i 2185_2745 2745 4256.89
c_2185_2745_i 2185 2185_2745 4.67522e-10
r_2745_3305_e 2745 3305 836.944
r_2745_3305_i 2745_3305 3305 4256.89
c_2745_3305_i 2745 2745_3305 4.67522e-10
r_3305_3865_e 3305 3865 13758.3
r_3305_3865_i 3305_3865 3865 95645.6
c_3305_3865_i 3305 3305_3865 9.36084e-12
r_506_1066_e 506 1066 13376.4
r_506_1066_i 506_1066 1066 93218.1
c_506_1066_i 506 506_1066 2.08965e-09
r_1066_1626_e 1066 1626 13376.4
r_1066_1626_i 1066_1626 1626 93218.1
c_1066_1626_i 1066 1066_1626 2.08965e-09
r_1626_2186_e 1626 2186 836.944
r_1626_2186_i 1626_2186 2186 4256.89
c_1626_2186_i 1626 1626_2186 4.67522e-10
r_2186_2746_e 2186 2746 836.944
r_2186_2746_i 2186_2746 2746 4256.89
c_2186_2746_i 2186 2186_2746 4.67522e-10
r_2746_3306_e 2746 3306 836.944
r_2746_3306_i 2746_3306 3306 4256.89
c_2746_3306_i 2746 2746_3306 4.67522e-10
r_3306_3866_e 3306 3866 13758.3
r_3306_3866_i 3306_3866 3866 95645.6
c_3306_3866_i 3306 3306_3866 9.36084e-12
r_507_1067_e 507 1067 13376.4
r_507_1067_i 507_1067 1067 93218.1
c_507_1067_i 507 507_1067 2.08965e-09
r_1067_1627_e 1067 1627 396.51
r_1067_1627_i 1067_1627 1627 1004.79
c_1067_1627_i 1067 1067_1627 1.65873e-10
r_1627_2187_e 1627 2187 836.944
r_1627_2187_i 1627_2187 2187 4256.89
c_1627_2187_i 1627 1627_2187 4.67522e-10
r_2187_2747_e 2187 2747 836.944
r_2187_2747_i 2187_2747 2747 4256.89
c_2187_2747_i 2187 2187_2747 4.67522e-10
r_2747_3307_e 2747 3307 836.944
r_2747_3307_i 2747_3307 3307 4256.89
c_2747_3307_i 2747 2747_3307 4.67522e-10
r_3307_3867_e 3307 3867 13758.3
r_3307_3867_i 3307_3867 3867 95645.6
c_3307_3867_i 3307 3307_3867 9.36084e-12
r_508_1068_e 508 1068 13376.4
r_508_1068_i 508_1068 1068 93218.1
c_508_1068_i 508 508_1068 2.08965e-09
r_1068_1628_e 1068 1628 396.51
r_1068_1628_i 1068_1628 1628 1004.79
c_1068_1628_i 1068 1068_1628 1.65873e-10
r_1628_2188_e 1628 2188 836.944
r_1628_2188_i 1628_2188 2188 4256.89
c_1628_2188_i 1628 1628_2188 4.67522e-10
r_2188_2748_e 2188 2748 836.944
r_2188_2748_i 2188_2748 2748 4256.89
c_2188_2748_i 2188 2188_2748 4.67522e-10
r_2748_3308_e 2748 3308 836.944
r_2748_3308_i 2748_3308 3308 4256.89
c_2748_3308_i 2748 2748_3308 4.67522e-10
r_3308_3868_e 3308 3868 13758.3
r_3308_3868_i 3308_3868 3868 95645.6
c_3308_3868_i 3308 3308_3868 9.36084e-12
r_509_1069_e 509 1069 13376.4
r_509_1069_i 509_1069 1069 93218.1
c_509_1069_i 509 509_1069 2.08965e-09
r_1069_1629_e 1069 1629 13376.4
r_1069_1629_i 1069_1629 1629 93218.1
c_1069_1629_i 1069 1069_1629 2.08965e-09
r_1629_2189_e 1629 2189 836.944
r_1629_2189_i 1629_2189 2189 4256.89
c_1629_2189_i 1629 1629_2189 4.67522e-10
r_2189_2749_e 2189 2749 836.944
r_2189_2749_i 2189_2749 2749 4256.89
c_2189_2749_i 2189 2189_2749 4.67522e-10
r_2749_3309_e 2749 3309 836.944
r_2749_3309_i 2749_3309 3309 4256.89
c_2749_3309_i 2749 2749_3309 4.67522e-10
r_3309_3869_e 3309 3869 13758.3
r_3309_3869_i 3309_3869 3869 95645.6
c_3309_3869_i 3309 3309_3869 9.36084e-12
r_510_1070_e 510 1070 13376.4
r_510_1070_i 510_1070 1070 93218.1
c_510_1070_i 510 510_1070 2.08965e-09
r_1070_1630_e 1070 1630 13376.4
r_1070_1630_i 1070_1630 1630 93218.1
c_1070_1630_i 1070 1070_1630 2.08965e-09
r_1630_2190_e 1630 2190 836.944
r_1630_2190_i 1630_2190 2190 4256.89
c_1630_2190_i 1630 1630_2190 4.67522e-10
r_2190_2750_e 2190 2750 836.944
r_2190_2750_i 2190_2750 2750 4256.89
c_2190_2750_i 2190 2190_2750 4.67522e-10
r_2750_3310_e 2750 3310 836.944
r_2750_3310_i 2750_3310 3310 4256.89
c_2750_3310_i 2750 2750_3310 4.67522e-10
r_3310_3870_e 3310 3870 13758.3
r_3310_3870_i 3310_3870 3870 95645.6
c_3310_3870_i 3310 3310_3870 9.36084e-12
r_511_1071_e 511 1071 13376.4
r_511_1071_i 511_1071 1071 93218.1
c_511_1071_i 511 511_1071 2.08965e-09
r_1071_1631_e 1071 1631 13376.4
r_1071_1631_i 1071_1631 1631 93218.1
c_1071_1631_i 1071 1071_1631 2.08965e-09
r_1631_2191_e 1631 2191 836.944
r_1631_2191_i 1631_2191 2191 4256.89
c_1631_2191_i 1631 1631_2191 4.67522e-10
r_2191_2751_e 2191 2751 836.944
r_2191_2751_i 2191_2751 2751 4256.89
c_2191_2751_i 2191 2191_2751 4.67522e-10
r_2751_3311_e 2751 3311 836.944
r_2751_3311_i 2751_3311 3311 4256.89
c_2751_3311_i 2751 2751_3311 4.67522e-10
r_3311_3871_e 3311 3871 13758.3
r_3311_3871_i 3311_3871 3871 95645.6
c_3311_3871_i 3311 3311_3871 9.36084e-12
r_512_1072_e 512 1072 13376.4
r_512_1072_i 512_1072 1072 93218.1
c_512_1072_i 512 512_1072 2.08965e-09
r_1072_1632_e 1072 1632 13376.4
r_1072_1632_i 1072_1632 1632 93218.1
c_1072_1632_i 1072 1072_1632 2.08965e-09
r_1632_2192_e 1632 2192 836.944
r_1632_2192_i 1632_2192 2192 4256.89
c_1632_2192_i 1632 1632_2192 4.67522e-10
r_2192_2752_e 2192 2752 836.944
r_2192_2752_i 2192_2752 2752 4256.89
c_2192_2752_i 2192 2192_2752 4.67522e-10
r_2752_3312_e 2752 3312 836.944
r_2752_3312_i 2752_3312 3312 4256.89
c_2752_3312_i 2752 2752_3312 4.67522e-10
r_3312_3872_e 3312 3872 13758.3
r_3312_3872_i 3312_3872 3872 95645.6
c_3312_3872_i 3312 3312_3872 9.36084e-12
r_513_1073_e 513 1073 13376.4
r_513_1073_i 513_1073 1073 93218.1
c_513_1073_i 513 513_1073 2.08965e-09
r_1073_1633_e 1073 1633 13376.4
r_1073_1633_i 1073_1633 1633 93218.1
c_1073_1633_i 1073 1073_1633 2.08965e-09
r_1633_2193_e 1633 2193 13376.4
r_1633_2193_i 1633_2193 2193 93218.1
c_1633_2193_i 1633 1633_2193 2.08965e-09
r_2193_2753_e 2193 2753 13376.4
r_2193_2753_i 2193_2753 2753 93218.1
c_2193_2753_i 2193 2193_2753 2.08965e-09
r_2753_3313_e 2753 3313 13376.4
r_2753_3313_i 2753_3313 3313 93218.1
c_2753_3313_i 2753 2753_3313 2.08965e-09
r_3313_3873_e 3313 3873 13376.4
r_3313_3873_i 3313_3873 3873 93218.1
c_3313_3873_i 3313 3313_3873 2.08965e-09
r_514_1074_e 514 1074 13376.4
r_514_1074_i 514_1074 1074 93218.1
c_514_1074_i 514 514_1074 2.08965e-09
r_1074_1634_e 1074 1634 13376.4
r_1074_1634_i 1074_1634 1634 93218.1
c_1074_1634_i 1074 1074_1634 2.08965e-09
r_1634_2194_e 1634 2194 13376.4
r_1634_2194_i 1634_2194 2194 93218.1
c_1634_2194_i 1634 1634_2194 2.08965e-09
r_2194_2754_e 2194 2754 13376.4
r_2194_2754_i 2194_2754 2754 93218.1
c_2194_2754_i 2194 2194_2754 2.08965e-09
r_2754_3314_e 2754 3314 13376.4
r_2754_3314_i 2754_3314 3314 93218.1
c_2754_3314_i 2754 2754_3314 2.08965e-09
r_3314_3874_e 3314 3874 13376.4
r_3314_3874_i 3314_3874 3874 93218.1
c_3314_3874_i 3314 3314_3874 2.08965e-09
r_515_1075_e 515 1075 13376.4
r_515_1075_i 515_1075 1075 93218.1
c_515_1075_i 515 515_1075 2.08965e-09
r_1075_1635_e 1075 1635 13376.4
r_1075_1635_i 1075_1635 1635 93218.1
c_1075_1635_i 1075 1075_1635 2.08965e-09
r_1635_2195_e 1635 2195 836.944
r_1635_2195_i 1635_2195 2195 4256.89
c_1635_2195_i 1635 1635_2195 4.67522e-10
r_2195_2755_e 2195 2755 836.944
r_2195_2755_i 2195_2755 2755 4256.89
c_2195_2755_i 2195 2195_2755 4.67522e-10
r_2755_3315_e 2755 3315 836.944
r_2755_3315_i 2755_3315 3315 4256.89
c_2755_3315_i 2755 2755_3315 4.67522e-10
r_3315_3875_e 3315 3875 836.944
r_3315_3875_i 3315_3875 3875 4256.89
c_3315_3875_i 3315 3315_3875 4.67522e-10
r_516_1076_e 516 1076 13376.4
r_516_1076_i 516_1076 1076 93218.1
c_516_1076_i 516 516_1076 2.08965e-09
r_1076_1636_e 1076 1636 13376.4
r_1076_1636_i 1076_1636 1636 93218.1
c_1076_1636_i 1076 1076_1636 2.08965e-09
r_1636_2196_e 1636 2196 836.944
r_1636_2196_i 1636_2196 2196 4256.89
c_1636_2196_i 1636 1636_2196 4.67522e-10
r_2196_2756_e 2196 2756 836.944
r_2196_2756_i 2196_2756 2756 4256.89
c_2196_2756_i 2196 2196_2756 4.67522e-10
r_2756_3316_e 2756 3316 836.944
r_2756_3316_i 2756_3316 3316 4256.89
c_2756_3316_i 2756 2756_3316 4.67522e-10
r_3316_3876_e 3316 3876 13758.3
r_3316_3876_i 3316_3876 3876 95645.6
c_3316_3876_i 3316 3316_3876 9.36084e-12
r_517_1077_e 517 1077 13376.4
r_517_1077_i 517_1077 1077 93218.1
c_517_1077_i 517 517_1077 2.08965e-09
r_1077_1637_e 1077 1637 13376.4
r_1077_1637_i 1077_1637 1637 93218.1
c_1077_1637_i 1077 1077_1637 2.08965e-09
r_1637_2197_e 1637 2197 836.944
r_1637_2197_i 1637_2197 2197 4256.89
c_1637_2197_i 1637 1637_2197 4.67522e-10
r_2197_2757_e 2197 2757 836.944
r_2197_2757_i 2197_2757 2757 4256.89
c_2197_2757_i 2197 2197_2757 4.67522e-10
r_2757_3317_e 2757 3317 836.944
r_2757_3317_i 2757_3317 3317 4256.89
c_2757_3317_i 2757 2757_3317 4.67522e-10
r_3317_3877_e 3317 3877 13758.3
r_3317_3877_i 3317_3877 3877 95645.6
c_3317_3877_i 3317 3317_3877 9.36084e-12
r_518_1078_e 518 1078 13376.4
r_518_1078_i 518_1078 1078 93218.1
c_518_1078_i 518 518_1078 2.08965e-09
r_1078_1638_e 1078 1638 13376.4
r_1078_1638_i 1078_1638 1638 93218.1
c_1078_1638_i 1078 1078_1638 2.08965e-09
r_1638_2198_e 1638 2198 836.944
r_1638_2198_i 1638_2198 2198 4256.89
c_1638_2198_i 1638 1638_2198 4.67522e-10
r_2198_2758_e 2198 2758 836.944
r_2198_2758_i 2198_2758 2758 4256.89
c_2198_2758_i 2198 2198_2758 4.67522e-10
r_2758_3318_e 2758 3318 836.944
r_2758_3318_i 2758_3318 3318 4256.89
c_2758_3318_i 2758 2758_3318 4.67522e-10
r_3318_3878_e 3318 3878 13758.3
r_3318_3878_i 3318_3878 3878 95645.6
c_3318_3878_i 3318 3318_3878 9.36084e-12
r_519_1079_e 519 1079 13376.4
r_519_1079_i 519_1079 1079 93218.1
c_519_1079_i 519 519_1079 2.08965e-09
r_1079_1639_e 1079 1639 13376.4
r_1079_1639_i 1079_1639 1639 93218.1
c_1079_1639_i 1079 1079_1639 2.08965e-09
r_1639_2199_e 1639 2199 836.944
r_1639_2199_i 1639_2199 2199 4256.89
c_1639_2199_i 1639 1639_2199 4.67522e-10
r_2199_2759_e 2199 2759 836.944
r_2199_2759_i 2199_2759 2759 4256.89
c_2199_2759_i 2199 2199_2759 4.67522e-10
r_2759_3319_e 2759 3319 836.944
r_2759_3319_i 2759_3319 3319 4256.89
c_2759_3319_i 2759 2759_3319 4.67522e-10
r_3319_3879_e 3319 3879 13758.3
r_3319_3879_i 3319_3879 3879 95645.6
c_3319_3879_i 3319 3319_3879 9.36084e-12
r_520_1080_e 520 1080 13376.4
r_520_1080_i 520_1080 1080 93218.1
c_520_1080_i 520 520_1080 2.08965e-09
r_1080_1640_e 1080 1640 13376.4
r_1080_1640_i 1080_1640 1640 93218.1
c_1080_1640_i 1080 1080_1640 2.08965e-09
r_1640_2200_e 1640 2200 836.944
r_1640_2200_i 1640_2200 2200 4256.89
c_1640_2200_i 1640 1640_2200 4.67522e-10
r_2200_2760_e 2200 2760 836.944
r_2200_2760_i 2200_2760 2760 4256.89
c_2200_2760_i 2200 2200_2760 4.67522e-10
r_2760_3320_e 2760 3320 836.944
r_2760_3320_i 2760_3320 3320 4256.89
c_2760_3320_i 2760 2760_3320 4.67522e-10
r_3320_3880_e 3320 3880 13758.3
r_3320_3880_i 3320_3880 3880 95645.6
c_3320_3880_i 3320 3320_3880 9.36084e-12
r_521_1081_e 521 1081 13376.4
r_521_1081_i 521_1081 1081 93218.1
c_521_1081_i 521 521_1081 2.08965e-09
r_1081_1641_e 1081 1641 13376.4
r_1081_1641_i 1081_1641 1641 93218.1
c_1081_1641_i 1081 1081_1641 2.08965e-09
r_1641_2201_e 1641 2201 836.944
r_1641_2201_i 1641_2201 2201 4256.89
c_1641_2201_i 1641 1641_2201 4.67522e-10
r_2201_2761_e 2201 2761 836.944
r_2201_2761_i 2201_2761 2761 4256.89
c_2201_2761_i 2201 2201_2761 4.67522e-10
r_2761_3321_e 2761 3321 836.944
r_2761_3321_i 2761_3321 3321 4256.89
c_2761_3321_i 2761 2761_3321 4.67522e-10
r_3321_3881_e 3321 3881 13758.3
r_3321_3881_i 3321_3881 3881 95645.6
c_3321_3881_i 3321 3321_3881 9.36084e-12
r_522_1082_e 522 1082 13376.4
r_522_1082_i 522_1082 1082 93218.1
c_522_1082_i 522 522_1082 2.08965e-09
r_1082_1642_e 1082 1642 13376.4
r_1082_1642_i 1082_1642 1642 93218.1
c_1082_1642_i 1082 1082_1642 2.08965e-09
r_1642_2202_e 1642 2202 836.944
r_1642_2202_i 1642_2202 2202 4256.89
c_1642_2202_i 1642 1642_2202 4.67522e-10
r_2202_2762_e 2202 2762 836.944
r_2202_2762_i 2202_2762 2762 4256.89
c_2202_2762_i 2202 2202_2762 4.67522e-10
r_2762_3322_e 2762 3322 836.944
r_2762_3322_i 2762_3322 3322 4256.89
c_2762_3322_i 2762 2762_3322 4.67522e-10
r_3322_3882_e 3322 3882 13758.3
r_3322_3882_i 3322_3882 3882 95645.6
c_3322_3882_i 3322 3322_3882 9.36084e-12
r_523_1083_e 523 1083 13376.4
r_523_1083_i 523_1083 1083 93218.1
c_523_1083_i 523 523_1083 2.08965e-09
r_1083_1643_e 1083 1643 396.501
r_1083_1643_i 1083_1643 1643 1004.77
c_1083_1643_i 1083 1083_1643 1.65876e-10
r_1643_2203_e 1643 2203 836.944
r_1643_2203_i 1643_2203 2203 4256.89
c_1643_2203_i 1643 1643_2203 4.67522e-10
r_2203_2763_e 2203 2763 836.944
r_2203_2763_i 2203_2763 2763 4256.89
c_2203_2763_i 2203 2203_2763 4.67522e-10
r_2763_3323_e 2763 3323 836.944
r_2763_3323_i 2763_3323 3323 4256.89
c_2763_3323_i 2763 2763_3323 4.67522e-10
r_3323_3883_e 3323 3883 13758.3
r_3323_3883_i 3323_3883 3883 95645.6
c_3323_3883_i 3323 3323_3883 9.36084e-12
r_524_1084_e 524 1084 13376.4
r_524_1084_i 524_1084 1084 93218.1
c_524_1084_i 524 524_1084 2.08965e-09
r_1084_1644_e 1084 1644 396.501
r_1084_1644_i 1084_1644 1644 1004.77
c_1084_1644_i 1084 1084_1644 1.65876e-10
r_1644_2204_e 1644 2204 836.944
r_1644_2204_i 1644_2204 2204 4256.89
c_1644_2204_i 1644 1644_2204 4.67522e-10
r_2204_2764_e 2204 2764 836.944
r_2204_2764_i 2204_2764 2764 4256.89
c_2204_2764_i 2204 2204_2764 4.67522e-10
r_2764_3324_e 2764 3324 836.944
r_2764_3324_i 2764_3324 3324 4256.89
c_2764_3324_i 2764 2764_3324 4.67522e-10
r_3324_3884_e 3324 3884 13758.3
r_3324_3884_i 3324_3884 3884 95645.6
c_3324_3884_i 3324 3324_3884 9.36084e-12
r_525_1085_e 525 1085 13376.4
r_525_1085_i 525_1085 1085 93218.1
c_525_1085_i 525 525_1085 2.08965e-09
r_1085_1645_e 1085 1645 13376.4
r_1085_1645_i 1085_1645 1645 93218.1
c_1085_1645_i 1085 1085_1645 2.08965e-09
r_1645_2205_e 1645 2205 836.944
r_1645_2205_i 1645_2205 2205 4256.89
c_1645_2205_i 1645 1645_2205 4.67522e-10
r_2205_2765_e 2205 2765 836.944
r_2205_2765_i 2205_2765 2765 4256.89
c_2205_2765_i 2205 2205_2765 4.67522e-10
r_2765_3325_e 2765 3325 836.944
r_2765_3325_i 2765_3325 3325 4256.89
c_2765_3325_i 2765 2765_3325 4.67522e-10
r_3325_3885_e 3325 3885 13758.3
r_3325_3885_i 3325_3885 3885 95645.6
c_3325_3885_i 3325 3325_3885 9.36084e-12
r_526_1086_e 526 1086 13376.4
r_526_1086_i 526_1086 1086 93218.1
c_526_1086_i 526 526_1086 2.08965e-09
r_1086_1646_e 1086 1646 13376.4
r_1086_1646_i 1086_1646 1646 93218.1
c_1086_1646_i 1086 1086_1646 2.08965e-09
r_1646_2206_e 1646 2206 836.944
r_1646_2206_i 1646_2206 2206 4256.89
c_1646_2206_i 1646 1646_2206 4.67522e-10
r_2206_2766_e 2206 2766 836.944
r_2206_2766_i 2206_2766 2766 4256.89
c_2206_2766_i 2206 2206_2766 4.67522e-10
r_2766_3326_e 2766 3326 836.944
r_2766_3326_i 2766_3326 3326 4256.89
c_2766_3326_i 2766 2766_3326 4.67522e-10
r_3326_3886_e 3326 3886 13758.3
r_3326_3886_i 3326_3886 3886 95645.6
c_3326_3886_i 3326 3326_3886 9.36084e-12
r_527_1087_e 527 1087 13376.4
r_527_1087_i 527_1087 1087 93218.1
c_527_1087_i 527 527_1087 2.08965e-09
r_1087_1647_e 1087 1647 13376.4
r_1087_1647_i 1087_1647 1647 93218.1
c_1087_1647_i 1087 1087_1647 2.08965e-09
r_1647_2207_e 1647 2207 836.944
r_1647_2207_i 1647_2207 2207 4256.89
c_1647_2207_i 1647 1647_2207 4.67522e-10
r_2207_2767_e 2207 2767 836.944
r_2207_2767_i 2207_2767 2767 4256.89
c_2207_2767_i 2207 2207_2767 4.67522e-10
r_2767_3327_e 2767 3327 836.944
r_2767_3327_i 2767_3327 3327 4256.89
c_2767_3327_i 2767 2767_3327 4.67522e-10
r_3327_3887_e 3327 3887 13758.3
r_3327_3887_i 3327_3887 3887 95645.6
c_3327_3887_i 3327 3327_3887 9.36084e-12
r_528_1088_e 528 1088 13376.4
r_528_1088_i 528_1088 1088 93218.1
c_528_1088_i 528 528_1088 2.08965e-09
r_1088_1648_e 1088 1648 13376.4
r_1088_1648_i 1088_1648 1648 93218.1
c_1088_1648_i 1088 1088_1648 2.08965e-09
r_1648_2208_e 1648 2208 836.944
r_1648_2208_i 1648_2208 2208 4256.89
c_1648_2208_i 1648 1648_2208 4.67522e-10
r_2208_2768_e 2208 2768 836.944
r_2208_2768_i 2208_2768 2768 4256.89
c_2208_2768_i 2208 2208_2768 4.67522e-10
r_2768_3328_e 2768 3328 836.944
r_2768_3328_i 2768_3328 3328 4256.89
c_2768_3328_i 2768 2768_3328 4.67522e-10
r_3328_3888_e 3328 3888 13758.3
r_3328_3888_i 3328_3888 3888 95645.6
c_3328_3888_i 3328 3328_3888 9.36084e-12
r_529_1089_e 529 1089 13376.4
r_529_1089_i 529_1089 1089 93218.1
c_529_1089_i 529 529_1089 2.08965e-09
r_1089_1649_e 1089 1649 13376.4
r_1089_1649_i 1089_1649 1649 93218.1
c_1089_1649_i 1089 1089_1649 2.08965e-09
r_1649_2209_e 1649 2209 13376.4
r_1649_2209_i 1649_2209 2209 93218.1
c_1649_2209_i 1649 1649_2209 2.08965e-09
r_2209_2769_e 2209 2769 13376.4
r_2209_2769_i 2209_2769 2769 93218.1
c_2209_2769_i 2209 2209_2769 2.08965e-09
r_2769_3329_e 2769 3329 13376.4
r_2769_3329_i 2769_3329 3329 93218.1
c_2769_3329_i 2769 2769_3329 2.08965e-09
r_3329_3889_e 3329 3889 13376.4
r_3329_3889_i 3329_3889 3889 93218.1
c_3329_3889_i 3329 3329_3889 2.08965e-09
r_530_1090_e 530 1090 13376.4
r_530_1090_i 530_1090 1090 93218.1
c_530_1090_i 530 530_1090 2.08965e-09
r_1090_1650_e 1090 1650 13376.4
r_1090_1650_i 1090_1650 1650 93218.1
c_1090_1650_i 1090 1090_1650 2.08965e-09
r_1650_2210_e 1650 2210 13376.4
r_1650_2210_i 1650_2210 2210 93218.1
c_1650_2210_i 1650 1650_2210 2.08965e-09
r_2210_2770_e 2210 2770 13376.4
r_2210_2770_i 2210_2770 2770 93218.1
c_2210_2770_i 2210 2210_2770 2.08965e-09
r_2770_3330_e 2770 3330 13376.4
r_2770_3330_i 2770_3330 3330 93218.1
c_2770_3330_i 2770 2770_3330 2.08965e-09
r_3330_3890_e 3330 3890 13376.4
r_3330_3890_i 3330_3890 3890 93218.1
c_3330_3890_i 3330 3330_3890 2.08965e-09
r_531_1091_e 531 1091 13376.4
r_531_1091_i 531_1091 1091 93218.1
c_531_1091_i 531 531_1091 2.08965e-09
r_1091_1651_e 1091 1651 13376.4
r_1091_1651_i 1091_1651 1651 93218.1
c_1091_1651_i 1091 1091_1651 2.08965e-09
r_1651_2211_e 1651 2211 836.944
r_1651_2211_i 1651_2211 2211 4256.89
c_1651_2211_i 1651 1651_2211 4.67522e-10
r_2211_2771_e 2211 2771 836.944
r_2211_2771_i 2211_2771 2771 4256.89
c_2211_2771_i 2211 2211_2771 4.67522e-10
r_2771_3331_e 2771 3331 836.944
r_2771_3331_i 2771_3331 3331 4256.89
c_2771_3331_i 2771 2771_3331 4.67522e-10
r_3331_3891_e 3331 3891 836.944
r_3331_3891_i 3331_3891 3891 4256.89
c_3331_3891_i 3331 3331_3891 4.67522e-10
r_532_1092_e 532 1092 13376.4
r_532_1092_i 532_1092 1092 93218.1
c_532_1092_i 532 532_1092 2.08965e-09
r_1092_1652_e 1092 1652 13376.4
r_1092_1652_i 1092_1652 1652 93218.1
c_1092_1652_i 1092 1092_1652 2.08965e-09
r_1652_2212_e 1652 2212 836.944
r_1652_2212_i 1652_2212 2212 4256.89
c_1652_2212_i 1652 1652_2212 4.67522e-10
r_2212_2772_e 2212 2772 836.944
r_2212_2772_i 2212_2772 2772 4256.89
c_2212_2772_i 2212 2212_2772 4.67522e-10
r_2772_3332_e 2772 3332 836.944
r_2772_3332_i 2772_3332 3332 4256.89
c_2772_3332_i 2772 2772_3332 4.67522e-10
r_3332_3892_e 3332 3892 13758.3
r_3332_3892_i 3332_3892 3892 95645.6
c_3332_3892_i 3332 3332_3892 9.36084e-12
r_533_1093_e 533 1093 13376.4
r_533_1093_i 533_1093 1093 93218.1
c_533_1093_i 533 533_1093 2.08965e-09
r_1093_1653_e 1093 1653 13376.4
r_1093_1653_i 1093_1653 1653 93218.1
c_1093_1653_i 1093 1093_1653 2.08965e-09
r_1653_2213_e 1653 2213 836.944
r_1653_2213_i 1653_2213 2213 4256.89
c_1653_2213_i 1653 1653_2213 4.67522e-10
r_2213_2773_e 2213 2773 836.944
r_2213_2773_i 2213_2773 2773 4256.89
c_2213_2773_i 2213 2213_2773 4.67522e-10
r_2773_3333_e 2773 3333 836.944
r_2773_3333_i 2773_3333 3333 4256.89
c_2773_3333_i 2773 2773_3333 4.67522e-10
r_3333_3893_e 3333 3893 13758.3
r_3333_3893_i 3333_3893 3893 95645.6
c_3333_3893_i 3333 3333_3893 9.36084e-12
r_534_1094_e 534 1094 13376.4
r_534_1094_i 534_1094 1094 93218.1
c_534_1094_i 534 534_1094 2.08965e-09
r_1094_1654_e 1094 1654 13376.4
r_1094_1654_i 1094_1654 1654 93218.1
c_1094_1654_i 1094 1094_1654 2.08965e-09
r_1654_2214_e 1654 2214 836.944
r_1654_2214_i 1654_2214 2214 4256.89
c_1654_2214_i 1654 1654_2214 4.67522e-10
r_2214_2774_e 2214 2774 836.944
r_2214_2774_i 2214_2774 2774 4256.89
c_2214_2774_i 2214 2214_2774 4.67522e-10
r_2774_3334_e 2774 3334 836.944
r_2774_3334_i 2774_3334 3334 4256.89
c_2774_3334_i 2774 2774_3334 4.67522e-10
r_3334_3894_e 3334 3894 13758.3
r_3334_3894_i 3334_3894 3894 95645.6
c_3334_3894_i 3334 3334_3894 9.36084e-12
r_535_1095_e 535 1095 13376.4
r_535_1095_i 535_1095 1095 93218.1
c_535_1095_i 535 535_1095 2.08965e-09
r_1095_1655_e 1095 1655 13376.4
r_1095_1655_i 1095_1655 1655 93218.1
c_1095_1655_i 1095 1095_1655 2.08965e-09
r_1655_2215_e 1655 2215 836.944
r_1655_2215_i 1655_2215 2215 4256.89
c_1655_2215_i 1655 1655_2215 4.67522e-10
r_2215_2775_e 2215 2775 836.944
r_2215_2775_i 2215_2775 2775 4256.89
c_2215_2775_i 2215 2215_2775 4.67522e-10
r_2775_3335_e 2775 3335 836.944
r_2775_3335_i 2775_3335 3335 4256.89
c_2775_3335_i 2775 2775_3335 4.67522e-10
r_3335_3895_e 3335 3895 13758.3
r_3335_3895_i 3335_3895 3895 95645.6
c_3335_3895_i 3335 3335_3895 9.36084e-12
r_536_1096_e 536 1096 13376.4
r_536_1096_i 536_1096 1096 93218.1
c_536_1096_i 536 536_1096 2.08965e-09
r_1096_1656_e 1096 1656 13376.4
r_1096_1656_i 1096_1656 1656 93218.1
c_1096_1656_i 1096 1096_1656 2.08965e-09
r_1656_2216_e 1656 2216 836.944
r_1656_2216_i 1656_2216 2216 4256.89
c_1656_2216_i 1656 1656_2216 4.67522e-10
r_2216_2776_e 2216 2776 836.944
r_2216_2776_i 2216_2776 2776 4256.89
c_2216_2776_i 2216 2216_2776 4.67522e-10
r_2776_3336_e 2776 3336 836.944
r_2776_3336_i 2776_3336 3336 4256.89
c_2776_3336_i 2776 2776_3336 4.67522e-10
r_3336_3896_e 3336 3896 13758.3
r_3336_3896_i 3336_3896 3896 95645.6
c_3336_3896_i 3336 3336_3896 9.36084e-12
r_537_1097_e 537 1097 13376.4
r_537_1097_i 537_1097 1097 93218.1
c_537_1097_i 537 537_1097 2.08965e-09
r_1097_1657_e 1097 1657 13376.4
r_1097_1657_i 1097_1657 1657 93218.1
c_1097_1657_i 1097 1097_1657 2.08965e-09
r_1657_2217_e 1657 2217 836.944
r_1657_2217_i 1657_2217 2217 4256.89
c_1657_2217_i 1657 1657_2217 4.67522e-10
r_2217_2777_e 2217 2777 836.944
r_2217_2777_i 2217_2777 2777 4256.89
c_2217_2777_i 2217 2217_2777 4.67522e-10
r_2777_3337_e 2777 3337 836.944
r_2777_3337_i 2777_3337 3337 4256.89
c_2777_3337_i 2777 2777_3337 4.67522e-10
r_3337_3897_e 3337 3897 13758.3
r_3337_3897_i 3337_3897 3897 95645.6
c_3337_3897_i 3337 3337_3897 9.36084e-12
r_538_1098_e 538 1098 13376.4
r_538_1098_i 538_1098 1098 93218.1
c_538_1098_i 538 538_1098 2.08965e-09
r_1098_1658_e 1098 1658 13376.4
r_1098_1658_i 1098_1658 1658 93218.1
c_1098_1658_i 1098 1098_1658 2.08965e-09
r_1658_2218_e 1658 2218 836.944
r_1658_2218_i 1658_2218 2218 4256.89
c_1658_2218_i 1658 1658_2218 4.67522e-10
r_2218_2778_e 2218 2778 836.944
r_2218_2778_i 2218_2778 2778 4256.89
c_2218_2778_i 2218 2218_2778 4.67522e-10
r_2778_3338_e 2778 3338 836.944
r_2778_3338_i 2778_3338 3338 4256.89
c_2778_3338_i 2778 2778_3338 4.67522e-10
r_3338_3898_e 3338 3898 13758.3
r_3338_3898_i 3338_3898 3898 95645.6
c_3338_3898_i 3338 3338_3898 9.36084e-12
r_539_1099_e 539 1099 13376.4
r_539_1099_i 539_1099 1099 93218.1
c_539_1099_i 539 539_1099 2.08965e-09
r_1099_1659_e 1099 1659 396.493
r_1099_1659_i 1099_1659 1659 1004.75
c_1099_1659_i 1099 1099_1659 1.6588e-10
r_1659_2219_e 1659 2219 836.944
r_1659_2219_i 1659_2219 2219 4256.89
c_1659_2219_i 1659 1659_2219 4.67522e-10
r_2219_2779_e 2219 2779 836.944
r_2219_2779_i 2219_2779 2779 4256.89
c_2219_2779_i 2219 2219_2779 4.67522e-10
r_2779_3339_e 2779 3339 836.944
r_2779_3339_i 2779_3339 3339 4256.89
c_2779_3339_i 2779 2779_3339 4.67522e-10
r_3339_3899_e 3339 3899 13758.3
r_3339_3899_i 3339_3899 3899 95645.6
c_3339_3899_i 3339 3339_3899 9.36084e-12
r_540_1100_e 540 1100 13376.4
r_540_1100_i 540_1100 1100 93218.1
c_540_1100_i 540 540_1100 2.08965e-09
r_1100_1660_e 1100 1660 396.493
r_1100_1660_i 1100_1660 1660 1004.75
c_1100_1660_i 1100 1100_1660 1.6588e-10
r_1660_2220_e 1660 2220 836.944
r_1660_2220_i 1660_2220 2220 4256.89
c_1660_2220_i 1660 1660_2220 4.67522e-10
r_2220_2780_e 2220 2780 836.944
r_2220_2780_i 2220_2780 2780 4256.89
c_2220_2780_i 2220 2220_2780 4.67522e-10
r_2780_3340_e 2780 3340 836.944
r_2780_3340_i 2780_3340 3340 4256.89
c_2780_3340_i 2780 2780_3340 4.67522e-10
r_3340_3900_e 3340 3900 13758.3
r_3340_3900_i 3340_3900 3900 95645.6
c_3340_3900_i 3340 3340_3900 9.36084e-12
r_541_1101_e 541 1101 13376.4
r_541_1101_i 541_1101 1101 93218.1
c_541_1101_i 541 541_1101 2.08965e-09
r_1101_1661_e 1101 1661 13376.4
r_1101_1661_i 1101_1661 1661 93218.1
c_1101_1661_i 1101 1101_1661 2.08965e-09
r_1661_2221_e 1661 2221 836.944
r_1661_2221_i 1661_2221 2221 4256.89
c_1661_2221_i 1661 1661_2221 4.67522e-10
r_2221_2781_e 2221 2781 836.944
r_2221_2781_i 2221_2781 2781 4256.89
c_2221_2781_i 2221 2221_2781 4.67522e-10
r_2781_3341_e 2781 3341 836.944
r_2781_3341_i 2781_3341 3341 4256.89
c_2781_3341_i 2781 2781_3341 4.67522e-10
r_3341_3901_e 3341 3901 13758.3
r_3341_3901_i 3341_3901 3901 95645.6
c_3341_3901_i 3341 3341_3901 9.36084e-12
r_542_1102_e 542 1102 13376.4
r_542_1102_i 542_1102 1102 93218.1
c_542_1102_i 542 542_1102 2.08965e-09
r_1102_1662_e 1102 1662 13376.4
r_1102_1662_i 1102_1662 1662 93218.1
c_1102_1662_i 1102 1102_1662 2.08965e-09
r_1662_2222_e 1662 2222 836.944
r_1662_2222_i 1662_2222 2222 4256.89
c_1662_2222_i 1662 1662_2222 4.67522e-10
r_2222_2782_e 2222 2782 836.944
r_2222_2782_i 2222_2782 2782 4256.89
c_2222_2782_i 2222 2222_2782 4.67522e-10
r_2782_3342_e 2782 3342 836.944
r_2782_3342_i 2782_3342 3342 4256.89
c_2782_3342_i 2782 2782_3342 4.67522e-10
r_3342_3902_e 3342 3902 13758.3
r_3342_3902_i 3342_3902 3902 95645.6
c_3342_3902_i 3342 3342_3902 9.36084e-12
r_543_1103_e 543 1103 13376.4
r_543_1103_i 543_1103 1103 93218.1
c_543_1103_i 543 543_1103 2.08965e-09
r_1103_1663_e 1103 1663 13376.4
r_1103_1663_i 1103_1663 1663 93218.1
c_1103_1663_i 1103 1103_1663 2.08965e-09
r_1663_2223_e 1663 2223 836.944
r_1663_2223_i 1663_2223 2223 4256.89
c_1663_2223_i 1663 1663_2223 4.67522e-10
r_2223_2783_e 2223 2783 836.944
r_2223_2783_i 2223_2783 2783 4256.89
c_2223_2783_i 2223 2223_2783 4.67522e-10
r_2783_3343_e 2783 3343 836.944
r_2783_3343_i 2783_3343 3343 4256.89
c_2783_3343_i 2783 2783_3343 4.67522e-10
r_3343_3903_e 3343 3903 13758.3
r_3343_3903_i 3343_3903 3903 95645.6
c_3343_3903_i 3343 3343_3903 9.36084e-12
r_544_1104_e 544 1104 13376.4
r_544_1104_i 544_1104 1104 93218.1
c_544_1104_i 544 544_1104 2.08965e-09
r_1104_1664_e 1104 1664 13376.4
r_1104_1664_i 1104_1664 1664 93218.1
c_1104_1664_i 1104 1104_1664 2.08965e-09
r_1664_2224_e 1664 2224 836.944
r_1664_2224_i 1664_2224 2224 4256.89
c_1664_2224_i 1664 1664_2224 4.67522e-10
r_2224_2784_e 2224 2784 836.944
r_2224_2784_i 2224_2784 2784 4256.89
c_2224_2784_i 2224 2224_2784 4.67522e-10
r_2784_3344_e 2784 3344 836.944
r_2784_3344_i 2784_3344 3344 4256.89
c_2784_3344_i 2784 2784_3344 4.67522e-10
r_3344_3904_e 3344 3904 13758.3
r_3344_3904_i 3344_3904 3904 95645.6
c_3344_3904_i 3344 3344_3904 9.36084e-12
r_545_1105_e 545 1105 13376.4
r_545_1105_i 545_1105 1105 93218.1
c_545_1105_i 545 545_1105 2.08965e-09
r_1105_1665_e 1105 1665 13376.4
r_1105_1665_i 1105_1665 1665 93218.1
c_1105_1665_i 1105 1105_1665 2.08965e-09
r_1665_2225_e 1665 2225 13376.4
r_1665_2225_i 1665_2225 2225 93218.1
c_1665_2225_i 1665 1665_2225 2.08965e-09
r_2225_2785_e 2225 2785 13376.4
r_2225_2785_i 2225_2785 2785 93218.1
c_2225_2785_i 2225 2225_2785 2.08965e-09
r_2785_3345_e 2785 3345 13376.4
r_2785_3345_i 2785_3345 3345 93218.1
c_2785_3345_i 2785 2785_3345 2.08965e-09
r_3345_3905_e 3345 3905 13376.4
r_3345_3905_i 3345_3905 3905 93218.1
c_3345_3905_i 3345 3345_3905 2.08965e-09
r_546_1106_e 546 1106 13376.4
r_546_1106_i 546_1106 1106 93218.1
c_546_1106_i 546 546_1106 2.08965e-09
r_1106_1666_e 1106 1666 13376.4
r_1106_1666_i 1106_1666 1666 93218.1
c_1106_1666_i 1106 1106_1666 2.08965e-09
r_1666_2226_e 1666 2226 13376.4
r_1666_2226_i 1666_2226 2226 93218.1
c_1666_2226_i 1666 1666_2226 2.08965e-09
r_2226_2786_e 2226 2786 13376.4
r_2226_2786_i 2226_2786 2786 93218.1
c_2226_2786_i 2226 2226_2786 2.08965e-09
r_2786_3346_e 2786 3346 13376.4
r_2786_3346_i 2786_3346 3346 93218.1
c_2786_3346_i 2786 2786_3346 2.08965e-09
r_3346_3906_e 3346 3906 13376.4
r_3346_3906_i 3346_3906 3906 93218.1
c_3346_3906_i 3346 3346_3906 2.08965e-09
r_547_1107_e 547 1107 13376.4
r_547_1107_i 547_1107 1107 93218.1
c_547_1107_i 547 547_1107 2.08965e-09
r_1107_1667_e 1107 1667 13376.4
r_1107_1667_i 1107_1667 1667 93218.1
c_1107_1667_i 1107 1107_1667 2.08965e-09
r_1667_2227_e 1667 2227 836.944
r_1667_2227_i 1667_2227 2227 4256.89
c_1667_2227_i 1667 1667_2227 4.67522e-10
r_2227_2787_e 2227 2787 836.944
r_2227_2787_i 2227_2787 2787 4256.89
c_2227_2787_i 2227 2227_2787 4.67522e-10
r_2787_3347_e 2787 3347 836.944
r_2787_3347_i 2787_3347 3347 4256.89
c_2787_3347_i 2787 2787_3347 4.67522e-10
r_3347_3907_e 3347 3907 836.944
r_3347_3907_i 3347_3907 3907 4256.89
c_3347_3907_i 3347 3347_3907 4.67522e-10
r_548_1108_e 548 1108 13376.4
r_548_1108_i 548_1108 1108 93218.1
c_548_1108_i 548 548_1108 2.08965e-09
r_1108_1668_e 1108 1668 13376.4
r_1108_1668_i 1108_1668 1668 93218.1
c_1108_1668_i 1108 1108_1668 2.08965e-09
r_1668_2228_e 1668 2228 836.944
r_1668_2228_i 1668_2228 2228 4256.89
c_1668_2228_i 1668 1668_2228 4.67522e-10
r_2228_2788_e 2228 2788 836.944
r_2228_2788_i 2228_2788 2788 4256.89
c_2228_2788_i 2228 2228_2788 4.67522e-10
r_2788_3348_e 2788 3348 836.944
r_2788_3348_i 2788_3348 3348 4256.89
c_2788_3348_i 2788 2788_3348 4.67522e-10
r_3348_3908_e 3348 3908 13758.3
r_3348_3908_i 3348_3908 3908 95645.6
c_3348_3908_i 3348 3348_3908 9.36084e-12
r_549_1109_e 549 1109 13376.4
r_549_1109_i 549_1109 1109 93218.1
c_549_1109_i 549 549_1109 2.08965e-09
r_1109_1669_e 1109 1669 13376.4
r_1109_1669_i 1109_1669 1669 93218.1
c_1109_1669_i 1109 1109_1669 2.08965e-09
r_1669_2229_e 1669 2229 836.944
r_1669_2229_i 1669_2229 2229 4256.89
c_1669_2229_i 1669 1669_2229 4.67522e-10
r_2229_2789_e 2229 2789 836.944
r_2229_2789_i 2229_2789 2789 4256.89
c_2229_2789_i 2229 2229_2789 4.67522e-10
r_2789_3349_e 2789 3349 836.944
r_2789_3349_i 2789_3349 3349 4256.89
c_2789_3349_i 2789 2789_3349 4.67522e-10
r_3349_3909_e 3349 3909 13758.3
r_3349_3909_i 3349_3909 3909 95645.6
c_3349_3909_i 3349 3349_3909 9.36084e-12
r_550_1110_e 550 1110 13376.4
r_550_1110_i 550_1110 1110 93218.1
c_550_1110_i 550 550_1110 2.08965e-09
r_1110_1670_e 1110 1670 13376.4
r_1110_1670_i 1110_1670 1670 93218.1
c_1110_1670_i 1110 1110_1670 2.08965e-09
r_1670_2230_e 1670 2230 836.944
r_1670_2230_i 1670_2230 2230 4256.89
c_1670_2230_i 1670 1670_2230 4.67522e-10
r_2230_2790_e 2230 2790 836.944
r_2230_2790_i 2230_2790 2790 4256.89
c_2230_2790_i 2230 2230_2790 4.67522e-10
r_2790_3350_e 2790 3350 836.944
r_2790_3350_i 2790_3350 3350 4256.89
c_2790_3350_i 2790 2790_3350 4.67522e-10
r_3350_3910_e 3350 3910 13758.3
r_3350_3910_i 3350_3910 3910 95645.6
c_3350_3910_i 3350 3350_3910 9.36084e-12
r_551_1111_e 551 1111 13376.4
r_551_1111_i 551_1111 1111 93218.1
c_551_1111_i 551 551_1111 2.08965e-09
r_1111_1671_e 1111 1671 13376.4
r_1111_1671_i 1111_1671 1671 93218.1
c_1111_1671_i 1111 1111_1671 2.08965e-09
r_1671_2231_e 1671 2231 836.944
r_1671_2231_i 1671_2231 2231 4256.89
c_1671_2231_i 1671 1671_2231 4.67522e-10
r_2231_2791_e 2231 2791 836.944
r_2231_2791_i 2231_2791 2791 4256.89
c_2231_2791_i 2231 2231_2791 4.67522e-10
r_2791_3351_e 2791 3351 836.944
r_2791_3351_i 2791_3351 3351 4256.89
c_2791_3351_i 2791 2791_3351 4.67522e-10
r_3351_3911_e 3351 3911 13758.3
r_3351_3911_i 3351_3911 3911 95645.6
c_3351_3911_i 3351 3351_3911 9.36084e-12
r_552_1112_e 552 1112 13376.4
r_552_1112_i 552_1112 1112 93218.1
c_552_1112_i 552 552_1112 2.08965e-09
r_1112_1672_e 1112 1672 13376.4
r_1112_1672_i 1112_1672 1672 93218.1
c_1112_1672_i 1112 1112_1672 2.08965e-09
r_1672_2232_e 1672 2232 836.944
r_1672_2232_i 1672_2232 2232 4256.89
c_1672_2232_i 1672 1672_2232 4.67522e-10
r_2232_2792_e 2232 2792 836.944
r_2232_2792_i 2232_2792 2792 4256.89
c_2232_2792_i 2232 2232_2792 4.67522e-10
r_2792_3352_e 2792 3352 836.944
r_2792_3352_i 2792_3352 3352 4256.89
c_2792_3352_i 2792 2792_3352 4.67522e-10
r_3352_3912_e 3352 3912 13758.3
r_3352_3912_i 3352_3912 3912 95645.6
c_3352_3912_i 3352 3352_3912 9.36084e-12
r_553_1113_e 553 1113 13376.4
r_553_1113_i 553_1113 1113 93218.1
c_553_1113_i 553 553_1113 2.08965e-09
r_1113_1673_e 1113 1673 13376.4
r_1113_1673_i 1113_1673 1673 93218.1
c_1113_1673_i 1113 1113_1673 2.08965e-09
r_1673_2233_e 1673 2233 836.944
r_1673_2233_i 1673_2233 2233 4256.89
c_1673_2233_i 1673 1673_2233 4.67522e-10
r_2233_2793_e 2233 2793 836.944
r_2233_2793_i 2233_2793 2793 4256.89
c_2233_2793_i 2233 2233_2793 4.67522e-10
r_2793_3353_e 2793 3353 836.944
r_2793_3353_i 2793_3353 3353 4256.89
c_2793_3353_i 2793 2793_3353 4.67522e-10
r_3353_3913_e 3353 3913 13758.3
r_3353_3913_i 3353_3913 3913 95645.6
c_3353_3913_i 3353 3353_3913 9.36084e-12
r_554_1114_e 554 1114 13376.4
r_554_1114_i 554_1114 1114 93218.1
c_554_1114_i 554 554_1114 2.08965e-09
r_1114_1674_e 1114 1674 13376.4
r_1114_1674_i 1114_1674 1674 93218.1
c_1114_1674_i 1114 1114_1674 2.08965e-09
r_1674_2234_e 1674 2234 836.944
r_1674_2234_i 1674_2234 2234 4256.89
c_1674_2234_i 1674 1674_2234 4.67522e-10
r_2234_2794_e 2234 2794 836.944
r_2234_2794_i 2234_2794 2794 4256.89
c_2234_2794_i 2234 2234_2794 4.67522e-10
r_2794_3354_e 2794 3354 836.944
r_2794_3354_i 2794_3354 3354 4256.89
c_2794_3354_i 2794 2794_3354 4.67522e-10
r_3354_3914_e 3354 3914 13758.3
r_3354_3914_i 3354_3914 3914 95645.6
c_3354_3914_i 3354 3354_3914 9.36084e-12
r_555_1115_e 555 1115 13376.4
r_555_1115_i 555_1115 1115 93218.1
c_555_1115_i 555 555_1115 2.08965e-09
r_1115_1675_e 1115 1675 396.485
r_1115_1675_i 1115_1675 1675 1004.73
c_1115_1675_i 1115 1115_1675 1.65883e-10
r_1675_2235_e 1675 2235 836.944
r_1675_2235_i 1675_2235 2235 4256.89
c_1675_2235_i 1675 1675_2235 4.67522e-10
r_2235_2795_e 2235 2795 836.944
r_2235_2795_i 2235_2795 2795 4256.89
c_2235_2795_i 2235 2235_2795 4.67522e-10
r_2795_3355_e 2795 3355 836.944
r_2795_3355_i 2795_3355 3355 4256.89
c_2795_3355_i 2795 2795_3355 4.67522e-10
r_3355_3915_e 3355 3915 13758.3
r_3355_3915_i 3355_3915 3915 95645.6
c_3355_3915_i 3355 3355_3915 9.36084e-12
r_556_1116_e 556 1116 13376.4
r_556_1116_i 556_1116 1116 93218.1
c_556_1116_i 556 556_1116 2.08965e-09
r_1116_1676_e 1116 1676 396.485
r_1116_1676_i 1116_1676 1676 1004.73
c_1116_1676_i 1116 1116_1676 1.65883e-10
r_1676_2236_e 1676 2236 836.944
r_1676_2236_i 1676_2236 2236 4256.89
c_1676_2236_i 1676 1676_2236 4.67522e-10
r_2236_2796_e 2236 2796 836.944
r_2236_2796_i 2236_2796 2796 4256.89
c_2236_2796_i 2236 2236_2796 4.67522e-10
r_2796_3356_e 2796 3356 836.944
r_2796_3356_i 2796_3356 3356 4256.89
c_2796_3356_i 2796 2796_3356 4.67522e-10
r_3356_3916_e 3356 3916 13758.3
r_3356_3916_i 3356_3916 3916 95645.6
c_3356_3916_i 3356 3356_3916 9.36084e-12
r_557_1117_e 557 1117 13376.4
r_557_1117_i 557_1117 1117 93218.1
c_557_1117_i 557 557_1117 2.08965e-09
r_1117_1677_e 1117 1677 13376.4
r_1117_1677_i 1117_1677 1677 93218.1
c_1117_1677_i 1117 1117_1677 2.08965e-09
r_1677_2237_e 1677 2237 836.944
r_1677_2237_i 1677_2237 2237 4256.89
c_1677_2237_i 1677 1677_2237 4.67522e-10
r_2237_2797_e 2237 2797 836.944
r_2237_2797_i 2237_2797 2797 4256.89
c_2237_2797_i 2237 2237_2797 4.67522e-10
r_2797_3357_e 2797 3357 836.944
r_2797_3357_i 2797_3357 3357 4256.89
c_2797_3357_i 2797 2797_3357 4.67522e-10
r_3357_3917_e 3357 3917 13758.3
r_3357_3917_i 3357_3917 3917 95645.6
c_3357_3917_i 3357 3357_3917 9.36084e-12
r_558_1118_e 558 1118 13376.4
r_558_1118_i 558_1118 1118 93218.1
c_558_1118_i 558 558_1118 2.08965e-09
r_1118_1678_e 1118 1678 13376.4
r_1118_1678_i 1118_1678 1678 93218.1
c_1118_1678_i 1118 1118_1678 2.08965e-09
r_1678_2238_e 1678 2238 836.944
r_1678_2238_i 1678_2238 2238 4256.89
c_1678_2238_i 1678 1678_2238 4.67522e-10
r_2238_2798_e 2238 2798 836.944
r_2238_2798_i 2238_2798 2798 4256.89
c_2238_2798_i 2238 2238_2798 4.67522e-10
r_2798_3358_e 2798 3358 836.944
r_2798_3358_i 2798_3358 3358 4256.89
c_2798_3358_i 2798 2798_3358 4.67522e-10
r_3358_3918_e 3358 3918 13758.3
r_3358_3918_i 3358_3918 3918 95645.6
c_3358_3918_i 3358 3358_3918 9.36084e-12
r_559_1119_e 559 1119 13376.4
r_559_1119_i 559_1119 1119 93218.1
c_559_1119_i 559 559_1119 2.08965e-09
r_1119_1679_e 1119 1679 13376.4
r_1119_1679_i 1119_1679 1679 93218.1
c_1119_1679_i 1119 1119_1679 2.08965e-09
r_1679_2239_e 1679 2239 836.944
r_1679_2239_i 1679_2239 2239 4256.89
c_1679_2239_i 1679 1679_2239 4.67522e-10
r_2239_2799_e 2239 2799 836.944
r_2239_2799_i 2239_2799 2799 4256.89
c_2239_2799_i 2239 2239_2799 4.67522e-10
r_2799_3359_e 2799 3359 836.944
r_2799_3359_i 2799_3359 3359 4256.89
c_2799_3359_i 2799 2799_3359 4.67522e-10
r_3359_3919_e 3359 3919 13758.3
r_3359_3919_i 3359_3919 3919 95645.6
c_3359_3919_i 3359 3359_3919 9.36084e-12
r_560_1120_e 560 1120 13376.4
r_560_1120_i 560_1120 1120 93218.1
c_560_1120_i 560 560_1120 2.08965e-09
r_1120_1680_e 1120 1680 13376.4
r_1120_1680_i 1120_1680 1680 93218.1
c_1120_1680_i 1120 1120_1680 2.08965e-09
r_1680_2240_e 1680 2240 836.944
r_1680_2240_i 1680_2240 2240 4256.89
c_1680_2240_i 1680 1680_2240 4.67522e-10
r_2240_2800_e 2240 2800 836.944
r_2240_2800_i 2240_2800 2800 4256.89
c_2240_2800_i 2240 2240_2800 4.67522e-10
r_2800_3360_e 2800 3360 836.944
r_2800_3360_i 2800_3360 3360 4256.89
c_2800_3360_i 2800 2800_3360 4.67522e-10
r_3360_3920_e 3360 3920 13758.3
r_3360_3920_i 3360_3920 3920 95645.6
c_3360_3920_i 3360 3360_3920 9.36084e-12
r1_s1_n1_136_se 136 136_se_i 1.04496e+06
c1_s1_n1_136_se 136 136_se_i 2.93293e-10
r2_s1_n1_136_se 136_se 136_se_i 24231.3
c2_s1_n1_136_se 136_se 136_se_i 2.53213e-11
r1_s1_n2_216_se 216 216_se_i 1.04496e+06
c1_s1_n2_216_se 216 216_se_i 2.93293e-10
r2_s1_n2_216_se 216_se 216_se_i 24231.3
c2_s1_n2_216_se 216_se 216_se_i 2.53213e-11
r1_s1_n1_137_se 137 137_se_i 1.04496e+06
c1_s1_n1_137_se 137 137_se_i 2.93293e-10
r2_s1_n1_137_se 137_se 137_se_i 24231.3
c2_s1_n1_137_se 137_se 137_se_i 2.53213e-11
r1_s1_n2_217_se 217 217_se_i 1.04496e+06
c1_s1_n2_217_se 217 217_se_i 2.93293e-10
r2_s1_n2_217_se 217_se 217_se_i 24231.3
c2_s1_n2_217_se 217_se 217_se_i 2.53213e-11
r1_s1_n1_138_se 138 138_se_i 1.04496e+06
c1_s1_n1_138_se 138 138_se_i 2.93293e-10
r2_s1_n1_138_se 138_se 138_se_i 24231.3
c2_s1_n1_138_se 138_se 138_se_i 2.53213e-11
r1_s1_n2_218_se 218 218_se_i 1.04496e+06
c1_s1_n2_218_se 218 218_se_i 2.93293e-10
r2_s1_n2_218_se 218_se 218_se_i 24231.3
c2_s1_n2_218_se 218_se 218_se_i 2.53213e-11
r1_s1_n1_139_se 139 139_se_i 1.04496e+06
c1_s1_n1_139_se 139 139_se_i 2.93293e-10
r2_s1_n1_139_se 139_se 139_se_i 24231.3
c2_s1_n1_139_se 139_se 139_se_i 2.53213e-11
r1_s1_n2_219_se 219 219_se_i 1.04496e+06
c1_s1_n2_219_se 219 219_se_i 2.93293e-10
r2_s1_n2_219_se 219_se 219_se_i 24231.3
c2_s1_n2_219_se 219_se 219_se_i 2.53213e-11
r1_s1_n1_140_se 140 140_se_i 1.04496e+06
c1_s1_n1_140_se 140 140_se_i 2.93293e-10
r2_s1_n1_140_se 140_se 140_se_i 24231.3
c2_s1_n1_140_se 140_se 140_se_i 2.53213e-11
r1_s1_n2_220_se 220 220_se_i 1.04496e+06
c1_s1_n2_220_se 220 220_se_i 2.93293e-10
r2_s1_n2_220_se 220_se 220_se_i 24231.3
c2_s1_n2_220_se 220_se 220_se_i 2.53213e-11
r1_s1_n1_141_se 141 141_se_i 1.04496e+06
c1_s1_n1_141_se 141 141_se_i 2.93293e-10
r2_s1_n1_141_se 141_se 141_se_i 24231.3
c2_s1_n1_141_se 141_se 141_se_i 2.53213e-11
r1_s1_n2_221_se 221 221_se_i 1.04496e+06
c1_s1_n2_221_se 221 221_se_i 2.93293e-10
r2_s1_n2_221_se 221_se 221_se_i 24231.3
c2_s1_n2_221_se 221_se 221_se_i 2.53213e-11
r1_s1_n1_142_se 142 142_se_i 1.04496e+06
c1_s1_n1_142_se 142 142_se_i 2.93293e-10
r2_s1_n1_142_se 142_se 142_se_i 24231.3
c2_s1_n1_142_se 142_se 142_se_i 2.53213e-11
r1_s1_n2_222_se 222 222_se_i 1.04496e+06
c1_s1_n2_222_se 222 222_se_i 2.93293e-10
r2_s1_n2_222_se 222_se 222_se_i 24231.3
c2_s1_n2_222_se 222_se 222_se_i 2.53213e-11
r1_s1_n1_143_se 143 143_se_i 1.04496e+06
c1_s1_n1_143_se 143 143_se_i 2.93293e-10
r2_s1_n1_143_se 143_se 143_se_i 24231.3
c2_s1_n1_143_se 143_se 143_se_i 2.53213e-11
r1_s1_n2_223_se 223 223_se_i 1.04496e+06
c1_s1_n2_223_se 223 223_se_i 2.93293e-10
r2_s1_n2_223_se 223_se 223_se_i 24231.3
c2_s1_n2_223_se 223_se 223_se_i 2.53213e-11
r1_s1_n1_152_se 152 152_se_i 1.04496e+06
c1_s1_n1_152_se 152 152_se_i 2.93293e-10
r2_s1_n1_152_se 152_se 152_se_i 24231.3
c2_s1_n1_152_se 152_se 152_se_i 2.53213e-11
r1_s1_n2_232_se 232 232_se_i 1.04496e+06
c1_s1_n2_232_se 232 232_se_i 2.93293e-10
r2_s1_n2_232_se 232_se 232_se_i 24231.3
c2_s1_n2_232_se 232_se 232_se_i 2.53213e-11
r1_s1_n1_153_se 153 153_se_i 1.04496e+06
c1_s1_n1_153_se 153 153_se_i 2.93293e-10
r2_s1_n1_153_se 153_se 153_se_i 24231.3
c2_s1_n1_153_se 153_se 153_se_i 2.53213e-11
r1_s1_n2_233_se 233 233_se_i 1.04496e+06
c1_s1_n2_233_se 233 233_se_i 2.93293e-10
r2_s1_n2_233_se 233_se 233_se_i 24231.3
c2_s1_n2_233_se 233_se 233_se_i 2.53213e-11
r1_s1_n1_154_se 154 154_se_i 1.04496e+06
c1_s1_n1_154_se 154 154_se_i 2.93293e-10
r2_s1_n1_154_se 154_se 154_se_i 24231.3
c2_s1_n1_154_se 154_se 154_se_i 2.53213e-11
r1_s1_n2_234_se 234 234_se_i 1.04496e+06
c1_s1_n2_234_se 234 234_se_i 2.93293e-10
r2_s1_n2_234_se 234_se 234_se_i 24231.3
c2_s1_n2_234_se 234_se 234_se_i 2.53213e-11
r1_s1_n1_155_se 155 155_se_i 1.04496e+06
c1_s1_n1_155_se 155 155_se_i 2.93293e-10
r2_s1_n1_155_se 155_se 155_se_i 24231.3
c2_s1_n1_155_se 155_se 155_se_i 2.53213e-11
r1_s1_n2_235_se 235 235_se_i 1.04496e+06
c1_s1_n2_235_se 235 235_se_i 2.93293e-10
r2_s1_n2_235_se 235_se 235_se_i 24231.3
c2_s1_n2_235_se 235_se 235_se_i 2.53213e-11
r1_s1_n1_156_se 156 156_se_i 1.04496e+06
c1_s1_n1_156_se 156 156_se_i 2.93293e-10
r2_s1_n1_156_se 156_se 156_se_i 24231.3
c2_s1_n1_156_se 156_se 156_se_i 2.53213e-11
r1_s1_n2_236_se 236 236_se_i 1.04496e+06
c1_s1_n2_236_se 236 236_se_i 2.93293e-10
r2_s1_n2_236_se 236_se 236_se_i 24231.3
c2_s1_n2_236_se 236_se 236_se_i 2.53213e-11
r1_s1_n1_157_se 157 157_se_i 1.04496e+06
c1_s1_n1_157_se 157 157_se_i 2.93293e-10
r2_s1_n1_157_se 157_se 157_se_i 24231.3
c2_s1_n1_157_se 157_se 157_se_i 2.53213e-11
r1_s1_n2_237_se 237 237_se_i 1.04496e+06
c1_s1_n2_237_se 237 237_se_i 2.93293e-10
r2_s1_n2_237_se 237_se 237_se_i 24231.3
c2_s1_n2_237_se 237_se 237_se_i 2.53213e-11
r1_s1_n1_158_se 158 158_se_i 1.04496e+06
c1_s1_n1_158_se 158 158_se_i 2.93293e-10
r2_s1_n1_158_se 158_se 158_se_i 24231.3
c2_s1_n1_158_se 158_se 158_se_i 2.53213e-11
r1_s1_n2_238_se 238 238_se_i 1.04496e+06
c1_s1_n2_238_se 238 238_se_i 2.93293e-10
r2_s1_n2_238_se 238_se 238_se_i 24231.3
c2_s1_n2_238_se 238_se 238_se_i 2.53213e-11
r1_s1_n1_159_se 159 159_se_i 1.04496e+06
c1_s1_n1_159_se 159 159_se_i 2.93293e-10
r2_s1_n1_159_se 159_se 159_se_i 24231.3
c2_s1_n1_159_se 159_se 159_se_i 2.53213e-11
r1_s1_n2_239_se 239 239_se_i 1.04496e+06
c1_s1_n2_239_se 239 239_se_i 2.93293e-10
r2_s1_n2_239_se 239_se 239_se_i 24231.3
c2_s1_n2_239_se 239_se 239_se_i 2.53213e-11
r1_s1_n1_168_se 168 168_se_i 1.04496e+06
c1_s1_n1_168_se 168 168_se_i 2.93293e-10
r2_s1_n1_168_se 168_se 168_se_i 24231.3
c2_s1_n1_168_se 168_se 168_se_i 2.53213e-11
r1_s1_n2_248_se 248 248_se_i 1.04496e+06
c1_s1_n2_248_se 248 248_se_i 2.93293e-10
r2_s1_n2_248_se 248_se 248_se_i 24231.3
c2_s1_n2_248_se 248_se 248_se_i 2.53213e-11
r1_s1_n1_169_se 169 169_se_i 1.04496e+06
c1_s1_n1_169_se 169 169_se_i 2.93293e-10
r2_s1_n1_169_se 169_se 169_se_i 24231.3
c2_s1_n1_169_se 169_se 169_se_i 2.53213e-11
r1_s1_n2_249_se 249 249_se_i 1.04496e+06
c1_s1_n2_249_se 249 249_se_i 2.93293e-10
r2_s1_n2_249_se 249_se 249_se_i 24231.3
c2_s1_n2_249_se 249_se 249_se_i 2.53213e-11
r1_s1_n1_170_se 170 170_se_i 1.04496e+06
c1_s1_n1_170_se 170 170_se_i 2.93293e-10
r2_s1_n1_170_se 170_se 170_se_i 24231.3
c2_s1_n1_170_se 170_se 170_se_i 2.53213e-11
r1_s1_n2_250_se 250 250_se_i 1.04496e+06
c1_s1_n2_250_se 250 250_se_i 2.93293e-10
r2_s1_n2_250_se 250_se 250_se_i 24231.3
c2_s1_n2_250_se 250_se 250_se_i 2.53213e-11
r1_s1_n1_171_se 171 171_se_i 1.04496e+06
c1_s1_n1_171_se 171 171_se_i 2.93293e-10
r2_s1_n1_171_se 171_se 171_se_i 24231.3
c2_s1_n1_171_se 171_se 171_se_i 2.53213e-11
r1_s1_n2_251_se 251 251_se_i 1.04496e+06
c1_s1_n2_251_se 251 251_se_i 2.93293e-10
r2_s1_n2_251_se 251_se 251_se_i 24231.3
c2_s1_n2_251_se 251_se 251_se_i 2.53213e-11
r1_s1_n1_172_se 172 172_se_i 1.04496e+06
c1_s1_n1_172_se 172 172_se_i 2.93293e-10
r2_s1_n1_172_se 172_se 172_se_i 24231.3
c2_s1_n1_172_se 172_se 172_se_i 2.53213e-11
r1_s1_n2_252_se 252 252_se_i 1.04496e+06
c1_s1_n2_252_se 252 252_se_i 2.93293e-10
r2_s1_n2_252_se 252_se 252_se_i 24231.3
c2_s1_n2_252_se 252_se 252_se_i 2.53213e-11
r1_s1_n1_173_se 173 173_se_i 1.04496e+06
c1_s1_n1_173_se 173 173_se_i 2.93293e-10
r2_s1_n1_173_se 173_se 173_se_i 24231.3
c2_s1_n1_173_se 173_se 173_se_i 2.53213e-11
r1_s1_n2_253_se 253 253_se_i 1.04496e+06
c1_s1_n2_253_se 253 253_se_i 2.93293e-10
r2_s1_n2_253_se 253_se 253_se_i 24231.3
c2_s1_n2_253_se 253_se 253_se_i 2.53213e-11
r1_s1_n1_174_se 174 174_se_i 1.04496e+06
c1_s1_n1_174_se 174 174_se_i 2.93293e-10
r2_s1_n1_174_se 174_se 174_se_i 24231.3
c2_s1_n1_174_se 174_se 174_se_i 2.53213e-11
r1_s1_n2_254_se 254 254_se_i 1.04496e+06
c1_s1_n2_254_se 254 254_se_i 2.93293e-10
r2_s1_n2_254_se 254_se 254_se_i 24231.3
c2_s1_n2_254_se 254_se 254_se_i 2.53213e-11
r1_s1_n1_175_se 175 175_se_i 1.04496e+06
c1_s1_n1_175_se 175 175_se_i 2.93293e-10
r2_s1_n1_175_se 175_se 175_se_i 24231.3
c2_s1_n1_175_se 175_se 175_se_i 2.53213e-11
r1_s1_n2_255_se 255 255_se_i 1.04496e+06
c1_s1_n2_255_se 255 255_se_i 2.93293e-10
r2_s1_n2_255_se 255_se 255_se_i 24231.3
c2_s1_n2_255_se 255_se 255_se_i 2.53213e-11
r1_s1_n1_184_se 184 184_se_i 1.04496e+06
c1_s1_n1_184_se 184 184_se_i 2.93293e-10
r2_s1_n1_184_se 184_se 184_se_i 24231.3
c2_s1_n1_184_se 184_se 184_se_i 2.53213e-11
r1_s1_n2_264_se 264 264_se_i 1.04496e+06
c1_s1_n2_264_se 264 264_se_i 2.93293e-10
r2_s1_n2_264_se 264_se 264_se_i 24231.3
c2_s1_n2_264_se 264_se 264_se_i 2.53213e-11
r1_s1_n1_185_se 185 185_se_i 1.04496e+06
c1_s1_n1_185_se 185 185_se_i 2.93293e-10
r2_s1_n1_185_se 185_se 185_se_i 24231.3
c2_s1_n1_185_se 185_se 185_se_i 2.53213e-11
r1_s1_n2_265_se 265 265_se_i 1.04496e+06
c1_s1_n2_265_se 265 265_se_i 2.93293e-10
r2_s1_n2_265_se 265_se 265_se_i 24231.3
c2_s1_n2_265_se 265_se 265_se_i 2.53213e-11
r1_s1_n1_186_se 186 186_se_i 1.04496e+06
c1_s1_n1_186_se 186 186_se_i 2.93293e-10
r2_s1_n1_186_se 186_se 186_se_i 24231.3
c2_s1_n1_186_se 186_se 186_se_i 2.53213e-11
r1_s1_n2_266_se 266 266_se_i 1.04496e+06
c1_s1_n2_266_se 266 266_se_i 2.93293e-10
r2_s1_n2_266_se 266_se 266_se_i 24231.3
c2_s1_n2_266_se 266_se 266_se_i 2.53213e-11
r1_s1_n1_187_se 187 187_se_i 1.04496e+06
c1_s1_n1_187_se 187 187_se_i 2.93293e-10
r2_s1_n1_187_se 187_se 187_se_i 24231.3
c2_s1_n1_187_se 187_se 187_se_i 2.53213e-11
r1_s1_n2_267_se 267 267_se_i 1.04496e+06
c1_s1_n2_267_se 267 267_se_i 2.93293e-10
r2_s1_n2_267_se 267_se 267_se_i 24231.3
c2_s1_n2_267_se 267_se 267_se_i 2.53213e-11
r1_s1_n1_188_se 188 188_se_i 1.04496e+06
c1_s1_n1_188_se 188 188_se_i 2.93293e-10
r2_s1_n1_188_se 188_se 188_se_i 24231.3
c2_s1_n1_188_se 188_se 188_se_i 2.53213e-11
r1_s1_n2_268_se 268 268_se_i 1.04496e+06
c1_s1_n2_268_se 268 268_se_i 2.93293e-10
r2_s1_n2_268_se 268_se 268_se_i 24231.3
c2_s1_n2_268_se 268_se 268_se_i 2.53213e-11
r1_s1_n1_189_se 189 189_se_i 1.04496e+06
c1_s1_n1_189_se 189 189_se_i 2.93293e-10
r2_s1_n1_189_se 189_se 189_se_i 24231.3
c2_s1_n1_189_se 189_se 189_se_i 2.53213e-11
r1_s1_n2_269_se 269 269_se_i 1.04496e+06
c1_s1_n2_269_se 269 269_se_i 2.93293e-10
r2_s1_n2_269_se 269_se 269_se_i 24231.3
c2_s1_n2_269_se 269_se 269_se_i 2.53213e-11
r1_s1_n1_190_se 190 190_se_i 1.04496e+06
c1_s1_n1_190_se 190 190_se_i 2.93293e-10
r2_s1_n1_190_se 190_se 190_se_i 24231.3
c2_s1_n1_190_se 190_se 190_se_i 2.53213e-11
r1_s1_n2_270_se 270 270_se_i 1.04496e+06
c1_s1_n2_270_se 270 270_se_i 2.93293e-10
r2_s1_n2_270_se 270_se 270_se_i 24231.3
c2_s1_n2_270_se 270_se 270_se_i 2.53213e-11
r1_s1_n1_191_se 191 191_se_i 1.04496e+06
c1_s1_n1_191_se 191 191_se_i 2.93293e-10
r2_s1_n1_191_se 191_se 191_se_i 24231.3
c2_s1_n1_191_se 191_se 191_se_i 2.53213e-11
r1_s1_n2_271_se 271 271_se_i 1.04496e+06
c1_s1_n2_271_se 271 271_se_i 2.93293e-10
r2_s1_n2_271_se 271_se 271_se_i 24231.3
c2_s1_n2_271_se 271_se 271_se_i 2.53213e-11
r1_s1_n1_200_se 200 200_se_i 1.04496e+06
c1_s1_n1_200_se 200 200_se_i 2.93293e-10
r2_s1_n1_200_se 200_se 200_se_i 24231.3
c2_s1_n1_200_se 200_se 200_se_i 2.53213e-11
r1_s1_n2_280_se 280 280_se_i 1.04496e+06
c1_s1_n2_280_se 280 280_se_i 2.93293e-10
r2_s1_n2_280_se 280_se 280_se_i 24231.3
c2_s1_n2_280_se 280_se 280_se_i 2.53213e-11
r1_s1_n1_201_se 201 201_se_i 1.04496e+06
c1_s1_n1_201_se 201 201_se_i 2.93293e-10
r2_s1_n1_201_se 201_se 201_se_i 24231.3
c2_s1_n1_201_se 201_se 201_se_i 2.53213e-11
r1_s1_n2_281_se 281 281_se_i 1.04496e+06
c1_s1_n2_281_se 281 281_se_i 2.93293e-10
r2_s1_n2_281_se 281_se 281_se_i 24231.3
c2_s1_n2_281_se 281_se 281_se_i 2.53213e-11
r1_s1_n1_202_se 202 202_se_i 1.04496e+06
c1_s1_n1_202_se 202 202_se_i 2.93293e-10
r2_s1_n1_202_se 202_se 202_se_i 24231.3
c2_s1_n1_202_se 202_se 202_se_i 2.53213e-11
r1_s1_n2_282_se 282 282_se_i 1.04496e+06
c1_s1_n2_282_se 282 282_se_i 2.93293e-10
r2_s1_n2_282_se 282_se 282_se_i 24231.3
c2_s1_n2_282_se 282_se 282_se_i 2.53213e-11
r1_s1_n1_203_se 203 203_se_i 1.04496e+06
c1_s1_n1_203_se 203 203_se_i 2.93293e-10
r2_s1_n1_203_se 203_se 203_se_i 24231.3
c2_s1_n1_203_se 203_se 203_se_i 2.53213e-11
r1_s1_n2_283_se 283 283_se_i 1.04496e+06
c1_s1_n2_283_se 283 283_se_i 2.93293e-10
r2_s1_n2_283_se 283_se 283_se_i 24231.3
c2_s1_n2_283_se 283_se 283_se_i 2.53213e-11
r1_s1_n1_204_se 204 204_se_i 1.04496e+06
c1_s1_n1_204_se 204 204_se_i 2.93293e-10
r2_s1_n1_204_se 204_se 204_se_i 24231.3
c2_s1_n1_204_se 204_se 204_se_i 2.53213e-11
r1_s1_n2_284_se 284 284_se_i 1.04496e+06
c1_s1_n2_284_se 284 284_se_i 2.93293e-10
r2_s1_n2_284_se 284_se 284_se_i 24231.3
c2_s1_n2_284_se 284_se 284_se_i 2.53213e-11
r1_s1_n1_205_se 205 205_se_i 1.04496e+06
c1_s1_n1_205_se 205 205_se_i 2.93293e-10
r2_s1_n1_205_se 205_se 205_se_i 24231.3
c2_s1_n1_205_se 205_se 205_se_i 2.53213e-11
r1_s1_n2_285_se 285 285_se_i 1.04496e+06
c1_s1_n2_285_se 285 285_se_i 2.93293e-10
r2_s1_n2_285_se 285_se 285_se_i 24231.3
c2_s1_n2_285_se 285_se 285_se_i 2.53213e-11
r1_s1_n1_206_se 206 206_se_i 1.04496e+06
c1_s1_n1_206_se 206 206_se_i 2.93293e-10
r2_s1_n1_206_se 206_se 206_se_i 24231.3
c2_s1_n1_206_se 206_se 206_se_i 2.53213e-11
r1_s1_n2_286_se 286 286_se_i 1.04496e+06
c1_s1_n2_286_se 286 286_se_i 2.93293e-10
r2_s1_n2_286_se 286_se 286_se_i 24231.3
c2_s1_n2_286_se 286_se 286_se_i 2.53213e-11
r1_s1_n1_207_se 207 207_se_i 1.04496e+06
c1_s1_n1_207_se 207 207_se_i 2.93293e-10
r2_s1_n1_207_se 207_se 207_se_i 24231.3
c2_s1_n1_207_se 207_se 207_se_i 2.53213e-11
r1_s1_n2_287_se 287 287_se_i 1.04496e+06
c1_s1_n2_287_se 287 287_se_i 2.93293e-10
r2_s1_n2_287_se 287_se 287_se_i 24231.3
c2_s1_n2_287_se 287_se 287_se_i 2.53213e-11
v_s1_n1_1 136_se 137_se dc 0 ac 0 0
v_s1_n2_1 216_se 217_se dc 0 ac 0 0
v_s1_n1_2 136_se 138_se dc 0 ac 0 0
v_s1_n2_2 216_se 218_se dc 0 ac 0 0
v_s1_n1_3 136_se 139_se dc 0 ac 0 0
v_s1_n2_3 216_se 219_se dc 0 ac 0 0
v_s1_n1_4 136_se 140_se dc 0 ac 0 0
v_s1_n2_4 216_se 220_se dc 0 ac 0 0
v_s1_n1_5 136_se 141_se dc 0 ac 0 0
v_s1_n2_5 216_se 221_se dc 0 ac 0 0
v_s1_n1_6 136_se 142_se dc 0 ac 0 0
v_s1_n2_6 216_se 222_se dc 0 ac 0 0
v_s1_n1_7 136_se 143_se dc 0 ac 0 0
v_s1_n2_7 216_se 223_se dc 0 ac 0 0
v_s1_n1_8 136_se 152_se dc 0 ac 0 0
v_s1_n2_8 216_se 232_se dc 0 ac 0 0
v_s1_n1_9 136_se 153_se dc 0 ac 0 0
v_s1_n2_9 216_se 233_se dc 0 ac 0 0
v_s1_n1_10 136_se 154_se dc 0 ac 0 0
v_s1_n2_10 216_se 234_se dc 0 ac 0 0
v_s1_n1_11 136_se 155_se dc 0 ac 0 0
v_s1_n2_11 216_se 235_se dc 0 ac 0 0
v_s1_n1_12 136_se 156_se dc 0 ac 0 0
v_s1_n2_12 216_se 236_se dc 0 ac 0 0
v_s1_n1_13 136_se 157_se dc 0 ac 0 0
v_s1_n2_13 216_se 237_se dc 0 ac 0 0
v_s1_n1_14 136_se 158_se dc 0 ac 0 0
v_s1_n2_14 216_se 238_se dc 0 ac 0 0
v_s1_n1_15 136_se 159_se dc 0 ac 0 0
v_s1_n2_15 216_se 239_se dc 0 ac 0 0
v_s1_n1_16 136_se 168_se dc 0 ac 0 0
v_s1_n2_16 216_se 248_se dc 0 ac 0 0
v_s1_n1_17 136_se 169_se dc 0 ac 0 0
v_s1_n2_17 216_se 249_se dc 0 ac 0 0
v_s1_n1_18 136_se 170_se dc 0 ac 0 0
v_s1_n2_18 216_se 250_se dc 0 ac 0 0
v_s1_n1_19 136_se 171_se dc 0 ac 0 0
v_s1_n2_19 216_se 251_se dc 0 ac 0 0
v_s1_n1_20 136_se 172_se dc 0 ac 0 0
v_s1_n2_20 216_se 252_se dc 0 ac 0 0
v_s1_n1_21 136_se 173_se dc 0 ac 0 0
v_s1_n2_21 216_se 253_se dc 0 ac 0 0
v_s1_n1_22 136_se 174_se dc 0 ac 0 0
v_s1_n2_22 216_se 254_se dc 0 ac 0 0
v_s1_n1_23 136_se 175_se dc 0 ac 0 0
v_s1_n2_23 216_se 255_se dc 0 ac 0 0
v_s1_n1_24 136_se 184_se dc 0 ac 0 0
v_s1_n2_24 216_se 264_se dc 0 ac 0 0
v_s1_n1_25 136_se 185_se dc 0 ac 0 0
v_s1_n2_25 216_se 265_se dc 0 ac 0 0
v_s1_n1_26 136_se 186_se dc 0 ac 0 0
v_s1_n2_26 216_se 266_se dc 0 ac 0 0
v_s1_n1_27 136_se 187_se dc 0 ac 0 0
v_s1_n2_27 216_se 267_se dc 0 ac 0 0
v_s1_n1_28 136_se 188_se dc 0 ac 0 0
v_s1_n2_28 216_se 268_se dc 0 ac 0 0
v_s1_n1_29 136_se 189_se dc 0 ac 0 0
v_s1_n2_29 216_se 269_se dc 0 ac 0 0
v_s1_n1_30 136_se 190_se dc 0 ac 0 0
v_s1_n2_30 216_se 270_se dc 0 ac 0 0
v_s1_n1_31 136_se 191_se dc 0 ac 0 0
v_s1_n2_31 216_se 271_se dc 0 ac 0 0
v_s1_n1_32 136_se 200_se dc 0 ac 0 0
v_s1_n2_32 216_se 280_se dc 0 ac 0 0
v_s1_n1_33 136_se 201_se dc 0 ac 0 0
v_s1_n2_33 216_se 281_se dc 0 ac 0 0
v_s1_n1_34 136_se 202_se dc 0 ac 0 0
v_s1_n2_34 216_se 282_se dc 0 ac 0 0
v_s1_n1_35 136_se 203_se dc 0 ac 0 0
v_s1_n2_35 216_se 283_se dc 0 ac 0 0
v_s1_n1_36 136_se 204_se dc 0 ac 0 0
v_s1_n2_36 216_se 284_se dc 0 ac 0 0
v_s1_n1_37 136_se 205_se dc 0 ac 0 0
v_s1_n2_37 216_se 285_se dc 0 ac 0 0
v_s1_n1_38 136_se 206_se dc 0 ac 0 0
v_s1_n2_38 216_se 286_se dc 0 ac 0 0
v_s1_n1_39 136_se 207_se dc 0 ac 0 0
v_s1_n2_39 216_se 287_se dc 0 ac 0 0
r1_s2_n1_296_se 296 296_se_i 1.04496e+06
c1_s2_n1_296_se 296 296_se_i 2.93293e-10
r2_s2_n1_296_se 296_se 296_se_i 24231.3
c2_s2_n1_296_se 296_se 296_se_i 2.53213e-11
r1_s2_n2_376_se 376 376_se_i 1.04496e+06
c1_s2_n2_376_se 376 376_se_i 2.93293e-10
r2_s2_n2_376_se 376_se 376_se_i 24231.3
c2_s2_n2_376_se 376_se 376_se_i 2.53213e-11
r1_s2_n1_297_se 297 297_se_i 1.04496e+06
c1_s2_n1_297_se 297 297_se_i 2.93293e-10
r2_s2_n1_297_se 297_se 297_se_i 24231.3
c2_s2_n1_297_se 297_se 297_se_i 2.53213e-11
r1_s2_n2_377_se 377 377_se_i 1.04496e+06
c1_s2_n2_377_se 377 377_se_i 2.93293e-10
r2_s2_n2_377_se 377_se 377_se_i 24231.3
c2_s2_n2_377_se 377_se 377_se_i 2.53213e-11
r1_s2_n1_298_se 298 298_se_i 1.04496e+06
c1_s2_n1_298_se 298 298_se_i 2.93293e-10
r2_s2_n1_298_se 298_se 298_se_i 24231.3
c2_s2_n1_298_se 298_se 298_se_i 2.53213e-11
r1_s2_n2_378_se 378 378_se_i 1.04496e+06
c1_s2_n2_378_se 378 378_se_i 2.93293e-10
r2_s2_n2_378_se 378_se 378_se_i 24231.3
c2_s2_n2_378_se 378_se 378_se_i 2.53213e-11
r1_s2_n1_299_se 299 299_se_i 1.04496e+06
c1_s2_n1_299_se 299 299_se_i 2.93293e-10
r2_s2_n1_299_se 299_se 299_se_i 24231.3
c2_s2_n1_299_se 299_se 299_se_i 2.53213e-11
r1_s2_n2_379_se 379 379_se_i 1.04496e+06
c1_s2_n2_379_se 379 379_se_i 2.93293e-10
r2_s2_n2_379_se 379_se 379_se_i 24231.3
c2_s2_n2_379_se 379_se 379_se_i 2.53213e-11
r1_s2_n1_300_se 300 300_se_i 1.04496e+06
c1_s2_n1_300_se 300 300_se_i 2.93293e-10
r2_s2_n1_300_se 300_se 300_se_i 24231.3
c2_s2_n1_300_se 300_se 300_se_i 2.53213e-11
r1_s2_n2_380_se 380 380_se_i 1.04496e+06
c1_s2_n2_380_se 380 380_se_i 2.93293e-10
r2_s2_n2_380_se 380_se 380_se_i 24231.3
c2_s2_n2_380_se 380_se 380_se_i 2.53213e-11
r1_s2_n1_301_se 301 301_se_i 1.04496e+06
c1_s2_n1_301_se 301 301_se_i 2.93293e-10
r2_s2_n1_301_se 301_se 301_se_i 24231.3
c2_s2_n1_301_se 301_se 301_se_i 2.53213e-11
r1_s2_n2_381_se 381 381_se_i 1.04496e+06
c1_s2_n2_381_se 381 381_se_i 2.93293e-10
r2_s2_n2_381_se 381_se 381_se_i 24231.3
c2_s2_n2_381_se 381_se 381_se_i 2.53213e-11
r1_s2_n1_302_se 302 302_se_i 1.04496e+06
c1_s2_n1_302_se 302 302_se_i 2.93293e-10
r2_s2_n1_302_se 302_se 302_se_i 24231.3
c2_s2_n1_302_se 302_se 302_se_i 2.53213e-11
r1_s2_n2_382_se 382 382_se_i 1.04496e+06
c1_s2_n2_382_se 382 382_se_i 2.93293e-10
r2_s2_n2_382_se 382_se 382_se_i 24231.3
c2_s2_n2_382_se 382_se 382_se_i 2.53213e-11
r1_s2_n1_303_se 303 303_se_i 1.04496e+06
c1_s2_n1_303_se 303 303_se_i 2.93293e-10
r2_s2_n1_303_se 303_se 303_se_i 24231.3
c2_s2_n1_303_se 303_se 303_se_i 2.53213e-11
r1_s2_n2_383_se 383 383_se_i 1.04496e+06
c1_s2_n2_383_se 383 383_se_i 2.93293e-10
r2_s2_n2_383_se 383_se 383_se_i 24231.3
c2_s2_n2_383_se 383_se 383_se_i 2.53213e-11
r1_s2_n1_312_se 312 312_se_i 1.04496e+06
c1_s2_n1_312_se 312 312_se_i 2.93293e-10
r2_s2_n1_312_se 312_se 312_se_i 24231.3
c2_s2_n1_312_se 312_se 312_se_i 2.53213e-11
r1_s2_n2_392_se 392 392_se_i 1.04496e+06
c1_s2_n2_392_se 392 392_se_i 2.93293e-10
r2_s2_n2_392_se 392_se 392_se_i 24231.3
c2_s2_n2_392_se 392_se 392_se_i 2.53213e-11
r1_s2_n1_313_se 313 313_se_i 1.04496e+06
c1_s2_n1_313_se 313 313_se_i 2.93293e-10
r2_s2_n1_313_se 313_se 313_se_i 24231.3
c2_s2_n1_313_se 313_se 313_se_i 2.53213e-11
r1_s2_n2_393_se 393 393_se_i 1.04496e+06
c1_s2_n2_393_se 393 393_se_i 2.93293e-10
r2_s2_n2_393_se 393_se 393_se_i 24231.3
c2_s2_n2_393_se 393_se 393_se_i 2.53213e-11
r1_s2_n1_314_se 314 314_se_i 1.04496e+06
c1_s2_n1_314_se 314 314_se_i 2.93293e-10
r2_s2_n1_314_se 314_se 314_se_i 24231.3
c2_s2_n1_314_se 314_se 314_se_i 2.53213e-11
r1_s2_n2_394_se 394 394_se_i 1.04496e+06
c1_s2_n2_394_se 394 394_se_i 2.93293e-10
r2_s2_n2_394_se 394_se 394_se_i 24231.3
c2_s2_n2_394_se 394_se 394_se_i 2.53213e-11
r1_s2_n1_315_se 315 315_se_i 1.04496e+06
c1_s2_n1_315_se 315 315_se_i 2.93293e-10
r2_s2_n1_315_se 315_se 315_se_i 24231.3
c2_s2_n1_315_se 315_se 315_se_i 2.53213e-11
r1_s2_n2_395_se 395 395_se_i 1.04496e+06
c1_s2_n2_395_se 395 395_se_i 2.93293e-10
r2_s2_n2_395_se 395_se 395_se_i 24231.3
c2_s2_n2_395_se 395_se 395_se_i 2.53213e-11
r1_s2_n1_316_se 316 316_se_i 1.04496e+06
c1_s2_n1_316_se 316 316_se_i 2.93293e-10
r2_s2_n1_316_se 316_se 316_se_i 24231.3
c2_s2_n1_316_se 316_se 316_se_i 2.53213e-11
r1_s2_n2_396_se 396 396_se_i 1.04496e+06
c1_s2_n2_396_se 396 396_se_i 2.93293e-10
r2_s2_n2_396_se 396_se 396_se_i 24231.3
c2_s2_n2_396_se 396_se 396_se_i 2.53213e-11
r1_s2_n1_317_se 317 317_se_i 1.04496e+06
c1_s2_n1_317_se 317 317_se_i 2.93293e-10
r2_s2_n1_317_se 317_se 317_se_i 24231.3
c2_s2_n1_317_se 317_se 317_se_i 2.53213e-11
r1_s2_n2_397_se 397 397_se_i 1.04496e+06
c1_s2_n2_397_se 397 397_se_i 2.93293e-10
r2_s2_n2_397_se 397_se 397_se_i 24231.3
c2_s2_n2_397_se 397_se 397_se_i 2.53213e-11
r1_s2_n1_318_se 318 318_se_i 1.04496e+06
c1_s2_n1_318_se 318 318_se_i 2.93293e-10
r2_s2_n1_318_se 318_se 318_se_i 24231.3
c2_s2_n1_318_se 318_se 318_se_i 2.53213e-11
r1_s2_n2_398_se 398 398_se_i 1.04496e+06
c1_s2_n2_398_se 398 398_se_i 2.93293e-10
r2_s2_n2_398_se 398_se 398_se_i 24231.3
c2_s2_n2_398_se 398_se 398_se_i 2.53213e-11
r1_s2_n1_319_se 319 319_se_i 1.04496e+06
c1_s2_n1_319_se 319 319_se_i 2.93293e-10
r2_s2_n1_319_se 319_se 319_se_i 24231.3
c2_s2_n1_319_se 319_se 319_se_i 2.53213e-11
r1_s2_n2_399_se 399 399_se_i 1.04496e+06
c1_s2_n2_399_se 399 399_se_i 2.93293e-10
r2_s2_n2_399_se 399_se 399_se_i 24231.3
c2_s2_n2_399_se 399_se 399_se_i 2.53213e-11
r1_s2_n1_328_se 328 328_se_i 1.04496e+06
c1_s2_n1_328_se 328 328_se_i 2.93293e-10
r2_s2_n1_328_se 328_se 328_se_i 24231.3
c2_s2_n1_328_se 328_se 328_se_i 2.53213e-11
r1_s2_n2_408_se 408 408_se_i 1.04496e+06
c1_s2_n2_408_se 408 408_se_i 2.93293e-10
r2_s2_n2_408_se 408_se 408_se_i 24231.3
c2_s2_n2_408_se 408_se 408_se_i 2.53213e-11
r1_s2_n1_329_se 329 329_se_i 1.04496e+06
c1_s2_n1_329_se 329 329_se_i 2.93293e-10
r2_s2_n1_329_se 329_se 329_se_i 24231.3
c2_s2_n1_329_se 329_se 329_se_i 2.53213e-11
r1_s2_n2_409_se 409 409_se_i 1.04496e+06
c1_s2_n2_409_se 409 409_se_i 2.93293e-10
r2_s2_n2_409_se 409_se 409_se_i 24231.3
c2_s2_n2_409_se 409_se 409_se_i 2.53213e-11
r1_s2_n1_330_se 330 330_se_i 1.04496e+06
c1_s2_n1_330_se 330 330_se_i 2.93293e-10
r2_s2_n1_330_se 330_se 330_se_i 24231.3
c2_s2_n1_330_se 330_se 330_se_i 2.53213e-11
r1_s2_n2_410_se 410 410_se_i 1.04496e+06
c1_s2_n2_410_se 410 410_se_i 2.93293e-10
r2_s2_n2_410_se 410_se 410_se_i 24231.3
c2_s2_n2_410_se 410_se 410_se_i 2.53213e-11
r1_s2_n1_331_se 331 331_se_i 1.04496e+06
c1_s2_n1_331_se 331 331_se_i 2.93293e-10
r2_s2_n1_331_se 331_se 331_se_i 24231.3
c2_s2_n1_331_se 331_se 331_se_i 2.53213e-11
r1_s2_n2_411_se 411 411_se_i 1.04496e+06
c1_s2_n2_411_se 411 411_se_i 2.93293e-10
r2_s2_n2_411_se 411_se 411_se_i 24231.3
c2_s2_n2_411_se 411_se 411_se_i 2.53213e-11
r1_s2_n1_332_se 332 332_se_i 1.04496e+06
c1_s2_n1_332_se 332 332_se_i 2.93293e-10
r2_s2_n1_332_se 332_se 332_se_i 24231.3
c2_s2_n1_332_se 332_se 332_se_i 2.53213e-11
r1_s2_n2_412_se 412 412_se_i 1.04496e+06
c1_s2_n2_412_se 412 412_se_i 2.93293e-10
r2_s2_n2_412_se 412_se 412_se_i 24231.3
c2_s2_n2_412_se 412_se 412_se_i 2.53213e-11
r1_s2_n1_333_se 333 333_se_i 1.04496e+06
c1_s2_n1_333_se 333 333_se_i 2.93293e-10
r2_s2_n1_333_se 333_se 333_se_i 24231.3
c2_s2_n1_333_se 333_se 333_se_i 2.53213e-11
r1_s2_n2_413_se 413 413_se_i 1.04496e+06
c1_s2_n2_413_se 413 413_se_i 2.93293e-10
r2_s2_n2_413_se 413_se 413_se_i 24231.3
c2_s2_n2_413_se 413_se 413_se_i 2.53213e-11
r1_s2_n1_334_se 334 334_se_i 1.04496e+06
c1_s2_n1_334_se 334 334_se_i 2.93293e-10
r2_s2_n1_334_se 334_se 334_se_i 24231.3
c2_s2_n1_334_se 334_se 334_se_i 2.53213e-11
r1_s2_n2_414_se 414 414_se_i 1.04496e+06
c1_s2_n2_414_se 414 414_se_i 2.93293e-10
r2_s2_n2_414_se 414_se 414_se_i 24231.3
c2_s2_n2_414_se 414_se 414_se_i 2.53213e-11
r1_s2_n1_335_se 335 335_se_i 1.04496e+06
c1_s2_n1_335_se 335 335_se_i 2.93293e-10
r2_s2_n1_335_se 335_se 335_se_i 24231.3
c2_s2_n1_335_se 335_se 335_se_i 2.53213e-11
r1_s2_n2_415_se 415 415_se_i 1.04496e+06
c1_s2_n2_415_se 415 415_se_i 2.93293e-10
r2_s2_n2_415_se 415_se 415_se_i 24231.3
c2_s2_n2_415_se 415_se 415_se_i 2.53213e-11
r1_s2_n1_344_se 344 344_se_i 1.04496e+06
c1_s2_n1_344_se 344 344_se_i 2.93293e-10
r2_s2_n1_344_se 344_se 344_se_i 24231.3
c2_s2_n1_344_se 344_se 344_se_i 2.53213e-11
r1_s2_n2_424_se 424 424_se_i 1.04496e+06
c1_s2_n2_424_se 424 424_se_i 2.93293e-10
r2_s2_n2_424_se 424_se 424_se_i 24231.3
c2_s2_n2_424_se 424_se 424_se_i 2.53213e-11
r1_s2_n1_345_se 345 345_se_i 1.04496e+06
c1_s2_n1_345_se 345 345_se_i 2.93293e-10
r2_s2_n1_345_se 345_se 345_se_i 24231.3
c2_s2_n1_345_se 345_se 345_se_i 2.53213e-11
r1_s2_n2_425_se 425 425_se_i 1.04496e+06
c1_s2_n2_425_se 425 425_se_i 2.93293e-10
r2_s2_n2_425_se 425_se 425_se_i 24231.3
c2_s2_n2_425_se 425_se 425_se_i 2.53213e-11
r1_s2_n1_346_se 346 346_se_i 1.04496e+06
c1_s2_n1_346_se 346 346_se_i 2.93293e-10
r2_s2_n1_346_se 346_se 346_se_i 24231.3
c2_s2_n1_346_se 346_se 346_se_i 2.53213e-11
r1_s2_n2_426_se 426 426_se_i 1.04496e+06
c1_s2_n2_426_se 426 426_se_i 2.93293e-10
r2_s2_n2_426_se 426_se 426_se_i 24231.3
c2_s2_n2_426_se 426_se 426_se_i 2.53213e-11
r1_s2_n1_347_se 347 347_se_i 1.04496e+06
c1_s2_n1_347_se 347 347_se_i 2.93293e-10
r2_s2_n1_347_se 347_se 347_se_i 24231.3
c2_s2_n1_347_se 347_se 347_se_i 2.53213e-11
r1_s2_n2_427_se 427 427_se_i 1.04496e+06
c1_s2_n2_427_se 427 427_se_i 2.93293e-10
r2_s2_n2_427_se 427_se 427_se_i 24231.3
c2_s2_n2_427_se 427_se 427_se_i 2.53213e-11
r1_s2_n1_348_se 348 348_se_i 1.04496e+06
c1_s2_n1_348_se 348 348_se_i 2.93293e-10
r2_s2_n1_348_se 348_se 348_se_i 24231.3
c2_s2_n1_348_se 348_se 348_se_i 2.53213e-11
r1_s2_n2_428_se 428 428_se_i 1.04496e+06
c1_s2_n2_428_se 428 428_se_i 2.93293e-10
r2_s2_n2_428_se 428_se 428_se_i 24231.3
c2_s2_n2_428_se 428_se 428_se_i 2.53213e-11
r1_s2_n1_349_se 349 349_se_i 1.04496e+06
c1_s2_n1_349_se 349 349_se_i 2.93293e-10
r2_s2_n1_349_se 349_se 349_se_i 24231.3
c2_s2_n1_349_se 349_se 349_se_i 2.53213e-11
r1_s2_n2_429_se 429 429_se_i 1.04496e+06
c1_s2_n2_429_se 429 429_se_i 2.93293e-10
r2_s2_n2_429_se 429_se 429_se_i 24231.3
c2_s2_n2_429_se 429_se 429_se_i 2.53213e-11
r1_s2_n1_350_se 350 350_se_i 1.04496e+06
c1_s2_n1_350_se 350 350_se_i 2.93293e-10
r2_s2_n1_350_se 350_se 350_se_i 24231.3
c2_s2_n1_350_se 350_se 350_se_i 2.53213e-11
r1_s2_n2_430_se 430 430_se_i 1.04496e+06
c1_s2_n2_430_se 430 430_se_i 2.93293e-10
r2_s2_n2_430_se 430_se 430_se_i 24231.3
c2_s2_n2_430_se 430_se 430_se_i 2.53213e-11
r1_s2_n1_351_se 351 351_se_i 1.04496e+06
c1_s2_n1_351_se 351 351_se_i 2.93293e-10
r2_s2_n1_351_se 351_se 351_se_i 24231.3
c2_s2_n1_351_se 351_se 351_se_i 2.53213e-11
r1_s2_n2_431_se 431 431_se_i 1.04496e+06
c1_s2_n2_431_se 431 431_se_i 2.93293e-10
r2_s2_n2_431_se 431_se 431_se_i 24231.3
c2_s2_n2_431_se 431_se 431_se_i 2.53213e-11
r1_s2_n1_360_se 360 360_se_i 1.04496e+06
c1_s2_n1_360_se 360 360_se_i 2.93293e-10
r2_s2_n1_360_se 360_se 360_se_i 24231.3
c2_s2_n1_360_se 360_se 360_se_i 2.53213e-11
r1_s2_n2_440_se 440 440_se_i 1.04496e+06
c1_s2_n2_440_se 440 440_se_i 2.93293e-10
r2_s2_n2_440_se 440_se 440_se_i 24231.3
c2_s2_n2_440_se 440_se 440_se_i 2.53213e-11
r1_s2_n1_361_se 361 361_se_i 1.04496e+06
c1_s2_n1_361_se 361 361_se_i 2.93293e-10
r2_s2_n1_361_se 361_se 361_se_i 24231.3
c2_s2_n1_361_se 361_se 361_se_i 2.53213e-11
r1_s2_n2_441_se 441 441_se_i 1.04496e+06
c1_s2_n2_441_se 441 441_se_i 2.93293e-10
r2_s2_n2_441_se 441_se 441_se_i 24231.3
c2_s2_n2_441_se 441_se 441_se_i 2.53213e-11
r1_s2_n1_362_se 362 362_se_i 1.04496e+06
c1_s2_n1_362_se 362 362_se_i 2.93293e-10
r2_s2_n1_362_se 362_se 362_se_i 24231.3
c2_s2_n1_362_se 362_se 362_se_i 2.53213e-11
r1_s2_n2_442_se 442 442_se_i 1.04496e+06
c1_s2_n2_442_se 442 442_se_i 2.93293e-10
r2_s2_n2_442_se 442_se 442_se_i 24231.3
c2_s2_n2_442_se 442_se 442_se_i 2.53213e-11
r1_s2_n1_363_se 363 363_se_i 1.04496e+06
c1_s2_n1_363_se 363 363_se_i 2.93293e-10
r2_s2_n1_363_se 363_se 363_se_i 24231.3
c2_s2_n1_363_se 363_se 363_se_i 2.53213e-11
r1_s2_n2_443_se 443 443_se_i 1.04496e+06
c1_s2_n2_443_se 443 443_se_i 2.93293e-10
r2_s2_n2_443_se 443_se 443_se_i 24231.3
c2_s2_n2_443_se 443_se 443_se_i 2.53213e-11
r1_s2_n1_364_se 364 364_se_i 1.04496e+06
c1_s2_n1_364_se 364 364_se_i 2.93293e-10
r2_s2_n1_364_se 364_se 364_se_i 24231.3
c2_s2_n1_364_se 364_se 364_se_i 2.53213e-11
r1_s2_n2_444_se 444 444_se_i 1.04496e+06
c1_s2_n2_444_se 444 444_se_i 2.93293e-10
r2_s2_n2_444_se 444_se 444_se_i 24231.3
c2_s2_n2_444_se 444_se 444_se_i 2.53213e-11
r1_s2_n1_365_se 365 365_se_i 1.04496e+06
c1_s2_n1_365_se 365 365_se_i 2.93293e-10
r2_s2_n1_365_se 365_se 365_se_i 24231.3
c2_s2_n1_365_se 365_se 365_se_i 2.53213e-11
r1_s2_n2_445_se 445 445_se_i 1.04496e+06
c1_s2_n2_445_se 445 445_se_i 2.93293e-10
r2_s2_n2_445_se 445_se 445_se_i 24231.3
c2_s2_n2_445_se 445_se 445_se_i 2.53213e-11
r1_s2_n1_366_se 366 366_se_i 1.04496e+06
c1_s2_n1_366_se 366 366_se_i 2.93293e-10
r2_s2_n1_366_se 366_se 366_se_i 24231.3
c2_s2_n1_366_se 366_se 366_se_i 2.53213e-11
r1_s2_n2_446_se 446 446_se_i 1.04496e+06
c1_s2_n2_446_se 446 446_se_i 2.93293e-10
r2_s2_n2_446_se 446_se 446_se_i 24231.3
c2_s2_n2_446_se 446_se 446_se_i 2.53213e-11
r1_s2_n1_367_se 367 367_se_i 1.04496e+06
c1_s2_n1_367_se 367 367_se_i 2.93293e-10
r2_s2_n1_367_se 367_se 367_se_i 24231.3
c2_s2_n1_367_se 367_se 367_se_i 2.53213e-11
r1_s2_n2_447_se 447 447_se_i 1.04496e+06
c1_s2_n2_447_se 447 447_se_i 2.93293e-10
r2_s2_n2_447_se 447_se 447_se_i 24231.3
c2_s2_n2_447_se 447_se 447_se_i 2.53213e-11
v_s2_n1_1 296_se 297_se dc 0 ac 0 0
v_s2_n2_1 376_se 377_se dc 0 ac 0 0
v_s2_n1_2 296_se 298_se dc 0 ac 0 0
v_s2_n2_2 376_se 378_se dc 0 ac 0 0
v_s2_n1_3 296_se 299_se dc 0 ac 0 0
v_s2_n2_3 376_se 379_se dc 0 ac 0 0
v_s2_n1_4 296_se 300_se dc 0 ac 0 0
v_s2_n2_4 376_se 380_se dc 0 ac 0 0
v_s2_n1_5 296_se 301_se dc 0 ac 0 0
v_s2_n2_5 376_se 381_se dc 0 ac 0 0
v_s2_n1_6 296_se 302_se dc 0 ac 0 0
v_s2_n2_6 376_se 382_se dc 0 ac 0 0
v_s2_n1_7 296_se 303_se dc 0 ac 0 0
v_s2_n2_7 376_se 383_se dc 0 ac 0 0
v_s2_n1_8 296_se 312_se dc 0 ac 0 0
v_s2_n2_8 376_se 392_se dc 0 ac 0 0
v_s2_n1_9 296_se 313_se dc 0 ac 0 0
v_s2_n2_9 376_se 393_se dc 0 ac 0 0
v_s2_n1_10 296_se 314_se dc 0 ac 0 0
v_s2_n2_10 376_se 394_se dc 0 ac 0 0
v_s2_n1_11 296_se 315_se dc 0 ac 0 0
v_s2_n2_11 376_se 395_se dc 0 ac 0 0
v_s2_n1_12 296_se 316_se dc 0 ac 0 0
v_s2_n2_12 376_se 396_se dc 0 ac 0 0
v_s2_n1_13 296_se 317_se dc 0 ac 0 0
v_s2_n2_13 376_se 397_se dc 0 ac 0 0
v_s2_n1_14 296_se 318_se dc 0 ac 0 0
v_s2_n2_14 376_se 398_se dc 0 ac 0 0
v_s2_n1_15 296_se 319_se dc 0 ac 0 0
v_s2_n2_15 376_se 399_se dc 0 ac 0 0
v_s2_n1_16 296_se 328_se dc 0 ac 0 0
v_s2_n2_16 376_se 408_se dc 0 ac 0 0
v_s2_n1_17 296_se 329_se dc 0 ac 0 0
v_s2_n2_17 376_se 409_se dc 0 ac 0 0
v_s2_n1_18 296_se 330_se dc 0 ac 0 0
v_s2_n2_18 376_se 410_se dc 0 ac 0 0
v_s2_n1_19 296_se 331_se dc 0 ac 0 0
v_s2_n2_19 376_se 411_se dc 0 ac 0 0
v_s2_n1_20 296_se 332_se dc 0 ac 0 0
v_s2_n2_20 376_se 412_se dc 0 ac 0 0
v_s2_n1_21 296_se 333_se dc 0 ac 0 0
v_s2_n2_21 376_se 413_se dc 0 ac 0 0
v_s2_n1_22 296_se 334_se dc 0 ac 0 0
v_s2_n2_22 376_se 414_se dc 0 ac 0 0
v_s2_n1_23 296_se 335_se dc 0 ac 0 0
v_s2_n2_23 376_se 415_se dc 0 ac 0 0
v_s2_n1_24 296_se 344_se dc 0 ac 0 0
v_s2_n2_24 376_se 424_se dc 0 ac 0 0
v_s2_n1_25 296_se 345_se dc 0 ac 0 0
v_s2_n2_25 376_se 425_se dc 0 ac 0 0
v_s2_n1_26 296_se 346_se dc 0 ac 0 0
v_s2_n2_26 376_se 426_se dc 0 ac 0 0
v_s2_n1_27 296_se 347_se dc 0 ac 0 0
v_s2_n2_27 376_se 427_se dc 0 ac 0 0
v_s2_n1_28 296_se 348_se dc 0 ac 0 0
v_s2_n2_28 376_se 428_se dc 0 ac 0 0
v_s2_n1_29 296_se 349_se dc 0 ac 0 0
v_s2_n2_29 376_se 429_se dc 0 ac 0 0
v_s2_n1_30 296_se 350_se dc 0 ac 0 0
v_s2_n2_30 376_se 430_se dc 0 ac 0 0
v_s2_n1_31 296_se 351_se dc 0 ac 0 0
v_s2_n2_31 376_se 431_se dc 0 ac 0 0
v_s2_n1_32 296_se 360_se dc 0 ac 0 0
v_s2_n2_32 376_se 440_se dc 0 ac 0 0
v_s2_n1_33 296_se 361_se dc 0 ac 0 0
v_s2_n2_33 376_se 441_se dc 0 ac 0 0
v_s2_n1_34 296_se 362_se dc 0 ac 0 0
v_s2_n2_34 376_se 442_se dc 0 ac 0 0
v_s2_n1_35 296_se 363_se dc 0 ac 0 0
v_s2_n2_35 376_se 443_se dc 0 ac 0 0
v_s2_n1_36 296_se 364_se dc 0 ac 0 0
v_s2_n2_36 376_se 444_se dc 0 ac 0 0
v_s2_n1_37 296_se 365_se dc 0 ac 0 0
v_s2_n2_37 376_se 445_se dc 0 ac 0 0
v_s2_n1_38 296_se 366_se dc 0 ac 0 0
v_s2_n2_38 376_se 446_se dc 0 ac 0 0
v_s2_n1_39 296_se 367_se dc 0 ac 0 0
v_s2_n2_39 376_se 447_se dc 0 ac 0 0
r1_i1_n1_56_se 56 56_se_i 1.04496e+06
c1_i1_n1_56_se 56 56_se_i 2.93293e-10
r2_i1_n1_56_se 56_se 56_se_i 24231.3
c2_i1_n1_56_se 56_se 56_se_i 2.53213e-11
r1_i1_n2_456_se 456 456_se_i 1.04496e+06
c1_i1_n2_456_se 456 456_se_i 2.93293e-10
r2_i1_n2_456_se 456_se 456_se_i 24231.3
c2_i1_n2_456_se 456_se 456_se_i 2.53213e-11
r1_i1_n1_57_se 57 57_se_i 1.04496e+06
c1_i1_n1_57_se 57 57_se_i 2.93293e-10
r2_i1_n1_57_se 57_se 57_se_i 24231.3
c2_i1_n1_57_se 57_se 57_se_i 2.53213e-11
r1_i1_n2_457_se 457 457_se_i 1.04496e+06
c1_i1_n2_457_se 457 457_se_i 2.93293e-10
r2_i1_n2_457_se 457_se 457_se_i 24231.3
c2_i1_n2_457_se 457_se 457_se_i 2.53213e-11
r1_i1_n1_58_se 58 58_se_i 1.04496e+06
c1_i1_n1_58_se 58 58_se_i 2.93293e-10
r2_i1_n1_58_se 58_se 58_se_i 24231.3
c2_i1_n1_58_se 58_se 58_se_i 2.53213e-11
r1_i1_n2_458_se 458 458_se_i 1.04496e+06
c1_i1_n2_458_se 458 458_se_i 2.93293e-10
r2_i1_n2_458_se 458_se 458_se_i 24231.3
c2_i1_n2_458_se 458_se 458_se_i 2.53213e-11
r1_i1_n1_59_se 59 59_se_i 1.04496e+06
c1_i1_n1_59_se 59 59_se_i 2.93293e-10
r2_i1_n1_59_se 59_se 59_se_i 24231.3
c2_i1_n1_59_se 59_se 59_se_i 2.53213e-11
r1_i1_n2_459_se 459 459_se_i 1.04496e+06
c1_i1_n2_459_se 459 459_se_i 2.93293e-10
r2_i1_n2_459_se 459_se 459_se_i 24231.3
c2_i1_n2_459_se 459_se 459_se_i 2.53213e-11
r1_i1_n1_60_se 60 60_se_i 1.04496e+06
c1_i1_n1_60_se 60 60_se_i 2.93293e-10
r2_i1_n1_60_se 60_se 60_se_i 24231.3
c2_i1_n1_60_se 60_se 60_se_i 2.53213e-11
r1_i1_n2_460_se 460 460_se_i 1.04496e+06
c1_i1_n2_460_se 460 460_se_i 2.93293e-10
r2_i1_n2_460_se 460_se 460_se_i 24231.3
c2_i1_n2_460_se 460_se 460_se_i 2.53213e-11
r1_i1_n1_61_se 61 61_se_i 1.04496e+06
c1_i1_n1_61_se 61 61_se_i 2.93293e-10
r2_i1_n1_61_se 61_se 61_se_i 24231.3
c2_i1_n1_61_se 61_se 61_se_i 2.53213e-11
r1_i1_n2_461_se 461 461_se_i 1.04496e+06
c1_i1_n2_461_se 461 461_se_i 2.93293e-10
r2_i1_n2_461_se 461_se 461_se_i 24231.3
c2_i1_n2_461_se 461_se 461_se_i 2.53213e-11
r1_i1_n1_62_se 62 62_se_i 1.04496e+06
c1_i1_n1_62_se 62 62_se_i 2.93293e-10
r2_i1_n1_62_se 62_se 62_se_i 24231.3
c2_i1_n1_62_se 62_se 62_se_i 2.53213e-11
r1_i1_n2_462_se 462 462_se_i 1.04496e+06
c1_i1_n2_462_se 462 462_se_i 2.93293e-10
r2_i1_n2_462_se 462_se 462_se_i 24231.3
c2_i1_n2_462_se 462_se 462_se_i 2.53213e-11
r1_i1_n1_63_se 63 63_se_i 1.04496e+06
c1_i1_n1_63_se 63 63_se_i 2.93293e-10
r2_i1_n1_63_se 63_se 63_se_i 24231.3
c2_i1_n1_63_se 63_se 63_se_i 2.53213e-11
r1_i1_n2_463_se 463 463_se_i 1.04496e+06
c1_i1_n2_463_se 463 463_se_i 2.93293e-10
r2_i1_n2_463_se 463_se 463_se_i 24231.3
c2_i1_n2_463_se 463_se 463_se_i 2.53213e-11
r1_i1_n1_72_se 72 72_se_i 1.04496e+06
c1_i1_n1_72_se 72 72_se_i 2.93293e-10
r2_i1_n1_72_se 72_se 72_se_i 24231.3
c2_i1_n1_72_se 72_se 72_se_i 2.53213e-11
r1_i1_n2_472_se 472 472_se_i 1.04496e+06
c1_i1_n2_472_se 472 472_se_i 2.93293e-10
r2_i1_n2_472_se 472_se 472_se_i 24231.3
c2_i1_n2_472_se 472_se 472_se_i 2.53213e-11
r1_i1_n1_73_se 73 73_se_i 1.04496e+06
c1_i1_n1_73_se 73 73_se_i 2.93293e-10
r2_i1_n1_73_se 73_se 73_se_i 24231.3
c2_i1_n1_73_se 73_se 73_se_i 2.53213e-11
r1_i1_n2_473_se 473 473_se_i 1.04496e+06
c1_i1_n2_473_se 473 473_se_i 2.93293e-10
r2_i1_n2_473_se 473_se 473_se_i 24231.3
c2_i1_n2_473_se 473_se 473_se_i 2.53213e-11
r1_i1_n1_74_se 74 74_se_i 1.04496e+06
c1_i1_n1_74_se 74 74_se_i 2.93293e-10
r2_i1_n1_74_se 74_se 74_se_i 24231.3
c2_i1_n1_74_se 74_se 74_se_i 2.53213e-11
r1_i1_n2_474_se 474 474_se_i 1.04496e+06
c1_i1_n2_474_se 474 474_se_i 2.93293e-10
r2_i1_n2_474_se 474_se 474_se_i 24231.3
c2_i1_n2_474_se 474_se 474_se_i 2.53213e-11
r1_i1_n1_75_se 75 75_se_i 1.04496e+06
c1_i1_n1_75_se 75 75_se_i 2.93293e-10
r2_i1_n1_75_se 75_se 75_se_i 24231.3
c2_i1_n1_75_se 75_se 75_se_i 2.53213e-11
r1_i1_n2_475_se 475 475_se_i 1.04496e+06
c1_i1_n2_475_se 475 475_se_i 2.93293e-10
r2_i1_n2_475_se 475_se 475_se_i 24231.3
c2_i1_n2_475_se 475_se 475_se_i 2.53213e-11
r1_i1_n1_76_se 76 76_se_i 1.04496e+06
c1_i1_n1_76_se 76 76_se_i 2.93293e-10
r2_i1_n1_76_se 76_se 76_se_i 24231.3
c2_i1_n1_76_se 76_se 76_se_i 2.53213e-11
r1_i1_n2_476_se 476 476_se_i 1.04496e+06
c1_i1_n2_476_se 476 476_se_i 2.93293e-10
r2_i1_n2_476_se 476_se 476_se_i 24231.3
c2_i1_n2_476_se 476_se 476_se_i 2.53213e-11
r1_i1_n1_77_se 77 77_se_i 1.04496e+06
c1_i1_n1_77_se 77 77_se_i 2.93293e-10
r2_i1_n1_77_se 77_se 77_se_i 24231.3
c2_i1_n1_77_se 77_se 77_se_i 2.53213e-11
r1_i1_n2_477_se 477 477_se_i 1.04496e+06
c1_i1_n2_477_se 477 477_se_i 2.93293e-10
r2_i1_n2_477_se 477_se 477_se_i 24231.3
c2_i1_n2_477_se 477_se 477_se_i 2.53213e-11
r1_i1_n1_78_se 78 78_se_i 1.04496e+06
c1_i1_n1_78_se 78 78_se_i 2.93293e-10
r2_i1_n1_78_se 78_se 78_se_i 24231.3
c2_i1_n1_78_se 78_se 78_se_i 2.53213e-11
r1_i1_n2_478_se 478 478_se_i 1.04496e+06
c1_i1_n2_478_se 478 478_se_i 2.93293e-10
r2_i1_n2_478_se 478_se 478_se_i 24231.3
c2_i1_n2_478_se 478_se 478_se_i 2.53213e-11
r1_i1_n1_79_se 79 79_se_i 1.04496e+06
c1_i1_n1_79_se 79 79_se_i 2.93293e-10
r2_i1_n1_79_se 79_se 79_se_i 24231.3
c2_i1_n1_79_se 79_se 79_se_i 2.53213e-11
r1_i1_n2_479_se 479 479_se_i 1.04496e+06
c1_i1_n2_479_se 479 479_se_i 2.93293e-10
r2_i1_n2_479_se 479_se 479_se_i 24231.3
c2_i1_n2_479_se 479_se 479_se_i 2.53213e-11
r1_i1_n1_88_se 88 88_se_i 1.04496e+06
c1_i1_n1_88_se 88 88_se_i 2.93293e-10
r2_i1_n1_88_se 88_se 88_se_i 24231.3
c2_i1_n1_88_se 88_se 88_se_i 2.53213e-11
r1_i1_n2_488_se 488 488_se_i 1.04496e+06
c1_i1_n2_488_se 488 488_se_i 2.93293e-10
r2_i1_n2_488_se 488_se 488_se_i 24231.3
c2_i1_n2_488_se 488_se 488_se_i 2.53213e-11
r1_i1_n1_89_se 89 89_se_i 1.04496e+06
c1_i1_n1_89_se 89 89_se_i 2.93293e-10
r2_i1_n1_89_se 89_se 89_se_i 24231.3
c2_i1_n1_89_se 89_se 89_se_i 2.53213e-11
r1_i1_n2_489_se 489 489_se_i 1.04496e+06
c1_i1_n2_489_se 489 489_se_i 2.93293e-10
r2_i1_n2_489_se 489_se 489_se_i 24231.3
c2_i1_n2_489_se 489_se 489_se_i 2.53213e-11
r1_i1_n1_90_se 90 90_se_i 1.04496e+06
c1_i1_n1_90_se 90 90_se_i 2.93293e-10
r2_i1_n1_90_se 90_se 90_se_i 24231.3
c2_i1_n1_90_se 90_se 90_se_i 2.53213e-11
r1_i1_n2_490_se 490 490_se_i 1.04496e+06
c1_i1_n2_490_se 490 490_se_i 2.93293e-10
r2_i1_n2_490_se 490_se 490_se_i 24231.3
c2_i1_n2_490_se 490_se 490_se_i 2.53213e-11
r1_i1_n1_91_se 91 91_se_i 1.04496e+06
c1_i1_n1_91_se 91 91_se_i 2.93293e-10
r2_i1_n1_91_se 91_se 91_se_i 24231.3
c2_i1_n1_91_se 91_se 91_se_i 2.53213e-11
r1_i1_n2_491_se 491 491_se_i 1.04496e+06
c1_i1_n2_491_se 491 491_se_i 2.93293e-10
r2_i1_n2_491_se 491_se 491_se_i 24231.3
c2_i1_n2_491_se 491_se 491_se_i 2.53213e-11
r1_i1_n1_92_se 92 92_se_i 1.04496e+06
c1_i1_n1_92_se 92 92_se_i 2.93293e-10
r2_i1_n1_92_se 92_se 92_se_i 24231.3
c2_i1_n1_92_se 92_se 92_se_i 2.53213e-11
r1_i1_n2_492_se 492 492_se_i 1.04496e+06
c1_i1_n2_492_se 492 492_se_i 2.93293e-10
r2_i1_n2_492_se 492_se 492_se_i 24231.3
c2_i1_n2_492_se 492_se 492_se_i 2.53213e-11
r1_i1_n1_93_se 93 93_se_i 1.04496e+06
c1_i1_n1_93_se 93 93_se_i 2.93293e-10
r2_i1_n1_93_se 93_se 93_se_i 24231.3
c2_i1_n1_93_se 93_se 93_se_i 2.53213e-11
r1_i1_n2_493_se 493 493_se_i 1.04496e+06
c1_i1_n2_493_se 493 493_se_i 2.93293e-10
r2_i1_n2_493_se 493_se 493_se_i 24231.3
c2_i1_n2_493_se 493_se 493_se_i 2.53213e-11
r1_i1_n1_94_se 94 94_se_i 1.04496e+06
c1_i1_n1_94_se 94 94_se_i 2.93293e-10
r2_i1_n1_94_se 94_se 94_se_i 24231.3
c2_i1_n1_94_se 94_se 94_se_i 2.53213e-11
r1_i1_n2_494_se 494 494_se_i 1.04496e+06
c1_i1_n2_494_se 494 494_se_i 2.93293e-10
r2_i1_n2_494_se 494_se 494_se_i 24231.3
c2_i1_n2_494_se 494_se 494_se_i 2.53213e-11
r1_i1_n1_95_se 95 95_se_i 1.04496e+06
c1_i1_n1_95_se 95 95_se_i 2.93293e-10
r2_i1_n1_95_se 95_se 95_se_i 24231.3
c2_i1_n1_95_se 95_se 95_se_i 2.53213e-11
r1_i1_n2_495_se 495 495_se_i 1.04496e+06
c1_i1_n2_495_se 495 495_se_i 2.93293e-10
r2_i1_n2_495_se 495_se 495_se_i 24231.3
c2_i1_n2_495_se 495_se 495_se_i 2.53213e-11
r1_i1_n1_104_se 104 104_se_i 1.04496e+06
c1_i1_n1_104_se 104 104_se_i 2.93293e-10
r2_i1_n1_104_se 104_se 104_se_i 24231.3
c2_i1_n1_104_se 104_se 104_se_i 2.53213e-11
r1_i1_n2_504_se 504 504_se_i 1.04496e+06
c1_i1_n2_504_se 504 504_se_i 2.93293e-10
r2_i1_n2_504_se 504_se 504_se_i 24231.3
c2_i1_n2_504_se 504_se 504_se_i 2.53213e-11
r1_i1_n1_105_se 105 105_se_i 1.04496e+06
c1_i1_n1_105_se 105 105_se_i 2.93293e-10
r2_i1_n1_105_se 105_se 105_se_i 24231.3
c2_i1_n1_105_se 105_se 105_se_i 2.53213e-11
r1_i1_n2_505_se 505 505_se_i 1.04496e+06
c1_i1_n2_505_se 505 505_se_i 2.93293e-10
r2_i1_n2_505_se 505_se 505_se_i 24231.3
c2_i1_n2_505_se 505_se 505_se_i 2.53213e-11
r1_i1_n1_106_se 106 106_se_i 1.04496e+06
c1_i1_n1_106_se 106 106_se_i 2.93293e-10
r2_i1_n1_106_se 106_se 106_se_i 24231.3
c2_i1_n1_106_se 106_se 106_se_i 2.53213e-11
r1_i1_n2_506_se 506 506_se_i 1.04496e+06
c1_i1_n2_506_se 506 506_se_i 2.93293e-10
r2_i1_n2_506_se 506_se 506_se_i 24231.3
c2_i1_n2_506_se 506_se 506_se_i 2.53213e-11
r1_i1_n1_107_se 107 107_se_i 1.04496e+06
c1_i1_n1_107_se 107 107_se_i 2.93293e-10
r2_i1_n1_107_se 107_se 107_se_i 24231.3
c2_i1_n1_107_se 107_se 107_se_i 2.53213e-11
r1_i1_n2_507_se 507 507_se_i 1.04496e+06
c1_i1_n2_507_se 507 507_se_i 2.93293e-10
r2_i1_n2_507_se 507_se 507_se_i 24231.3
c2_i1_n2_507_se 507_se 507_se_i 2.53213e-11
r1_i1_n1_108_se 108 108_se_i 1.04496e+06
c1_i1_n1_108_se 108 108_se_i 2.93293e-10
r2_i1_n1_108_se 108_se 108_se_i 24231.3
c2_i1_n1_108_se 108_se 108_se_i 2.53213e-11
r1_i1_n2_508_se 508 508_se_i 1.04496e+06
c1_i1_n2_508_se 508 508_se_i 2.93293e-10
r2_i1_n2_508_se 508_se 508_se_i 24231.3
c2_i1_n2_508_se 508_se 508_se_i 2.53213e-11
r1_i1_n1_109_se 109 109_se_i 1.04496e+06
c1_i1_n1_109_se 109 109_se_i 2.93293e-10
r2_i1_n1_109_se 109_se 109_se_i 24231.3
c2_i1_n1_109_se 109_se 109_se_i 2.53213e-11
r1_i1_n2_509_se 509 509_se_i 1.04496e+06
c1_i1_n2_509_se 509 509_se_i 2.93293e-10
r2_i1_n2_509_se 509_se 509_se_i 24231.3
c2_i1_n2_509_se 509_se 509_se_i 2.53213e-11
r1_i1_n1_110_se 110 110_se_i 1.04496e+06
c1_i1_n1_110_se 110 110_se_i 2.93293e-10
r2_i1_n1_110_se 110_se 110_se_i 24231.3
c2_i1_n1_110_se 110_se 110_se_i 2.53213e-11
r1_i1_n2_510_se 510 510_se_i 1.04496e+06
c1_i1_n2_510_se 510 510_se_i 2.93293e-10
r2_i1_n2_510_se 510_se 510_se_i 24231.3
c2_i1_n2_510_se 510_se 510_se_i 2.53213e-11
r1_i1_n1_111_se 111 111_se_i 1.04496e+06
c1_i1_n1_111_se 111 111_se_i 2.93293e-10
r2_i1_n1_111_se 111_se 111_se_i 24231.3
c2_i1_n1_111_se 111_se 111_se_i 2.53213e-11
r1_i1_n2_511_se 511 511_se_i 1.04496e+06
c1_i1_n2_511_se 511 511_se_i 2.93293e-10
r2_i1_n2_511_se 511_se 511_se_i 24231.3
c2_i1_n2_511_se 511_se 511_se_i 2.53213e-11
r1_i1_n1_120_se 120 120_se_i 1.04496e+06
c1_i1_n1_120_se 120 120_se_i 2.93293e-10
r2_i1_n1_120_se 120_se 120_se_i 24231.3
c2_i1_n1_120_se 120_se 120_se_i 2.53213e-11
r1_i1_n2_520_se 520 520_se_i 1.04496e+06
c1_i1_n2_520_se 520 520_se_i 2.93293e-10
r2_i1_n2_520_se 520_se 520_se_i 24231.3
c2_i1_n2_520_se 520_se 520_se_i 2.53213e-11
r1_i1_n1_121_se 121 121_se_i 1.04496e+06
c1_i1_n1_121_se 121 121_se_i 2.93293e-10
r2_i1_n1_121_se 121_se 121_se_i 24231.3
c2_i1_n1_121_se 121_se 121_se_i 2.53213e-11
r1_i1_n2_521_se 521 521_se_i 1.04496e+06
c1_i1_n2_521_se 521 521_se_i 2.93293e-10
r2_i1_n2_521_se 521_se 521_se_i 24231.3
c2_i1_n2_521_se 521_se 521_se_i 2.53213e-11
r1_i1_n1_122_se 122 122_se_i 1.04496e+06
c1_i1_n1_122_se 122 122_se_i 2.93293e-10
r2_i1_n1_122_se 122_se 122_se_i 24231.3
c2_i1_n1_122_se 122_se 122_se_i 2.53213e-11
r1_i1_n2_522_se 522 522_se_i 1.04496e+06
c1_i1_n2_522_se 522 522_se_i 2.93293e-10
r2_i1_n2_522_se 522_se 522_se_i 24231.3
c2_i1_n2_522_se 522_se 522_se_i 2.53213e-11
r1_i1_n1_123_se 123 123_se_i 1.04496e+06
c1_i1_n1_123_se 123 123_se_i 2.93293e-10
r2_i1_n1_123_se 123_se 123_se_i 24231.3
c2_i1_n1_123_se 123_se 123_se_i 2.53213e-11
r1_i1_n2_523_se 523 523_se_i 1.04496e+06
c1_i1_n2_523_se 523 523_se_i 2.93293e-10
r2_i1_n2_523_se 523_se 523_se_i 24231.3
c2_i1_n2_523_se 523_se 523_se_i 2.53213e-11
r1_i1_n1_124_se 124 124_se_i 1.04496e+06
c1_i1_n1_124_se 124 124_se_i 2.93293e-10
r2_i1_n1_124_se 124_se 124_se_i 24231.3
c2_i1_n1_124_se 124_se 124_se_i 2.53213e-11
r1_i1_n2_524_se 524 524_se_i 1.04496e+06
c1_i1_n2_524_se 524 524_se_i 2.93293e-10
r2_i1_n2_524_se 524_se 524_se_i 24231.3
c2_i1_n2_524_se 524_se 524_se_i 2.53213e-11
r1_i1_n1_125_se 125 125_se_i 1.04496e+06
c1_i1_n1_125_se 125 125_se_i 2.93293e-10
r2_i1_n1_125_se 125_se 125_se_i 24231.3
c2_i1_n1_125_se 125_se 125_se_i 2.53213e-11
r1_i1_n2_525_se 525 525_se_i 1.04496e+06
c1_i1_n2_525_se 525 525_se_i 2.93293e-10
r2_i1_n2_525_se 525_se 525_se_i 24231.3
c2_i1_n2_525_se 525_se 525_se_i 2.53213e-11
r1_i1_n1_126_se 126 126_se_i 1.04496e+06
c1_i1_n1_126_se 126 126_se_i 2.93293e-10
r2_i1_n1_126_se 126_se 126_se_i 24231.3
c2_i1_n1_126_se 126_se 126_se_i 2.53213e-11
r1_i1_n2_526_se 526 526_se_i 1.04496e+06
c1_i1_n2_526_se 526 526_se_i 2.93293e-10
r2_i1_n2_526_se 526_se 526_se_i 24231.3
c2_i1_n2_526_se 526_se 526_se_i 2.53213e-11
r1_i1_n1_127_se 127 127_se_i 1.04496e+06
c1_i1_n1_127_se 127 127_se_i 2.93293e-10
r2_i1_n1_127_se 127_se 127_se_i 24231.3
c2_i1_n1_127_se 127_se 127_se_i 2.53213e-11
r1_i1_n2_527_se 527 527_se_i 1.04496e+06
c1_i1_n2_527_se 527 527_se_i 2.93293e-10
r2_i1_n2_527_se 527_se 527_se_i 24231.3
c2_i1_n2_527_se 527_se 527_se_i 2.53213e-11
v_i1_n1_1_se 56_se 57_se dc 0 ac 0 0
v_i1_n2_2_se 456_se 457_se dc 0 ac 0 0
v_i1_n1_3_se 56_se 58_se dc 0 ac 0 0
v_i1_n2_4_se 456_se 458_se dc 0 ac 0 0
v_i1_n1_5_se 56_se 59_se dc 0 ac 0 0
v_i1_n2_6_se 456_se 459_se dc 0 ac 0 0
v_i1_n1_7_se 56_se 60_se dc 0 ac 0 0
v_i1_n2_8_se 456_se 460_se dc 0 ac 0 0
v_i1_n1_9_se 56_se 61_se dc 0 ac 0 0
v_i1_n2_10_se 456_se 461_se dc 0 ac 0 0
v_i1_n1_11_se 56_se 62_se dc 0 ac 0 0
v_i1_n2_12_se 456_se 462_se dc 0 ac 0 0
v_i1_n1_13_se 56_se 63_se dc 0 ac 0 0
v_i1_n2_14_se 456_se 463_se dc 0 ac 0 0
v_i1_n1_15_se 56_se 72_se dc 0 ac 0 0
v_i1_n2_16_se 456_se 472_se dc 0 ac 0 0
v_i1_n1_17_se 56_se 73_se dc 0 ac 0 0
v_i1_n2_18_se 456_se 473_se dc 0 ac 0 0
v_i1_n1_19_se 56_se 74_se dc 0 ac 0 0
v_i1_n2_20_se 456_se 474_se dc 0 ac 0 0
v_i1_n1_21_se 56_se 75_se dc 0 ac 0 0
v_i1_n2_22_se 456_se 475_se dc 0 ac 0 0
v_i1_n1_23_se 56_se 76_se dc 0 ac 0 0
v_i1_n2_24_se 456_se 476_se dc 0 ac 0 0
v_i1_n1_25_se 56_se 77_se dc 0 ac 0 0
v_i1_n2_26_se 456_se 477_se dc 0 ac 0 0
v_i1_n1_27_se 56_se 78_se dc 0 ac 0 0
v_i1_n2_28_se 456_se 478_se dc 0 ac 0 0
v_i1_n1_29_se 56_se 79_se dc 0 ac 0 0
v_i1_n2_30_se 456_se 479_se dc 0 ac 0 0
v_i1_n1_31_se 56_se 88_se dc 0 ac 0 0
v_i1_n2_32_se 456_se 488_se dc 0 ac 0 0
v_i1_n1_33_se 56_se 89_se dc 0 ac 0 0
v_i1_n2_34_se 456_se 489_se dc 0 ac 0 0
v_i1_n1_35_se 56_se 90_se dc 0 ac 0 0
v_i1_n2_36_se 456_se 490_se dc 0 ac 0 0
v_i1_n1_37_se 56_se 91_se dc 0 ac 0 0
v_i1_n2_38_se 456_se 491_se dc 0 ac 0 0
v_i1_n1_39_se 56_se 92_se dc 0 ac 0 0
v_i1_n2_40_se 456_se 492_se dc 0 ac 0 0
v_i1_n1_41_se 56_se 93_se dc 0 ac 0 0
v_i1_n2_42_se 456_se 493_se dc 0 ac 0 0
v_i1_n1_43_se 56_se 94_se dc 0 ac 0 0
v_i1_n2_44_se 456_se 494_se dc 0 ac 0 0
v_i1_n1_45_se 56_se 95_se dc 0 ac 0 0
v_i1_n2_46_se 456_se 495_se dc 0 ac 0 0
v_i1_n1_47_se 56_se 104_se dc 0 ac 0 0
v_i1_n2_48_se 456_se 504_se dc 0 ac 0 0
v_i1_n1_49_se 56_se 105_se dc 0 ac 0 0
v_i1_n2_50_se 456_se 505_se dc 0 ac 0 0
v_i1_n1_51_se 56_se 106_se dc 0 ac 0 0
v_i1_n2_52_se 456_se 506_se dc 0 ac 0 0
v_i1_n1_53_se 56_se 107_se dc 0 ac 0 0
v_i1_n2_54_se 456_se 507_se dc 0 ac 0 0
v_i1_n1_55_se 56_se 108_se dc 0 ac 0 0
v_i1_n2_56_se 456_se 508_se dc 0 ac 0 0
v_i1_n1_57_se 56_se 109_se dc 0 ac 0 0
v_i1_n2_58_se 456_se 509_se dc 0 ac 0 0
v_i1_n1_59_se 56_se 110_se dc 0 ac 0 0
v_i1_n2_60_se 456_se 510_se dc 0 ac 0 0
v_i1_n1_61_se 56_se 111_se dc 0 ac 0 0
v_i1_n2_62_se 456_se 511_se dc 0 ac 0 0
v_i1_n1_63_se 56_se 120_se dc 0 ac 0 0
v_i1_n2_64_se 456_se 520_se dc 0 ac 0 0
v_i1_n1_65_se 56_se 121_se dc 0 ac 0 0
v_i1_n2_66_se 456_se 521_se dc 0 ac 0 0
v_i1_n1_67_se 56_se 122_se dc 0 ac 0 0
v_i1_n2_68_se 456_se 522_se dc 0 ac 0 0
v_i1_n1_69_se 56_se 123_se dc 0 ac 0 0
v_i1_n2_70_se 456_se 523_se dc 0 ac 0 0
v_i1_n1_71_se 56_se 124_se dc 0 ac 0 0
v_i1_n2_72_se 456_se 524_se dc 0 ac 0 0
v_i1_n1_73_se 56_se 125_se dc 0 ac 0 0
v_i1_n2_74_se 456_se 525_se dc 0 ac 0 0
v_i1_n1_75_se 56_se 126_se dc 0 ac 0 0
v_i1_n2_76_se 456_se 526_se dc 0 ac 0 0
v_i1_n1_77_se 56_se 127_se dc 0 ac 0 0
v_i1_n2_78_se 456_se 527_se dc 0 ac 0 0
i1 56_se 456_se dc 0 ac 0.0005 0
vgnd 0 456_se dc 0 ac 0 0
.ac oct 1 10000 10000
.options reltol=0.001 abstol=1e-06 Noopiter GminSteps=0
.backanno
.end
